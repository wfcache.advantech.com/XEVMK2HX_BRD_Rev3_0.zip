# Allegro board 19C2830503-01-JOB.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SOC_RESETSTATZ: length 170.2
  TOP w0.102: v2(69.93,97.99) 69.52,97.58 U24.AC5
  L5 w0.114: v1(103.94,158.31) 103.17,159.09 93.62,159.09 91.25,156.72 81.86,156.72 77.16,152.01 77.16,151 74.83,148.67 74.83,146.96 73.53,145.67 73.05,145.67 71.79,144.41 71.79,137.18 71.25,136.64 71.25,134.37 72.46,133.15 72.46,127.96 73.2,127.22 73.2,113.82 72.87,113.5 72.87,104.86 70.4,102.4 70.4,98.47 v2(69.93,97.99)
  L10 w0.114: v1(103.94,158.31) 104.95,157.3 104.95,154.1 107.23,151.82 109.5,151.82 109.88,152.2 125.52,152.2 127.77,149.96 137.75,149.96 141.78,145.92 141.78,144.98 143.22,143.55 144.65,143.55 146.06,142.14 156.61,142.14 159.26,144.78 161.11,144.78 161.63,144.26 170.4,144.26 170.71,143.94 v1(171.58,143.94)
  BOTTOM w0.127: U47.28 103.78,158.47 v1(103.94,158.31) ; R533.1 171.96,144.32 v1(171.58,143.94)
SOC_RESETZ: length 132.3
  TOP w0.102: U24.AD2 68.52,100.44 68.05,100.91 v2(68.05,100.92)
  L5 w0.114: v1(100.08,160.9) 100,160.83 93.53,160.83 92.14,159.44 60.25,159.44 52.7,151.89 48.51,151.89 46.74,150.11 46.74,148.5 49.56,145.68 49.56,143.59 50.49,142.65 51.88,142.65 54.25,140.28 54.25,140.23 54.5,139.97 54.57,139.97 54.57,139.74 55.34,138.97 55.34,138.56 55.63,138.27 55.85,138.05 57.4,138.05 60.96,134.49 62.1,134.49 64.26,132.33 64.26,122.81 62.22,120.76 62.22,116.69 64.38,114.53 64.38,112.15 65.41,111.12 65.41,108.13 v1(65.91,107.62)
  BOTTOM w0.102: 69.56,104.01 69.56,102.44 v2(68.05,100.92) 68.05,100.56 66.55,99.06 R620.2
  BOTTOM w0.127: v1(65.91,107.62) 65.91,107.62 C810.2 C808.1 C809.1 69.56,107.28 69.56,104.01 ; v1(100.08,160.9) 99.9,160.9 97.56,163.25 U47.7
SOC_RS232_RX: length 25.9
  TOP w0.127: v1(155.45,114.3) 155.32,114.43 155.32,116.71 155.13,116.9 154.24,116.9 153.93,117.21 U18.8
  BOTTOM w0.127: v1(155.45,114.3) 157.19,114.3 159.77,116.88 159.77,119.88 160.53,120.64 160.53,126.37 164.72,130.56 SOC.4
SOC_RS232_TX: length 21.5
  TOP w0.127: SOC.3 161.67,128.14 159.69,126.16 159.69,120.17 159.26,119.74 159.26,116.61 159.13,116.48 159.13,116.48 158.43,115.78 158.43,115.78 156.54,113.89 U18.13
SOC_SCL0: length 72.7
  TOP w0.102: v2(79.02,100.92) U24.N1
  TOP w0.127: v1(127.56,100.97) EEPROM1.6
  L10 w0.114: v2(79.02,100.92) 83.2,105.1 83.2,106.14 85.8,108.74 92.08,108.74 97.64,114.3 104.79,114.3 105.23,113.87 115.37,113.87 115.54,113.69 119.43,113.69 119.67,113.45 126.22,113.45 128.33,111.34 128.33,105.82 v1(127.91,105.41) 127.99,105.33 127.99,101.4 v1(127.56,100.97)
  BOTTOM w0.127: v1(127.91,105.41) 127.66,105.66 U58.2 125.8,105.66 R610.2
SOC_SCL1: length 177.1
  TOP w0.102: U24.N4 79.52,98.29 v2(79.98,97.82)
  TOP w0.127: U34.2 133.86,50.86 R429.2 134.86,49.86 135.92,49.86 136.45,50.39 136.45,55.42 v1(136.91,55.88)
  L3 w0.114: v1(100.52,153.8) 100.52,153.76 102.41,151.87 102.41,145.36 105.94,141.83 105.94,140.84 111.39,135.4 111.39,134.69 115.89,130.19 115.89,128.67 116.61,127.94 116.61,117.38 117.97,116.02 117.97,115.61 121.22,112.36 121.63,112.36 v1(122.16,111.83)
  L10 w0.102: v2(79.98,97.82) 81.47,99.3 81.94,99.3 83.31,100.68 83.31,100.76 86.57,104.01
  L10 w0.114: v1(136.91,55.88) 134.69,58.1 134.69,76.51 125.08,86.13 125.08,108.92 v1(122.16,111.83) 119.75,111.83 118.42,110.5 116.39,110.5 115.6,111.29 103.46,111.29 101.72,113.03 98.27,113.03 91.55,106.31 88.74,106.31 86.68,104.25 86.68,104.12 86.57,104.01
  BOTTOM w0.127: v1(100.52,153.8) 101.48,152.84 U50.7
SOC_SCL2: length 48.9
  TOP w0.102: U24.P4 v2(79.02,97.92)
  L8 w0.114: v1(81.55,123.64) 80.71,123.64 77.36,120.28 77.36,118.13 75.59,116.36 75.59,113.68 74.63,112.71 74.63,110.64 75.18,110.08 v1(75.18,109.98)
  L10 w0.102: 73.23,104.01 73.23,103.7 72.64,103.11 72.64,100.71 72.99,100.36 75.34,100.36 75.56,100.13 75.56,99.62 75.67,99.52 77.11,99.52 77.55,99.08 77.55,97.85 77.86,97.54 78.64,97.54 v2(79.02,97.92)
  L10 w0.114: 73.23,104.01 73.23,108.03 arc(73.77,109.34) 75.08,109.88 v1(75.18,109.98)
  BOTTOM w0.127: U54.2 78.69,126.67 79.12,126.24 R570.2 82.68,126.24 83.22,126.78 83.67,126.78 83.89,126.56 83.89,125.36 83.5,124.97 82.04,124.97 81.55,124.48 v1(81.55,123.64)
SOC_SCL_RTM: length 10.8
  BOTTOM w0.127: J1.D2 16.11,116.9 16.48,116.9 17.36,116.02 17.36,114.69 20.95,111.1 R536.1
SOC_SDA0: length 72.7
  TOP w0.102: v2(79.02,98.96) 78.98,98.96 U24.P3
  TOP w0.127: EEPROM1.5 v1(127.56,102.24)
  L10 w0.114: v2(79.02,98.96) 78.68,99.3 78.68,100.19 79.02,100.54 79.18,100.54 83.44,104.8 83.44,106.04 85.86,108.46 92.22,108.46 97.81,114.05 104.71,114.05 105.15,113.61 115.29,113.61 115.44,113.45 119.33,113.45 119.57,113.21 126.12,113.21 127.89,111.44 v1(127.89,106.55) 127.89,106.35 127.48,105.94 127.48,102.31 v1(127.56,102.24)
  BOTTOM w0.127: R604.2 125.55,106.93 U58.3 127.51,106.93 v1(127.89,106.55)
SOC_SDA1: length 173.6
  TOP w0.102: U24.N2 79.52,100.34 v2(80.01,99.85)
  TOP w0.127: v1(136.91,56.54) 135.69,55.32 135.69,53.17 135.02,52.51 134.99,52.51 R422.2 134.25,51.77 133.6,51.77 133.24,52.13 U34.3
  L3 w0.114: v1(101.19,153.8) 102.64,152.35 102.64,151.98 102.65,151.97 102.65,145.46 106.18,141.93 106.18,140.94 111.63,135.5 111.63,134.79 117.04,129.38 117.04,117.3 118.21,116.12 118.21,115.71 121.32,112.6 122.22,112.6 v1(122.94,111.89)
  L10 w0.102: v2(80.01,99.85) 80.62,100.46 82.42,100.46 82.98,101.02
  L10 w0.114: 82.98,101.02 82.98,101.4 88.27,106.68 91.58,106.68 98.17,113.27 101.82,113.27 103.56,111.53 115.7,111.53 116.49,110.75 118.32,110.75 119.84,112.27 122.56,112.27 122.94,111.89 v1(122.94,111.89) 122.94,111.89 125.35,109.48 125.35,86.36 134.93,76.78 134.93,58.2 136.59,56.54 v1(136.91,56.54)
  BOTTOM w0.127: U50.8 101.5,153.49 v1(101.19,153.8)
SOC_SDA2: length 51.8
  TOP w0.102: U24.N3 v2(80.02,98.92)
  L8 w0.114: v1(82.04,124.08) 80.77,124.08 77.12,120.42 77.12,118.27 75.35,116.5 75.35,113.78 74.24,112.67 74.24,111.3 v1(73.56,110.62)
  L10 w0.102: v2(80.02,98.92) 80.02,98.79 79.5,98.27 79.5,97.87 78.97,97.34 76.96,97.34 76.56,97.74 76.56,99.06 76.3,99.31 75.58,99.31 75.38,99.52 72.76,99.52 72.43,99.85 72.43,103.28 72.8,103.64 72.8,104.01
  L10 w0.114: v1(73.56,110.62) 73.36,110.62 72.8,110.06 72.8,104.01
  BOTTOM w0.127: U54.3 79.96,126.67 80.14,126.49 82.04,126.49 82.63,127.08 R572.2 82.68,127.63 83.22,127.09 84.4,127.09 84.65,126.83 84.65,125.05 84.19,124.59 82.55,124.59 v1(82.04,124.08)
SOC_SDA_RTM: length 8
  BOTTOM w0.127: R541.1 19.56,111.81 17.6,113.77 16.74,113.77 J1.D1
SOC_SGMII0_RXN: length 149.9
  BOTTOM w0.102: PHY1.A8 138.15,71.2 arc(138.12,71.27) 138.05,71.3 137.18,71.3 arc(137.16,71.3) 137.15,71.29 arc(137.12,71.28) 137.1,71.27 136.73,70.89 arc(136.45,70.47) 136.35,69.97 136.35,55.1 arc(136.13,54.03) 135.53,53.13 132.37,49.97 arc(131.46,49.36) 130.39,49.15 126.81,49.15 arc(125.93,48.97) 125.19,48.48 121.55,44.84 arc(120.64,44.23) 119.57,44.02 116.9,44.02 arc(116.86,44.03) 116.83,44.05 115.57,45.31 arc(115.54,45.33) 115.5,45.34 112.23,45.34 arc(111.16,45.55) 110.25,46.16 108.87,47.54 arc(108.13,48.04) 107.25,48.21 104.4,48.21 arc(104.06,48.28) 103.78,48.47 arc(103.66,48.55) 103.51,48.58 96.88,48.58 arc(96.41,48.62) 95.96,48.77 arc(95.58,48.98) 95.24,49.25 arc(94.66,49.64) 93.97,49.78 79.19,49.78 arc(78.16,49.98) 77.3,50.56 77.27,50.59 arc(76.53,51.08) 75.66,51.26 58.5,51.26 58.5,51.26 57.6,51.26 arc(56.76,51.09) 56.05,50.62 56.02,50.58 arc(55.27,50.09) 54.39,49.91 45.07,49.91 arc(44,50.12) 43.09,50.73 41.92,51.91 arc(41.31,52.81) 41.1,53.88 41.1,55.67 arc(40.92,56.54) 40.43,57.28 37.19,60.52 arc(36.59,61.43) 36.37,62.49 36.37,66.38 arc(36.45,66.77) 36.67,67.1 41,71.43 arc(41.33,71.65) 41.72,71.73 44.92,71.73 arc(45.12,71.77) 45.28,71.88 45.5,72.09 arc(45.83,72.31) 46.22,72.39 46.43,72.39 arc(46.69,72.5) C668.1
SOC_SGMII0_RXN_C: length 9.4
  TOP w0.102: v2(52.48,74.6) 52.4,74.52 arc(52.34,74.44) 52.32,74.34 52.32,74.32 arc(52.35,74.2) 52.41,74.1 52.43,74.09 arc(52.54,74.02) 52.67,73.99 53.2,73.99 arc(53.47,74.13) U24.AW28
  BOTTOM w0.102: v2(52.48,74.6) 52.32,74.75 52.31,74.78 52.32,74.78 arc(52.33,74.85) 52.32,74.92 arc(52.21,75.2) 51.93,75.31 arc(51.87,75.31) 51.82,75.31 arc(51.8,75.31) 51.79,75.3 arc(51.29,75.17) 50.86,74.87 50.06,74.07 arc(49.86,73.76) 49.78,73.4 49.78,73.12 arc(49.53,72.51) 48.92,72.26 47.83,72.26 arc(47.78,72.27) 47.73,72.3 arc(47.7,72.34) 47.69,72.4 C668.2
SOC_SGMII0_RXP: length 149.9
  BOTTOM w0.102: PHY1.A7 138.15,72.09 138.19,72.05 arc(138.22,72) 138.23,71.95 138.23,71.73 arc(138.22,71.68) 138.19,71.64 138.16,71.61 arc(138.09,71.57) 138.01,71.55 137.18,71.55 arc(137.16,71.55) 137.15,71.55 arc(137.11,71.54) 137.07,71.53 arc(136.99,71.5) 136.93,71.45 136.55,71.07 arc(136.21,70.57) 136.09,69.97 136.09,55.1 arc(135.9,54.13) 135.35,53.31 132.19,50.15 arc(131.36,49.6) 130.39,49.4 126.81,49.4 arc(125.84,49.21) 125.01,48.66 121.37,45.02 arc(120.54,44.47) 119.57,44.27 116.97,44.27 115.65,45.59 112.23,45.59 arc(111.26,45.79) 110.43,46.34 109.05,47.72 arc(108.23,48.27) 107.25,48.46 104.4,48.46 arc(104.16,48.51) 103.96,48.65 arc(103.75,48.78) 103.51,48.83 96.88,48.83 arc(96.46,48.87) 96.06,49 arc(95.72,49.19) 95.42,49.43 arc(94.76,49.88) 93.97,50.03 79.19,50.03 arc(78.26,50.22) 77.48,50.74 77.45,50.77 arc(76.63,51.32) 75.66,51.51 58.39,51.51 58.39,51.51 57.6,51.51 arc(56.66,51.33) 55.87,50.8 55.84,50.76 arc(55.18,50.32) 54.39,50.16 45.07,50.16 arc(44.1,50.36) 43.27,50.91 42.1,52.09 arc(41.54,52.91) 41.35,53.88 41.35,55.67 arc(41.16,56.64) 40.61,57.46 37.37,60.7 arc(36.82,61.52) 36.63,62.49 36.63,66.38 arc(36.68,66.68) 36.85,66.92 41.18,71.25 arc(41.43,71.42) 41.72,71.48 44.92,71.48 arc(45.21,71.53) 45.46,71.7 45.68,71.92 arc(45.92,72.08) 46.22,72.14 46.43,72.14 arc(46.55,72.12) 46.65,72.05 46.67,72.02 arc(46.76,71.89) 46.79,71.73 C686.1
SOC_SGMII0_RXP_C: length 9.4
  TOP w0.102: U24.AW29 arc(53.48,73.64) 53.29,73.74 52.67,73.74 arc(52.44,73.78) 52.25,73.91 52.23,73.92 arc(52.11,74.11) 52.07,74.32 arc(52.02,74.49) v2(51.89,74.6)
  BOTTOM w0.102: C686.2 47.69,71.81 arc(47.71,71.88) 47.75,71.95 arc(47.81,71.99) 47.89,72 48.92,72 arc(49.71,72.33) 50.04,73.12 50.04,73.4 arc(50.09,73.66) 50.24,73.89 51.04,74.69 arc(51.4,74.94) 51.82,75.05 arc(51.87,75.06) 51.93,75.06 arc(52.03,75.02) 52.07,74.92 arc(52.04,74.79) 51.97,74.68 v2(51.89,74.6)
SOC_SGMII0_TXN: length 156.5
  TOP w0.102: v2(55.12,74.88) 55.52,74.48 U24.AU28
  BOTTOM w0.102: C675.2 133.66,75.53 arc(133.64,75.65) 133.57,75.75 133.51,75.81 arc(133.47,75.84) 133.43,75.84 133.32,75.84 arc(132.95,75.77) 132.63,75.56 arc(132.42,75.24) 132.35,74.87 132.35,71.35 arc(132.52,70.47) 133.02,69.73 134.56,68.18 arc(135.17,67.28) 135.38,66.21 135.38,55.59 arc(135.17,54.52) 134.56,53.61 131.81,50.86 arc(130.9,50.25) 129.83,50.04 126.17,50.04 arc(125.2,49.84) 124.38,49.29 122.05,46.97 arc(121.23,46.42) 120.26,46.23 112.74,46.23 arc(111.67,46.44) 110.76,47.05 109.04,48.77 arc(108.29,49.27) 107.42,49.44 97.13,49.44 arc(96.34,49.6) 95.68,50.04 arc(95.01,50.49) 94.23,50.64 79.81,50.64 arc(78.85,50.84) 78.03,51.38 arc(77.21,51.93) 76.25,52.12 56.47,52.12 arc(55.41,52.33) 54.5,52.94 48.75,58.69 arc(48.01,59.19) 47.13,59.36 41.28,59.36 arc(40.47,59.49) 39.77,59.94 38.51,61.2 arc(37.91,62.11) 37.69,63.18 37.69,64.89 arc(37.91,65.96) 38.51,66.86 41.6,69.95 arc(42.5,70.55) 43.57,70.76 48.15,70.76 arc(49.12,70.96) 49.94,71.51 52.77,74.33 arc(52.8,74.37) 52.82,74.41 arc(52.85,74.48) 52.86,74.55 arc(52.88,74.67) 52.95,74.77 53.59,75.42 arc(53.79,75.55) 54.01,75.59 arc(54.24,75.55) 54.43,75.42 54.62,75.23 arc(54.64,75.19) 54.65,75.15 54.65,74.8 arc(54.7,74.67) 54.81,74.6 arc(55.04,74.66) v2(55.12,74.88)
SOC_SGMII0_TXN_C: length 4.3
  BOTTOM w0.102: PHY1.A4 138.15,75.2 arc(138.13,75.29) 138.07,75.37 138.06,75.39 arc(137.96,75.45) 137.85,75.47 137.28,75.47 arc(137.21,75.47) 137.15,75.48 arc(137.12,75.49) 137.09,75.49 arc(136.86,75.58) 136.66,75.73 136.63,75.76 arc(136.48,75.86) 136.3,75.9 135.01,75.9 arc(134.84,75.86) 134.69,75.76 134.68,75.75 arc(134.59,75.62) 134.56,75.47 C675.1
SOC_SGMII0_TXP: length 156.5
  TOP w0.102: v2(55.02,73.92) 55.16,74.07 55.27,74.07 55.6,73.74 55.6,73.51 U24.AU29
  BOTTOM w0.102: C666.2 133.66,76.46 arc(133.63,76.32) 133.56,76.2 133.5,76.14 arc(133.45,76.11) 133.39,76.1 133.32,76.1 arc(132.85,76) 132.45,75.74 arc(132.19,75.34) 132.09,74.87 132.09,71.35 arc(132.29,70.37) 132.84,69.55 134.38,68 arc(134.93,67.18) 135.13,66.21 135.13,55.59 arc(134.93,54.61) 134.38,53.79 131.63,51.04 arc(130.81,50.49) 129.83,50.29 126.17,50.29 arc(125.1,50.08) 124.2,49.47 121.87,47.15 arc(121.13,46.66) 120.26,46.48 112.74,46.48 arc(111.76,46.68) 110.94,47.23 109.22,48.95 arc(108.39,49.5) 107.42,49.69 97.13,49.69 arc(96.44,49.83) 95.86,50.22 arc(95.11,50.72) 94.23,50.9 79.81,50.9 arc(78.95,51.07) 78.21,51.56 arc(77.31,52.16) 76.25,52.37 56.47,52.37 arc(55.5,52.57) 54.68,53.12 48.93,58.87 arc(48.1,59.42) 47.13,59.61 41.27,59.61 arc(40.56,59.73) 39.95,60.12 38.69,61.38 arc(38.14,62.21) 37.95,63.18 37.95,64.89 arc(38.14,65.86) 38.69,66.68 41.78,69.77 arc(42.6,70.32) 43.57,70.51 48.15,70.51 arc(49.22,70.72) 50.12,71.33 52.95,74.15 arc(53,74.22) 53.05,74.3 arc(53.1,74.42) 53.11,74.55 arc(53.12,74.57) 53.13,74.59 53.77,75.24 arc(53.88,75.31) 54.01,75.34 arc(54.14,75.31) 54.25,75.24 54.4,75.09 54.4,74.8 arc(54.5,74.52) 54.76,74.35 arc(54.79,74.35) 54.83,74.34 54.83,74.34 arc(54.85,74.34) 54.87,74.34 54.87,74.34 arc(54.88,74.34) 54.9,74.34 arc(55.13,74.18) v2(55.02,73.92)
SOC_SGMII0_TXP_C: length 4.4
  BOTTOM w0.102: PHY1.A3 138.15,75.96 arc(138.13,75.87) 138.08,75.8 arc(138,75.74) 137.91,75.73 137.28,75.73 arc(137.21,75.73) 137.15,75.74 arc(136.98,75.8) 136.84,75.91 136.81,75.94 arc(136.58,76.09) 136.3,76.15 134.96,76.15 arc(134.81,76.18) 134.68,76.27 arc(134.59,76.4) 134.56,76.55 C666.1
SOC_SGMII1_RXN: length 162.1
  BOTTOM w0.102: C717.1 46.49,69.54 43.65,69.54 arc(42.58,69.33) 41.67,68.73 39.33,66.38 arc(38.76,65.53) 38.56,64.52 38.56,63.54 arc(38.76,62.51) 39.34,61.64 39.87,61.12 arc(40.16,60.93) 40.5,60.86 40.87,60.86 46.98,60.86 arc(47.85,60.68) 48.6,60.19 54.97,53.82 arc(55.88,53.21) 56.94,53 76.86,53 arc(77.74,52.82) 78.48,52.33 78.48,52.33 arc(79.39,51.72) 80.46,51.51 94.66,51.51 arc(95.44,51.35) 96.11,50.91 arc(96.78,50.46) 97.56,50.3 107.95,50.3 arc(108.83,50.13) 109.57,49.63 111.27,47.94 arc(112.17,47.33) 113.24,47.12 119.29,47.12 arc(120.27,47.31) 121.09,47.86 123.41,50.18 arc(124.24,50.73) 125.21,50.93 129.43,50.93 arc(130.5,51.14) 131.4,51.75 133.7,54.04 arc(134.31,54.95) 134.52,56.02 134.52,65.75 arc(134.31,66.82) 133.7,67.73 132.15,69.27 arc(131.66,70.01) 131.48,70.89 131.48,74.93 arc(131.66,75.81) 132.15,76.55 133.8,78.2 arc(134.41,79.1) 134.62,80.17 134.62,92.55 arc(134.81,93.52) 135.36,94.34 136.16,95.14 arc(136.61,95.46) 137.15,95.62 arc(137.25,95.63) 137.35,95.63 137.98,95.63 arc(138.04,95.62) 138.1,95.58 138.13,95.55 arc(138.14,95.53) 138.15,95.51 PHY2.A8
SOC_SGMII1_RXN_C: length 10.1
  TOP w0.102: v2(54.02,74.92) 54.52,75.42 U24.AV27
  BOTTOM w0.102: C717.2 47.69,69.5 47.96,69.23 arc(48.84,69.41) 49.59,69.91 51.82,72.14 53.17,73.49 arc(53.31,73.71) 53.37,73.96 53.37,74.07 arc(53.4,74.26) 53.51,74.42 53.54,74.45 arc(53.68,74.54) 53.84,74.58 arc(53.92,74.6) 53.95,74.68 arc(53.97,74.8) v2(54.02,74.92)
SOC_SGMII1_RXP: length 162.1
  BOTTOM w0.102: C716.1 46.79,68.99 46.5,69.29 43.65,69.29 arc(42.67,69.1) 41.85,68.55 39.51,66.2 arc(38.99,65.43) 38.81,64.52 38.81,63.54 arc(39,62.61) 39.52,61.82 40.05,61.3 arc(40.25,61.16) 40.5,61.11 40.76,61.11 46.98,61.11 arc(47.95,60.92) 48.78,60.37 55.15,54 arc(55.97,53.44) 56.94,53.25 76.86,53.25 arc(77.83,53.06) 78.66,52.51 78.66,52.5 arc(79.48,51.95) 80.46,51.76 94.66,51.76 arc(95.54,51.59) 96.29,51.08 arc(96.87,50.69) 97.56,50.56 107.95,50.56 arc(108.93,50.36) 109.75,49.81 111.45,48.11 arc(112.27,47.56) 113.24,47.37 119.29,47.37 arc(120.17,47.55) 120.91,48.04 123.23,50.36 arc(124.14,50.97) 125.21,51.18 129.43,51.18 arc(130.4,51.37) 131.22,51.92 133.52,54.22 arc(134.07,55.05) 134.26,56.02 134.26,65.75 arc(134.07,66.72) 133.52,67.55 131.97,69.09 arc(131.42,69.92) 131.23,70.89 131.23,74.93 arc(131.42,75.9) 131.97,76.73 133.62,78.38 arc(134.17,79.2) 134.37,80.17 134.37,92.55 arc(134.58,93.62) 135.18,94.52 135.98,95.32 arc(136.5,95.69) 137.11,95.87 arc(137.13,95.87) 137.15,95.87 arc(137.25,95.88) 137.35,95.88 137.85,95.88 arc(137.96,95.91) 138.06,95.97 arc(138.12,96.07) 138.15,96.18 PHY2.A7
SOC_SGMII1_RXP_C: length 10.1
  TOP w0.102: U24.AV28 54.28,74.42 54.02,74.16 v2(54.02,73.92)
  BOTTOM w0.102: v2(54.02,73.92) 54.02,74.15 arc(54,74.21) 53.97,74.27 53.97,74.27 arc(53.91,74.31) 53.84,74.32 arc(53.78,74.31) 53.72,74.27 53.69,74.24 arc(53.64,74.16) 53.62,74.07 53.62,73.96 arc(53.55,73.61) 53.35,73.31 49.77,69.73 arc(48.94,69.17) 47.96,68.98 arc(47.94,68.98) 47.93,68.98 47.69,68.75 C716.2
SOC_SGMII1_TXN: length 174.2
  TOP w0.102: v2(55.98,74.83) 56.52,75.36 U24.AT27
  BOTTOM w0.102: v2(55.98,74.83) 56,74.81 arc(56.01,74.79) 56.02,74.77 56.02,74.73 arc(56,74.67) 55.97,74.61 55.96,74.6 arc(55.9,74.56) 55.83,74.55 55.78,74.55 arc(55.63,74.52) 55.51,74.44 arc(55.43,74.31) 55.4,74.17 55.4,73.85 arc(55.38,73.75) 55.32,73.66 55.3,73.64 arc(55.19,73.57) 55.06,73.54 54.96,73.54 arc(54.76,73.5) 54.59,73.39 51.82,70.61 49.89,68.69 arc(49.07,68.14) 48.1,67.94 46.73,67.94 arc(46.38,68.01) 46.09,68.21 arc(45.79,68.41) 45.44,68.48 43.85,68.48 arc(42.78,68.27) 41.88,67.66 40.2,65.99 arc(39.87,65.58) 39.63,65.12 arc(39.57,64.93) 39.55,64.73 39.55,63.32 arc(39.66,62.73) 40,62.23 40.03,62.2 arc(40.56,61.85) 41.19,61.72 47.56,61.72 arc(48.54,61.53) 49.36,60.98 55.73,54.6 arc(56.56,54.05) 57.53,53.86 77.35,53.86 arc(78.32,53.67) 79.14,53.12 79.14,53.11 arc(79.97,52.56) 80.94,52.37 95.04,52.37 arc(95.82,52.21) 96.49,51.77 arc(97.16,51.32) 97.94,51.17 109.75,51.17 arc(110.37,51.04) 110.9,50.69 arc(111.25,50.16) 111.38,49.54 111.38,49.43 arc(111.42,49.24) 111.53,49.07 111.99,48.61 arc(112.66,48.16) 113.45,48.01 118.94,48.01 arc(119.91,48.2) 120.73,48.75 123.31,51.33 arc(124.13,51.88) 125.11,52.07 129.45,52.07 arc(130.43,52.26) 131.25,52.81 132.89,54.45 arc(133.44,55.27) 133.63,56.25 133.63,65.52 arc(133.44,66.49) 132.89,67.32 131.36,68.84 arc(130.81,69.66) 130.62,70.64 130.62,75.7 arc(130.81,76.64) 131.34,77.44 arc(131.88,78.25) 132.07,79.19 132.07,98.02 arc(132.23,98.83) 132.68,99.51 arc(133.13,99.81) 133.66,99.92 arc(133.67,99.92) 133.68,99.92 arc(133.78,99.9) 133.86,99.82 arc(133.93,99.61) C512.2
SOC_SGMII1_TXN_C: length 4.1
  BOTTOM w0.102: C512.1 134.82,99.72 arc(134.83,99.81) 134.88,99.88 arc(134.96,99.93) 135.04,99.95 137.85,99.95 arc(137.96,99.93) 138.06,99.86 arc(138.12,99.77) 138.15,99.66 PHY2.A4
SOC_SGMII1_TXP: length 174.2
  TOP w0.102: v2(56.13,73.91) 55.96,73.91 55.9,73.97 55.9,74.18 56.26,74.54 56.4,74.54 U24.AT28
  BOTTOM w0.102: v2(56.13,73.91) 56.13,74.1 arc(56.08,74.24) 55.94,74.3 55.88,74.3 55.88,74.3 55.78,74.3 arc(55.73,74.29) 55.69,74.26 arc(55.66,74.22) 55.65,74.17 55.65,73.85 arc(55.61,73.65) 55.5,73.48 55.48,73.46 arc(55.29,73.33) 55.06,73.29 54.96,73.29 arc(54.86,73.27) 54.77,73.21 50.07,68.51 arc(49.17,67.9) 48.1,67.69 46.73,67.69 arc(46.29,67.78) 45.91,68.03 arc(45.7,68.17) 45.44,68.22 43.85,68.22 arc(42.88,68.03) 42.06,67.48 40.38,65.81 arc(40.08,65.44) 39.86,65.02 arc(39.82,64.88) 39.8,64.73 39.8,63.32 arc(39.9,62.83) 40.18,62.41 40.21,62.38 arc(40.66,62.08) 41.19,61.98 47.56,61.98 arc(48.63,61.76) 49.54,61.16 55.91,54.78 arc(56.65,54.29) 57.53,54.11 77.35,54.11 arc(78.41,53.9) 79.32,53.3 79.32,53.29 arc(80.06,52.8) 80.94,52.62 95.04,52.62 arc(95.92,52.45) 96.67,51.95 arc(97.25,51.56) 97.94,51.42 109.75,51.42 arc(110.47,51.28) 111.08,50.87 arc(111.49,50.26) 111.63,49.54 111.63,49.43 arc(111.65,49.33) 111.71,49.25 112.17,48.79 arc(112.76,48.4) 113.45,48.26 118.94,48.26 arc(119.81,48.43) 120.55,48.93 123.13,51.51 arc(124.04,52.11) 125.11,52.32 129.45,52.32 arc(130.33,52.5) 131.07,52.99 132.71,54.63 arc(133.2,55.37) 133.38,56.25 133.38,65.52 arc(133.2,66.4) 132.71,67.14 131.18,68.66 arc(130.58,69.57) 130.37,70.64 130.37,75.7 arc(130.57,76.74) 131.16,77.62 arc(131.64,78.34) 131.81,79.19 131.81,98.02 arc(131.99,98.93) 132.5,99.69 arc(133.03,100.05) 133.65,100.18 arc(133.76,100.2) 133.83,100.28 arc(133.93,100.55) C507.2
SOC_SGMII1_TXP_C: length 4.1
  BOTTOM w0.102: PHY2.A3 138.15,100.34 arc(138.14,100.3) 138.12,100.27 138.1,100.25 arc(138.04,100.22) 137.98,100.2 135,100.2 arc(134.93,100.22) 134.87,100.26 arc(134.83,100.32) 134.82,100.39 C507.1
SOC_SIM_CLK: length 116.9
  TOP w0.102: U24.AN32 v2(59.02,70.92)
  TOP w0.127: v1(140.74,60.1) 142.36,61.71 U33.13
  L10 w0.114: v1(140.74,60.1) 140.74,59.74 138.67,57.67 138.67,52.86 136.13,50.32 134.85,50.32 132.25,47.72 110.78,47.72 106.85,51.65 102.75,51.65 102.61,51.5 98.89,51.5 96.67,53.72 96.67,57.68 v1(96.93,57.94)
  BOTTOM w0.102: v2(59.02,70.92) 59.02,70.8 59.31,70.51 59.31,69.7 58.64,69.03 58.64,64.53 60.68,62.48 60.68,61.59
  BOTTOM w0.127: 60.68,61.59 60.68,58 62.67,56.01 80.31,56.01 81.8,54.52 91.62,54.52 91.83,54.73 94.24,57.14 95.7,58.6 96.27,58.6 v1(96.93,57.94)
SOC_SIM_IO: length 117.7
  TOP w0.102: U24.AP33 58.93,69.83 v2(58.93,69.93)
  TOP w0.127: v1(142.06,60.07) 142.7,60.71 U33.15
  L10 w0.114: v1(142.06,60.07) 141.45,60.07 138.91,57.53 138.91,52.76 136.23,50.08 134.95,50.08 132.35,47.48 110.4,47.48 106.62,51.25 98.25,51.25 96.29,53.21 96.29,56.54 96.43,56.68 96.43,57.77 v1(96.27,57.94)
  BOTTOM w0.102: R714.1 58.58,72.36 58.58,70.45 58.93,70.1 v2(58.93,69.93) 58.42,69.42 58.42,64.44 60.43,62.43 60.43,61.59
  BOTTOM w0.127: 60.43,61.59 60.43,57.9 62.57,55.75 80.21,55.75 81.7,54.26 91.73,54.26 95.4,57.94 v1(96.27,57.94)
SOC_SIM_RST: length 118.7
  TOP w0.102: v2(58.02,69.92) 58.52,70.42 U24.AP32
  TOP w0.127: v1(141.52,59.52) 141.52,60.24 142.49,61.21 U33.14
  L10 w0.114: v1(141.52,59.52) 141.24,59.52 139.15,57.43 139.15,52.66 136.33,49.83 135.05,49.83 132.45,47.24 110.24,47.24 106.51,50.97 98.03,50.97 95.99,53.01 v1(95.99,57.25)
  BOTTOM w0.102: v2(58.02,69.92) 58.02,69.67 57.53,69.19 57.53,62.15 56.97,61.59
  BOTTOM w0.127: 56.97,61.59 55.94,60.57 55.94,59.38 59.82,55.5 80.1,55.5 81.59,54.01 91.94,54.01 95.18,57.25 v1(95.99,57.25)
SOC_SSP0_CLK: length 126.4
  TOP w0.127: R364.1 102.23,78.04 102.23,81.07 101.46,81.85 99.35,81.85 99.02,81.52 98.65,81.52 98.3,81.87 v1(98.3,82.32)
  L5 w0.114: v1(98.3,82.32) 98.3,100.42 105.36,107.47 105.36,116.71 105.79,117.15 105.79,120.53 105.24,121.07 105.24,126.3 104.39,127.15 104.39,128.31 103.99,128.71 103.99,129.36 104.03,129.39 104.03,130.7 103.99,130.74 103.99,135.15 102.47,136.67 102.47,140.55 104.01,142.09 v1(104.01,142.43)
  BOTTOM w0.127: v1(104.01,142.43) 104.01,140.51 105.13,139.4 106.3,139.4 109.55,136.14 109.55,134.87 111.08,133.35 111.7,133.35 112.08,132.97 120.29,132.97 121.37,134.05 121.37,134.79 121.84,135.25 138.18,135.25 144.1,141.17 145.01,141.17 145.59,141.76 NOR1.16
SOC_SSP0_MISO: length 97.1
  TOP w0.102: 93.18,77.18 92.43,76.42 U24.A26
  TOP w0.127: 93.18,77.18 94.51,78.51 v1(97.05,78.51) 97.7,78.51 R363.1
  L5 w0.114: v1(97.05,78.51) 97.05,81.86 97.96,82.76 97.96,100.56 105.01,107.61 105.01,116.85 105.45,117.29 105.45,119.54 v1(104.88,120.1)
  BOTTOM w0.127: v1(104.88,120.1) 105.81,121.03 107.42,121.03 108.05,120.4 115.8,120.4 118.72,117.47 128.47,117.47 131.72,120.73 131.72,122.4 132.77,123.45 132.77,128.45 134.04,129.72 R558.1
SOC_SSP0_MOSI: length 125.3
  TOP w0.127: v1(98.83,81.97) 99.16,82.3 101.55,82.3 101.61,82.23 101.61,82.23 102.62,81.23 102.62,77.22 102.05,76.65 R368.1
  L5 w0.114: v1(98.83,81.97) 98.97,82.1 98.97,100.6 106.06,107.7 106.06,113.73 106.23,113.9 106.23,120.57 105.59,121.22 105.59,126.44 104.9,127.13 104.9,128.29 104.34,128.85 104.34,129.21 104.37,129.25 104.37,130.84 104.34,130.88 104.34,135.44 102.81,136.96 102.81,140.4 104.65,142.24 v1(104.65,142.43)
  BOTTOM w0.127: v1(104.65,142.43) 105.78,141.3 105.78,140.47 109.8,136.45 109.8,136.43 109.93,136.3 109.93,135.03 111.23,133.73 111.86,133.73 112.24,133.35 120.14,133.35 120.99,134.21 120.99,134.94 121.69,135.64 138.02,135.64 144.06,141.67 144.06,141.82 144.32,142.09 NOR1.15
SOC_SSP1_CLK: length 51.8
  TOP w0.102: v2(92.31,73.15) 92.2,73.15 92.09,73.04 91.36,73.04 91.14,73.27 91.14,73.34 90.56,73.91 90.04,73.91 89.53,74.42 U24.C28
  TOP w0.127: v1(123.95,60.43) 123.63,60.1 R402.1
  L3 w0.114: v1(106.47,55.19) 106.89,55.62 111.11,55.62 111.82,56.33 112.23,56.33 112.44,56.11 117.92,56.11 118.71,56.9 121.41,56.9 122.43,57.91 124.44,57.91 125.13,58.6 125.13,59.25 v1(123.95,60.43)
  L10 w0.114: v2(92.31,73.15) 93.18,73.15 94.77,71.57 94.77,65.84 103.71,56.9 104.7,56.9 106.4,55.19 v1(106.47,55.19)
SOC_SSP1_CS0: length 40
  TOP w0.127: v1(99.95,76.5) 99.77,76.33 R367.1 ; U32.12 v1(124.69,58.78)
  L3 w0.114: v1(99.95,76.5) 100.04,76.6 105.98,76.6 108.84,73.74 108.84,67.73 113.7,62.87 118.87,62.87 118.88,62.88 123.24,62.88 124.07,62.06 124.07,61.69 123.51,61.14 123.51,59.96 v1(124.69,58.78)
SOC_SSP1_MOSI: length 51.7
  TOP w0.102: 93.18,74.93 92.68,74.42 U24.A28
  TOP w0.127: v1(108.2,59.73) 109.81,59.73 111.12,61.04 111.12,65.32 106.58,69.86 106.58,74.52 105.73,75.37 95.73,75.37 95.29,74.93 93.18,74.93 ; v1(123.63,61.87) R401.1
  L3 w0.114: v1(123.63,61.87) 122.28,60.52 108.99,60.52 v1(108.2,59.73)
SOC_SSP2_CLK: length 132
  TOP w0.127: v1(105.8,76.16) 105.76,76.2 R369.2 ; CN3.91 39.68,154.7 39.71,154.73 41.86,154.73 42.63,153.97 43.68,153.97 43.72,153.92 v1(43.94,153.92)
  L3 w0.114: v1(105.8,76.16) 105.36,75.72 97.74,75.72 95.8,77.66 91.74,77.66 90.4,78.99 90.4,80.08 90.18,80.31 90.08,80.31 89.63,80.76 89.63,80.86 89.17,81.32 86.77,81.32 86.41,81.67 86.41,81.94 86.16,82.19 85.76,82.19 84.68,83.27 84.68,83.8 84.17,84.32 83.07,84.32 82.41,84.98 82.41,98 81.89,98.53 81.87,98.53 81.05,99.34 81.05,100.05 77.58,103.52 76.55,103.52 73.09,106.98 73.09,107.12 72.72,107.49 72.72,114.37 70.81,116.28 70.81,121.79 69.89,122.72 69.89,128.66 67.11,131.44 65.71,131.44 65.29,131.85 64.57,131.85 60.1,136.32 50.37,136.32 49.85,136.84 48.76,136.84 48.27,137.32 48.27,138.25 46.45,140.08 46.45,140.25 44.97,141.73 44.5,141.73 43.94,142.29 43.94,143 43.01,143.93 42.06,143.93 40.68,145.31 40.68,145.96 40.67,145.97 40.67,150.8 43.79,153.92 v1(43.94,153.92)
SOC_SSP2_CS0: length 123.3
  TOP w0.127: v1(39.98,152.76) 39.9,152.76 39.88,152.78 39.7,152.78 39.63,152.7 CN3.83 ; v1(96.93,74.42) 97.09,74.26 98.58,74.26 R372.2
  L3 w0.114: v1(39.98,152.76) 39.21,151.99 39.21,145.81 41.67,143.35 41.67,140.12 42.04,139.75 43.91,139.75 46.66,137 46.82,137 47.67,136.15 49.57,136.15 51.3,134.42 55.05,134.42 56.21,135.57 59.86,135.57 64.27,131.17 64.58,131.17 65.83,129.91 67.66,129.91 69.2,128.38 69.2,116.92 72.03,114.09 72.03,107.21 72.4,106.84 72.4,106.7 76.01,103.09 77.4,103.09 80.4,100.08 80.4,98.41 80.64,98.18 80.64,97.71 80.87,97.48 81.12,97.48 81.41,97.19 81.41,84.63 81.63,84.41 81.63,83.76 81.86,83.54 82.94,83.54 83.49,82.99 83.49,82.9 84.07,82.32 84.17,82.32 85.63,80.86 85.63,80.76 85.86,80.54 86.55,80.54 86.77,80.32 88.17,80.32 88.63,79.86 88.63,79.76 88.86,79.54 88.95,79.54 89.41,79.07 89.41,77.67 89.53,77.56 89.53,76.85 90.17,76.21 95.69,76.21 96.93,74.97 v1(96.93,74.42)
SOC_SSP2_CS1: length 128.8
  TOP w0.127: CN3.85 40.16,153.2 40.33,153.03 42.26,153.03 42.43,153.2 43.36,153.2 43.72,152.84 43.81,152.84 v1(44,152.65)
  L3 w0.114: v1(105.61,77.09) 102.34,80.37 94.26,80.37 92.09,82.54 87.05,82.54 86.61,82.98 86.61,83.88 86.17,84.32 85.89,84.32 84.58,85.63 84.58,99.08 84.09,99.56 83.45,99.56 82.47,100.54 81.84,100.54 77.84,104.53 76.99,104.53 74.65,106.87 74.65,114.76 73.41,116.01 73.41,128.37 71.91,129.87 71.91,131.03 70.02,132.92 66.61,132.92 65.91,133.62 64.3,133.62 60.58,137.35 50.81,137.35 46.01,142.15 46.01,143.6 45.42,144.19 44.55,144.19 44.29,144.45 44.29,145.45 43.54,146.2 43.54,146.71 43.12,147.12 43.12,147.36 42.45,148.03 41.94,148.03 41.73,148.24 41.73,150.14 44,152.41 v1(44,152.65)
  BOTTOM w0.127: v1(105.61,77.09) 105.23,76.7 R691.2
SOC_SSP2_CS2: length 123.5
  TOP w0.127: R373.2 100.71,74.68 v1(100.46,74.93) ; v1(40.01,153.65) 39.82,153.65 39.76,153.7 CN3.87
  L3 w0.114: v1(40.01,153.65) 40.69,152.96 40.69,151.31 40.32,150.95 40.32,145.83 40.34,145.82 40.34,145.17 41.92,143.59 42.2,143.59 42.78,143.59 43.54,142.82 43.54,142.13 44.28,141.39 44.83,141.39 46.11,140.11 46.11,139.93 46.63,139.41 46.63,138.61 47.93,137.31 47.93,137.18 48.62,136.49 49.71,136.49 50.23,135.98 51.62,135.98 52.84,134.76 54.91,134.76 56.07,135.91 60.01,135.91 64.41,131.51 65.15,131.51 65.56,131.1 66.97,131.1 69.55,128.52 69.55,121.21 70.47,120.28 70.47,116.14 72.38,114.23 72.38,107.35 72.75,106.98 72.75,106.84 76.28,103.3 77.49,103.3 80.62,100.17 80.62,98.82 81.41,98.03 81.41,97.91 81.63,97.69 81.63,84.76 82.08,84.31 82.57,84.31 83.48,83.4 84.09,83.4 84.43,83.06 84.43,82.83 85.86,81.4 86.09,81.4 86.63,80.86 86.63,80.76 86.86,80.54 88.95,80.54 89.63,79.86 89.63,77.76 89.86,77.54 89.94,77.54 90.6,76.88 90.6,76.8 90.82,76.57 96.4,76.57 98.04,74.93 v1(100.46,74.93)
SOC_SSP2_CS3: length 122.6
  TOP w0.127: v1(43.93,153.29) 43.81,153.29 43.52,153.58 42.27,153.58 42.1,153.42 40.87,153.42 40.08,154.2 CN3.89
  L3 w0.114: v1(100.46,79.43) 100.43,79.43 99.84,80.02 92.95,80.02 92.51,80.47 91.92,80.47 91.4,80.99 91.4,81.08 91.18,81.31 91.08,81.31 90.63,81.76 90.63,81.86 90.17,82.32 86.96,82.32 86.34,82.94 86.34,83.02 84.95,84.4 84.95,84.54 83.95,85.54 83.86,85.54 83.45,85.95 83.45,99.04 82.18,100.31 81.58,100.31 77.7,104.19 76.85,104.19 74.31,106.73 74.31,110.5 73.53,111.27 73.53,115.39 73.06,115.86 73.06,128.08 69.02,132.12 65.99,132.12 65.53,132.58 65.53,132.76 65.01,133.28 64.16,133.28 60.43,137.01 50.67,137.01 45.67,142.01 45.67,143.46 45.28,143.85 44.4,143.85 43.64,144.61 43.12,144.61 42.57,145.16 42.56,145.16 42.46,145.25 42.36,145.25 41.35,146.26 41.35,150.25 43.43,152.33 43.43,152.79 v1(43.93,153.29)
  BOTTOM w0.127: R690.2 100.77,79.12 v1(100.46,79.43)
SOC_SSP2_MISO: length 118
  TOP w0.102: U24.F28 86.07,73.98 v2(86.07,73.94)
  TOP w0.127: R55.1 42.16,152.4 42.48,152.72 43.31,152.72 43.81,152.21 44,152.21 44.84,151.36 44.84,147.48 42.62,145.26 42.1,145.26 41.9,145.06 41.9,145.05 41.17,144.32 37.78,144.32 v1(37.21,143.76)
  L3 w0.114: v2(86.07,73.94) 86.07,74.03 86.33,74.29 86.33,76 85.87,76.46 85.33,76.46 85.27,76.53 85.26,76.53 83.62,78.16 83.62,78.83 83.22,79.23 82.86,79.23 82.57,79.51 81.78,79.51 81.43,79.87 81.43,80.06 81.17,80.32 80.06,80.32 79.4,80.98 79.4,81.08 78.48,82.01 78.48,82.63 77.57,83.54 77.57,83.93 76.63,84.87 76.63,96.62 75.63,97.62 75.63,97.92 75.01,98.54 74.86,98.54 74.63,98.76 74.63,99.15 74.27,99.51 73.92,99.51 73.66,99.76 73.66,100.13 73.26,100.54 72.86,100.54 70.65,102.74 69.29,102.74 60.93,111.1 60.93,122.1 59.4,123.63 58.79,123.63 55.76,126.66 55.62,126.81 49.73,126.81 49.71,126.79 49.35,126.79 48.94,127.2 48.31,127.2 48.2,127.32 45.78,127.32 45.39,126.93 44.52,126.93 44.51,126.91 44.26,126.91 43.95,127.22 43.95,128.08 43.49,128.54 43.45,128.54 40.93,131.07 40.93,134.96 38.07,137.82 38.07,142.44 37.41,143.1 37.41,143.55 v1(37.21,143.76)
SOC_SSP2_MOSI: length 118.7
  TOP w0.127: v1(42.75,152.27) 41.85,151.37 R60.1
  L3 w0.114: v1(42.75,152.27) 41.01,150.53 41.01,146.11 41.02,146.1 41.02,145.46 42.2,144.27 43.49,144.27 44.28,143.49 44.98,143.49 45.21,143.26 45.21,141.98 48.62,138.57 48.62,137.47 48.9,137.18 50.01,137.18 50.53,136.66 60.24,136.66 64.72,132.19 65.43,132.19 65.85,131.78 67.93,131.78 70.23,129.48 70.23,122.86 72.7,120.39 72.7,115.74 73.12,115.32 73.12,107.58 73.43,107.26 73.43,107.12 76.72,103.84 77.57,103.84 77.67,103.73 77.67,103.73 81.63,99.78 81.63,99.76 81.86,99.54 81.95,99.54 82.63,98.86 82.63,85.76 82.86,85.54 82.95,85.54 83.63,84.86 83.63,84.76 83.86,84.54 84.26,84.54 85.14,83.65 85.14,83.12 85.85,82.41 86.25,82.41 86.63,82.03 86.63,81.76 86.86,81.54 89.95,81.54 90.63,80.86 90.63,79.76 90.92,79.48 98.83,79.48 v1(100.46,77.85)
  BOTTOM w0.127: R692.2 v1(100.46,77.85)
SOC_SSPCK_R: length 11.5
  TOP w0.102: 93.18,76.64 92.58,76.04 90.9,76.04 U24.B26
  TOP w0.127: R364.2 100.51,77.22 93.76,77.22 93.18,76.64
SOC_SSPMOSI_3.3V: length 4.7
  TOP w0.127: U29.7 130.75,62.36 130.43,62.03 130.43,60.33 130.68,60.08 U32.7
SOC_SSPMOSI_R: length 10.3
  TOP w0.102: 93.18,75.42 U24.A27
  TOP w0.127: R368.2 100.43,76.2 100.01,75.78 98.06,75.78 97.62,76.22 94.47,76.22 93.68,75.42 93.18,75.42
SOC_TCK: length 151.6
  TOP w0.127: U24.AE1 67.52,102.44 v1(69.09,104.01) ; v1(62.64,112.37) 63.05,111.96 C797.1 R798.2
  L5 w0.102: 67.74,104.01 v1(69.09,104.01)
  L5 w0.114: v1(62.64,112.37) 62.05,111.79 62.05,109.7 67.74,104.01
  L8 w0.102: v1(69.09,104.01) 70.35,104.01
  L8 w0.114: 70.35,104.01 75.13,108.79 76.29,108.79 76.83,109.33 76.83,110.27 77.51,110.95 78.47,110.95 79.19,111.68 79.19,112.11 81.79,114.7 81.79,115.6 82.02,115.83 82.6,115.83 82.65,115.79 84.97,115.79 85.87,114.88 92.17,114.88 92.91,114.15 95.95,114.15 96.3,113.8 98.16,113.8 98.49,114.13 98.49,114.13 99.09,114.72 99.09,118.55 99.36,118.82 99.36,123.9 101.83,126.38 101.83,128.59 102.66,129.41 104.19,129.41 104.66,129.88 108.03,129.88 108.81,129.1 112.9,129.1 114.25,130.44 119.91,130.44 120.7,131.23 122.1,131.23 122.74,130.6 123.3,130.6 123.96,131.25 136.38,131.25 136.76,131.64 137.44,131.64 138.11,132.3 138.11,132.41 139.63,133.93 141.57,133.93 141.79,133.72 146.49,133.72 146.82,133.39 147.24,133.39 147.25,133.39 v1(147.38,133.39)
  BOTTOM w0.127: U49.10 143.89,157.21 140.85,154.17 140.85,150.69 140.34,150.18 140.34,148.31 142.41,146.24 146.22,146.24 147.64,144.82 147.64,142.91 146.81,142.09 146.81,141.36 146.51,141.05 146.51,136.02 147.02,135.51 147.02,134.45 147.37,134.1 147.37,133.4 v1(147.38,133.39)
SOC_TDI: length 144.4
  TOP w0.127: U24.AG1 65.52,101.59 66.63,102.7 v1(66.63,102.74)
  L8 w0.102: v1(66.63,102.74) 71.04,102.74 72.03,103.73 72.03,104.01
  L8 w0.114: 72.03,104.01 72.03,105.36 75.23,108.55 76.39,108.55 77.07,109.23 77.07,110.17 77.61,110.71 79.33,110.71 80.07,111.45 80.07,112.63 81.71,114.27 81.71,114.28 82.33,114.9 83.01,114.9 83.6,115.49 84.58,115.49 85.1,114.98 85.43,114.98 85.8,114.6 92.11,114.6 92.81,113.91 95.85,113.91 96.2,113.56 98.26,113.56 98.59,113.89 98.59,113.89 99.33,114.62 99.33,118.45 99.6,118.72 99.6,123.8 102.07,126.28 102.07,128.49 102.76,129.17 104.29,129.17 104.76,129.64 107.93,129.64 108.71,128.85 113,128.85 114.35,130.2 121.06,130.2 121.07,130.19 121.93,130.19 122.1,130.36 123.4,130.36 124.06,131.01 136.48,131.01 136.86,131.39 137.54,131.39 138.35,132.2 138.35,132.31 139.73,133.69 141.47,133.69 141.69,133.48 146.39,133.48 146.72,133.15 146.99,133.15 147.24,132.9 147.24,132.76 v1(147.37,132.63)
  BOTTOM w0.127: U49.2 143.5,161.21 140.72,158.42 140.72,155.15 140.06,154.49 140.06,150.98 139.57,150.49 139.57,147.99 142.09,145.48 144.72,145.48 146.05,144.15 146.05,141.68 145.75,141.37 145.75,135.7 146.23,135.22 146.23,132.41 146.23,132.4 146.25,132.4 146.47,132.18 146.92,132.18 147.37,132.63 v1(147.37,132.63)
SOC_TDO: length 135.7
  TOP w0.127: v1(69.09,105.28) 69.09,104.61 66.52,102.03 U24.AF1
  L8 w0.114: v1(147.79,134.26) 147.64,134.4 146.6,134.4 146.39,134.2 141.99,134.2 141.77,134.42 139.43,134.42 138.26,133.24 135.01,133.24 133.5,131.74 123.76,131.74 123.74,131.71 121.11,131.71 121.01,131.81 119.3,131.81 118.41,130.92 114.05,130.92 112.7,129.58 109.87,129.58 108.87,130.58 103.53,130.58 103.43,130.67 103.07,130.67 101.35,128.95 101.35,126.58 98.88,124.1 98.88,119.02 98.6,118.75 98.6,114.92 98.29,114.61 98.29,114.61 97.96,114.28 96.5,114.28 96.15,114.63 93.11,114.63 92.37,115.37 86.07,115.37 85.17,116.27 83.86,116.27 83.81,116.32 81.2,116.32 80.48,115.6 80.48,115.1 78.65,113.27 78.65,111.86 78.25,111.46 77.33,111.46 76.53,110.66 76.24,110.66 75.62,110.04 75.62,109.38 75.51,109.27 74.92,109.27 70.94,105.28 v1(69.09,105.28)
  BOTTOM w0.127: v1(147.79,134.26) 147.76,134.28 147.76,134.39 147.27,134.88 147.27,135.61 146.76,136.12 146.76,140.95 147.07,141.25 147.07,141.96 147.89,142.79 147.89,145.09 144.5,148.48 143.43,148.48 143.2,148.72 141.25,148.72 140.59,149.38 140.59,150.07 141.1,150.58 141.1,153.33 142.47,154.71 U49.15
SOC_TEMP1: length 8
  TOP w0.127: Q6.3 120.64,120.48 120.9,120.75 121.57,120.75 121.96,120.36 123.76,120.36 124.59,121.18 124.59,121.92 125.27,122.6 U13.48
SOC_TIMI0: length 116.5
  TOP w0.127: R313.1 77.85,106.81 78.87,105.79 78.87,104.14 v1(79.25,103.76) 80.91,102.1 80.91,100.82 U24.M2 ; v1(106.43,67.06) 106.43,66.8 107.76,65.47 109.03,65.47 109.98,64.52 109.98,61.72 109.1,60.84 U28.6
  L5 w0.114: v1(113.39,112.93) 113.39,112.5 111.89,111 111.89,106.3 109.07,103.48 109.07,70.59 106.43,67.94 v1(106.43,67.06)
  L10 w0.114: v1(113.39,112.93) 113.39,112.73 113.06,112.4 105.98,112.4 104.58,113.79 97.9,113.79 92.31,108.2 88.61,108.2 85.57,105.16 84.24,105.16 79.62,100.54 79.62,99.02 79.18,98.58 78.86,98.58 78.4,99.03 78.4,99.12 78.08,99.44 78.05,99.44 77.63,99.86 77.63,102.14 v1(79.25,103.76)
SOC_TIMI0_B: length 3.3
  TOP w0.127: U28.2 104.77,61.34 104.52,61.09 104.52,60.04 U30.5
SOC_TIMI1: length 113
  TOP w0.127: U28.3 106.17,60.84 106.5,60.5 v1(107.09,60.5) ; U24.M1 78.41,103.53 v1(78.41,104.65) 78.16,104.9 77.17,104.9 76.45,105.61 R312.1
  L5 w0.114: v1(107.09,60.5) 107.29,60.71 108.84,60.71 110.49,62.36 110.49,65.02 111.63,66.17 112.39,66.17 113.79,67.56 113.79,110.11 116.03,112.35 116.03,114.24 v1(115.9,114.36)
  L10 w0.114: v1(78.41,104.65) 78.79,104.27 80.99,104.27 85.7,108.98 91.97,108.98 94.23,111.24 94.23,112.9 95.12,113.79 96.77,113.79 97.54,114.55 104.88,114.55 105.26,114.17 115.71,114.17 v1(115.9,114.36)
SOC_TIMI1_B: length 103.8
  TOP w0.127: v1(79.17,121.16) 79.56,121.55 U17.5 ; U28.5 109.36,60.34 110.36,61.34 110.36,65.53 109.35,66.55 107.95,66.55 v1(106.93,67.56)
  L5 w0.114: v1(106.93,67.56) 106.93,68.11 109.31,70.49 109.31,70.61 111.51,72.8 111.51,81.68 110.58,82.61 110.58,83.88 110.15,84.31 110.15,104.22 112.14,106.21 112.14,110.85 113.98,112.69 v1(113.98,114.96)
  L8 w0.114: v1(79.17,121.16) 80.45,122.44 82.16,122.44 82.78,123.06 92.33,123.06 93.34,122.05 93.34,121.41 93.73,121.03 94.17,121.03 97.1,118.11 v1(97.72,118.11)
  L10 w0.114: v1(97.72,118.11) 98.81,117.02 98.81,115.57 99.57,114.8 104.98,114.8 105.35,114.43 113.45,114.43 v1(113.98,114.96)
SOC_TIMO0: length 180.8
  TOP w0.127: v1(43.02,148.84) 43.02,148.85 43.01,148.85 43.01,148.88 42.92,148.88 42.45,149.35 42.11,149.35 41.58,149.89 39.5,149.89 39.32,149.7 CN3.71 ; R311.1 75.64,109.62 75.64,110.83 v1(75.29,111.18)
  L3 w0.114: v1(43.02,148.84) 43.02,148.85 43.01,148.85 43.01,148.88 43.01,148.88 43.01,148.91 43.47,148.46 43.47,147.27 43.72,147.01 44.25,147.01 44.74,146.52 44.74,145.52 46.35,143.91 46.35,142.29 50.95,137.69 60.72,137.69 64.45,133.97 66.05,133.97 66.76,133.26 71.02,133.26 73.86,130.41 73.86,117.91 75.19,116.58 75.19,114.54 75,114.36 75,111.47 v1(75.29,111.18)
  L5 w0.114: v1(14.27,63.07) 14.71,63.5 14.71,71.94 15.61,72.84 15.61,75.67 18.55,78.6 18.55,86.71 16.11,89.15 16.11,92.98 14.78,94.32 14.78,104.8 20.27,110.29 24.55,110.29 25.89,111.63 27.02,111.63 27.49,112.11 27.49,113.27 28.36,114.14 28.36,133.53 29.15,134.33 31.09,134.33 32.98,136.23 32.98,136.89 34.11,138.02 34.42,138.02 35.3,138.89 35.3,139.83 36.85,141.39 39.37,141.39 39.63,141.65 39.76,141.65 40.51,142.4 40.51,147.1 41.65,148.23 42.42,148.23 43.02,148.84 v1(43.02,148.84)
  BOTTOM w0.127: R740.1 10.72,61.77 12.01,63.07 v1(14.27,63.07)
SOC_TIMO0_R: length 11.2
  TOP w0.102: 77.22,104.01 79.25,101.98 79.5,101.98 80.01,101.47 80.01,100.39 80.52,99.88 U24.M3
  TOP w0.127: 77.22,104.01 75.63,105.6 75.63,107.82 R311.2
SOC_TIMO1: length 181
  TOP w0.127: v1(69.65,118.14) 69.65,117.83 70.26,117.22 71.28,117.22 71.75,117.69 72.33,117.69 72.64,117.37 72.64,116.21 75.44,113.41 v1(75.44,112.9) ; CN3.75 39.39,150.7 39.86,150.24 43.17,150.24 43.93,151 v1(43.95,151) ; v1(76.12,109.91) 77.27,109.91 77.6,110.24 78.41,110.24 79.25,109.4 R314.1
  L3 w0.114: v1(76.12,109.91) 76.12,109.93 75.84,110.22 75.84,112.05 75.88,112.09 75.88,112.46 v1(75.44,112.9) 75.44,115.47 76.64,116.67 76.64,128.65 71.55,133.74 66.96,133.74 66.25,134.45 64.65,134.45 60.92,138.18 51.38,138.18 46.96,142.6 46.96,143.98 45.22,145.72 45.22,150.18 44.4,151 v1(43.95,151)
  L8 w0.114: CN17.4 23.01,58.93 21.62,60.33 20.99,60.33 20.14,61.18 20.14,70.74 21.07,71.68 25.48,71.68 27.64,73.84 36.14,73.84 37.15,74.84 37.15,77.22 36.2,78.17 36.2,82.3 39.93,86.03 40.6,86.03 41.75,87.18 41.75,97.2 52.25,107.7 58.8,107.7 61.47,110.36 61.47,112.22 63.04,113.79 66.37,113.79 67.14,114.56 67.14,115.53 69.65,118.03 v1(69.65,118.14)
SOC_TIMO1_R: length 10.9
  TOP w0.102: 81.13,102.83 81.13,99.03 U24.M4
  TOP w0.127: 81.13,102.83 79.25,104.71 R314.2
SOC_TMS: length 141.5
  TOP w0.102: U24.AE2 68.02,99.92 v2(68.02,99.75)
  L8 w0.102: 72.8,104.01 70.46,101.68 70.46,100.61 69.6,99.75 v2(68.02,99.75)
  L8 w0.114: v1(146.74,132.69) 146.2,133.24 141.59,133.24 141.37,133.45 139.83,133.45 138.59,132.21 138.59,132.1 137.64,131.15 136.96,131.15 136.58,130.77 124.99,130.77 123.6,129.38 122.88,129.38 122.31,129.95 120.88,129.95 120.87,129.95 114.45,129.95 113.11,128.6 108.55,128.6 107.75,129.4 107.39,129.4 106.12,128.13 104.51,128.13 103.71,128.93 102.95,128.93 102.31,128.3 102.31,126.18 99.84,123.7 99.84,118.62 99.58,118.36 99.58,114.54 98.69,113.65 98.69,113.65 98.36,113.32 96.1,113.32 95.94,113.47 88.79,113.47 88.75,113.43 88.38,113.43 88.38,113.44 86.33,113.44 85.76,114.01 85.76,114.31 85.33,114.74 84.72,114.74 84.51,114.52 83.47,114.52 83.05,114.1 83.05,113.73 81.94,112.63 80.64,112.63 80.31,112.3 80.31,111.35 79.43,110.47 77.71,110.47 77.31,110.07 77.31,109.1 76.51,108.31 76.1,108.31 76.09,108.3 75.32,108.3 73.36,106.34 73.36,104.58 72.8,104.01
  BOTTOM w0.127: v1(146.74,132.69) 146.71,132.72 146.71,133.1 146.48,133.32 146.48,135.32 146,135.8 146,141.27 146.3,141.57 146.3,144.26 144.83,145.73 142.19,145.73 139.83,148.1 139.83,150.39 140.31,150.87 140.31,154.39 142.71,156.79 142.71,159.73 143.19,160.21 U49.4
SOC_TRST#: length 150.2
  TOP w0.102: 69.6,104.01 69.6,103.95 68.52,102.87 U24.AD1
  TOP w0.127: v1(69.72,112.4) 69.73,112.4 70.36,113.03 C807.2 C806.1 C805.1 ; 69.6,104.01 v2(70.1,104.52)
  L5 w0.114: v2(70.1,104.52) 70.1,105.89 67.85,108.15 67.85,110.64 69.6,112.4 v1(69.72,112.4)
  L8 w0.114: v2(70.1,104.52) 70.52,104.52 75.02,109.03 76.19,109.03 76.59,109.43 76.59,110.37 77.43,111.22 78.35,111.22 78.89,111.76 78.89,113.04 80.9,115.06 81.24,115.06 81.49,115.31 81.49,115.68 81.89,116.08 83.71,116.08 83.76,116.03 85.07,116.03 85.97,115.13 92.27,115.13 93.01,114.39 96.05,114.39 96.4,114.04 98.06,114.04 98.39,114.37 98.39,114.37 98.84,114.82 98.84,118.65 99.12,118.92 99.12,124 101.59,126.48 101.59,128.69 102.56,129.65 104.09,129.65 104.56,130.12 108.13,130.12 108.91,129.34 112.8,129.34 114.15,130.68 118.51,130.68 119.39,131.56 120.92,131.56 121.01,131.47 122.2,131.47 122.84,130.84 123.2,130.84 123.86,131.5 136.27,131.5 136.97,132.19 136.97,132.47 137.5,133 138.36,133 139.53,134.18 141.67,134.18 141.89,133.96 146.59,133.96 146.64,133.91 v1(146.93,133.91)
  BOTTOM w0.127: v1(146.93,133.91) 146.74,134.1 146.74,135.43 146.25,135.91 146.25,141.16 146.56,141.46 146.56,142.24 147.38,143.07 147.38,144.7 146.89,145.2 146.89,145.21 146.11,145.99 142.3,145.99 140.08,148.21 140.08,150.28 140.56,150.76 140.56,154.28 143.38,157.1 143.38,157.96 143.63,158.21 U49.8
SOC_TVD: length 21
  TOP w0.127: EMU1.12 100.63,150.68 100.86,150.91 103.72,150.91 v1(103.81,150.82) ; R33.2 91.28,156.75 92.51,155.52 92.51,153.59 92.92,153.18 EMU1.1 v1(95.44,153.18)
  L8 w0.114: v1(95.44,153.18) 100.92,153.18 103.28,150.82 v1(103.81,150.82)
SOC_UART0_DETECT: length 109.1
  TOP w0.127: SOC.1 168.9,123.06 R220.2 ; U55.6 76.1,113.66 74.75,115.02 v1(74.75,115.32)
  L10 w0.114: SOC.1 163.68,122.02 144.4,122.02 142.27,119.89 139.19,119.89 138.08,118.78 117.39,118.78 115.88,120.28 110.93,120.28 106.74,124.48 106.24,124.48 105.99,124.74 105.99,125.34 104.88,126.45 104.52,126.45 103.67,125.6 94.74,125.6 94.64,125.5 92.18,125.5 91.57,126.11 83.39,126.11 76.89,119.6 76.89,117.33 74.87,115.32 v1(74.75,115.32)
SOC_UART0_RXD_3V3: length 11
  TOP w0.127: U55.5 78.56,114.16 78.96,114.55 79.48,114.55 79.95,115.02 81.32,115.02 81.42,114.92 83.58,114.92 83.64,114.99 v1(83.71,114.99)
  BOTTOM w0.127: v1(83.71,114.99) 83.64,115.05 83.62,115.05 82.87,115.81 82.68,115.81 82.52,115.96 U57.7 82.52,118.31 R587.1
SOC_UART0_RXD_V1P8: length 14.2
  TOP w0.102: v2(82.02,98.92) U24.K4
  BOTTOM w0.127: U57.10 82.52,109.88 83.11,109.3 83.11,105.71 82.93,105.54 82.93,101.96 82.68,101.71 82.03,101.71 81.28,100.97 81.28,99.36 81.44,99.2 81.74,99.2 v2(82.02,98.92)
SOC_UART0_TXD_3V3: length 172.4
  TOP w0.127: U3.17 156.4,161.47 157.73,160.15 v1(159.26,160.15) ; U18.11 155.23,111.1 155.04,110.91 154.09,110.91 153.36,110.18 R289.1 v1(152.91,110.75)
  L3 w0.114: v1(80.83,111.53) 79.58,110.28 79.58,110.26 79.59,110.25 79.59,106.44 84.49,101.54 97.04,101.54 107.79,112.29 109.71,112.29 v1(110.43,113.02)
  L8 w0.114: v1(162.61,148.69) 162.13,148.21 162.13,145.49 161.66,145.02 161.66,142.06 160.95,141.35 159.64,141.35 155.68,137.39 155.68,135.16 154.05,133.53 154.05,123.44 152.27,121.67 152.27,120.78 152.94,120.11 152.94,110.78 v1(152.91,110.75)
  BOTTOM w0.127: R524.1 163.23,148.69 v1(162.61,148.69) 162.61,149.53 160.76,151.38 160.76,155.47 158.9,157.33 158.9,159.79 v1(159.26,160.15) ; v1(110.43,113.02) 110.44,113.02 111.47,114.05 114.55,114.05 115.49,114.99 117.68,114.99 118.4,114.26 118.69,114.26 119.07,113.88 123.15,113.88 123.73,114.47 151.98,114.47 153.12,113.32 153.12,110.96 v1(152.91,110.75) ; v1(80.83,111.53) 82.25,112.95 82.25,113.35 83.17,114.28 83.17,114.65 82.91,114.91 82.02,114.91 81.5,115.43 81.5,115.69 81.22,115.96 U57.5
SOC_UART0_TXD_V1P8: length 3.2
  TOP w0.127: R315.2 81.72,109.16 v1(82.17,108.71)
  BOTTOM w0.127: U57.12 81.22,109.92 81.6,109.54 81.86,109.54 82.17,109.23 v1(82.17,108.71)
SOC_UART1_CTS_3V3: length 81.1
  TOP w0.127: v1(43.88,155.65) 43.6,155.93 42.77,155.93 42.25,156.46 39.56,156.46 39.32,156.7 CN3.99
  L3 w0.114: v1(43.88,155.65) 43.88,155.24 44.83,154.29 44.83,151.26 45.85,150.24 45.85,145.78 47.44,144.18 47.44,143.08 50.21,140.31 53.31,140.31 54.1,139.52 60.26,139.52 64.85,134.93 70.17,134.93 70.87,134.24 73.3,134.24 75.99,131.55 78.94,131.55 79.26,131.88 81.3,131.88 83.08,130.1 83.79,130.1 84.63,129.26 84.63,128.5 84.39,128.26 84.39,125.19 v1(85.63,123.95)
  L5 w0.114: v1(82.42,115.39) 83.15,115.39 83.49,115.73 83.65,115.73 84.71,116.79 84.71,121.97 85.63,122.89 v1(85.63,123.95)
  BOTTOM w0.127: U57.6 81.87,115.94 v1(82.42,115.39)
SOC_UART1_CTS_V1P8: length 9.5
  TOP w0.102: v2(82.52,102.11) U24.K1
  BOTTOM w0.127: v2(82.52,102.11) 82.52,105.66 82.74,105.89 82.74,109.03 81.87,109.9 U57.11
SOC_UART1_RTS_3V3: length 83.3
  TOP w0.127: v1(43.26,155.49) 42.86,155.49 42.14,156.2 CN3.97
  L3 w0.114: v1(43.26,155.49) 43.41,155.35 43.43,155.35 44.58,154.2 44.58,151.17 45.47,150.28 45.47,145.82 47.2,144.08 47.2,142.98 50.11,140.07 53.15,140.07 53.94,139.28 60.14,139.28 61,138.42 61.02,138.42 64.75,134.69 66.35,134.69 67.06,133.99 73.2,133.99 75.88,131.31 79.04,131.31 79.36,131.64 81.2,131.64 83.06,129.77 83.78,129.77 84.39,129.16 84.39,128.6 84.13,128.34 84.13,124.82 v1(84.99,123.96)
  L5 w0.114: v1(84.99,123.96) 84.99,122.93 82.59,120.52 82.59,117.23 81.53,116.18 81.53,114.76 82.14,114.15 v1(82.14,114.1)
  BOTTOM w0.127: U57.4 80.57,115.34 80.9,115.01 81.28,115.01 82.14,114.15 v1(82.14,114.1)
SOC_UART1_RTS_V1P8: length 2
  BOTTOM w0.127: R619.2 81.03,109.16 80.57,109.62 U57.13
SOC_UART1_RXD_1V8: length 126.4
  TOP w0.127: U21.1 76.1,116.96 v1(75.08,117.98)
  L5 w0.114: v1(88.72,147.35) 88.18,147.88 88.18,148.48 87.13,149.52 79.68,149.52 74.68,144.52 74.68,143.59 73.86,142.77 73.86,133.57 73.9,133.53 73.9,118.67 74.59,117.98 v1(75.08,117.98)
  L10 w0.114: v1(160.66,140.44) 159.57,139.36 139.46,139.36 137.43,137.33 119.74,137.33 117.47,139.6 116.28,139.6 116.26,139.59 106.71,139.59 105.87,140.43 97.4,140.43 90.48,147.35 v1(88.72,147.35)
  BOTTOM w0.127: v1(160.66,140.44) 161.01,140.44 161.26,140.69 U51.10
SOC_UART1_TXD_1V8: length 99.5
  TOP w0.127: v1(94.74,106.38) 83.98,106.38 83.35,107.01 83.35,108.97 83.15,109.16 R316.2 ; U26.3 105,63.1 104.92,63.18 104.55,63.18 104.25,62.89 104.25,62.6 102.43,60.77 v1(97.12,60.77)
  L3 w0.114: v1(94.74,106.38) 95.09,106.02 101.04,106.02 107.95,112.93 v1(108.57,112.93)
  L5 w0.114: v1(97.12,60.77) 96.08,61.81 96.08,66.74 98.88,69.54 98.88,69.78 99.13,70.03 99.74,70.03 102.3,72.6 102.3,74.85 102.47,75.02 102.47,101.2 108.73,107.46 108.73,111.32 108.57,111.48 v1(108.57,112.93)
SOC_URX_3V3: length 92.7
  TOP w0.127: U55.1 80.35,112.66 v1(80.82,112.19) ; v1(154.43,116.46) 153.93,115.96 U18.9
  L10 w0.114: v1(154.43,116.46) 154.43,117.62 153.25,118.8 150.91,118.8 150.25,118.14 138.88,118.14 138.13,117.39 130.2,117.39 130.06,117.53 122.63,117.53 122.06,118.1 117.31,118.1 117.03,118.1 115.53,119.6 110.65,119.6 106.97,123.27 106.17,123.27 104.9,124.54 103.98,124.54 103.81,124.37 102.77,124.37 102.64,124.51 99.64,124.51 98.68,123.55 93.68,123.55 91.87,121.74 86.25,121.74 85.32,120.81 85.32,116.54 84.69,115.91 84.01,115.91 83.25,115.15 83.25,114.37 82.35,113.46 82.09,113.46 v1(80.82,112.19)
SOC_VPPB_EN: length 13.3
  TOP w0.254: v1(108.43,151.15) 110.16,152.88 110.16,159.3 R28.1 109.33,160.13 Q2.5
  BOTTOM w0.254: U50.24 108.82,151.54 v1(108.43,151.15)
SOC_XFI_CLKN: length 73.4
  TOP w0.102: U15.16 65.5,121.15 arc(65.51,121.07) 65.56,121 arc(65.61,120.94) 65.62,120.85 65.62,120.73 arc(65.6,120.6) 65.52,120.49 65.44,120.41 arc(65.32,120.26) 65.22,120.08 65.17,119.95 arc(65.16,119.93) 65.14,119.9 65.08,119.85 arc(64.96,119.76) 64.81,119.74 64.78,119.74 arc(64.65,119.71) 64.54,119.64 64.5,119.6 arc(64.44,119.52) 64.39,119.43 arc(64.37,119.37) 64.36,119.3 arc(64.26,119.09) v1(64.04,119)
  L8 w0.102: v1(64.04,119) 64.07,119 arc(64.1,118.99) 64.13,118.98 64.18,118.92 arc(64.24,118.84) 64.26,118.74 64.26,118.58 arc(64.31,118.33) 64.45,118.12 arc(64.66,117.98) 64.91,117.93 67.5,117.93 arc(67.79,117.99) 68.04,118.16 68.46,118.57 arc(68.7,118.74) 69,118.79 69.6,118.79 arc(69.86,118.74) 70.07,118.6 arc(70.21,118.39) 70.26,118.14 70.26,115.56 arc(70.2,115.27) 70.04,115.02 69.4,114.38 arc(69.17,114.23) 68.9,114.17 68.79,114.17 arc(68.59,114.13) 68.43,114.02 65.32,110.92 arc(65.1,110.59) 65.02,110.2 65.02,109.26 arc(64.97,108.96) 64.8,108.72 61.72,105.63 arc(61.47,105.47) 61.18,105.41 51.57,105.41 arc(51.18,105.33) 50.85,105.11 42.66,96.92 arc(42.44,96.59) 42.37,96.2 42.37,86.17 arc(42.44,85.78) 42.66,85.45 43.16,84.96 arc(43.27,84.79) 43.31,84.6 43.31,82.28 arc(43.27,82.09) 43.16,81.92 42.46,81.23 arc(42.24,80.9) 42.16,80.51 42.16,80.31 arc(42.17,80.26) 42.17,80.21 arc(42.28,79.97) 42.47,79.78 arc(42.66,79.63) v1(42.82,79.44)
  BOTTOM w0.102: v1(42.82,79.44) arc(42.9,79.59) 43.05,79.66 arc(43.19,79.7) 43.31,79.78 43.46,79.94 arc(43.71,80.1) 44,80.16 44.36,80.16 arc(44.56,80.12) 44.72,80.01 45.55,79.19 arc(45.88,78.97) 46.26,78.89 46.38,78.89 arc(46.54,78.85) 46.66,78.74 arc(46.76,78.56) R669.1
