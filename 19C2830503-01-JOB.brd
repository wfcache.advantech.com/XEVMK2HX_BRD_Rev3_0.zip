# Allegro board 19C2830503-01-JOB.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USB_TXN_R: length 4.9
  TOP w0.102: C839.1 162.5,107.15 arc(162.53,107) 162.62,106.88 162.64,106.86 arc(162.78,106.76) 162.96,106.72 163.09,106.72 arc(163.2,106.75) 163.3,106.81 164.52,108.03 arc(164.77,108.2) 165.06,108.25 165.34,108.25 arc(165.45,108.28) 165.54,108.34 arc(165.6,108.43) 165.62,108.54 SOC_USB.8
USB_TXP: length 108.7
  TOP w0.102: U24.U1 75.49,101.42 75.44,101.47 arc(75.4,101.53) 75.39,101.6 75.39,101.94 arc(75.4,102.02) 75.45,102.1 arc(75.53,102.15) 75.61,102.16 v2(76.02,102.16) ; v1(159.66,107.65) 159.66,107.71 arc(159.68,107.77) 159.71,107.82 159.79,107.89 arc(159.92,107.98) 160.08,108.01 160.43,108.01 arc(160.51,108) 160.58,107.95 arc(160.62,107.88) 160.64,107.8 160.64,107.21 arc(160.69,106.97) 160.83,106.76 arc(161.03,106.63) 161.27,106.58 161.36,106.58 arc(161.38,106.58) 161.4,106.58 161.4,106.58 161.42,106.58 161.46,106.58 arc(161.49,106.57) 161.52,106.55 161.55,106.52 arc(161.59,106.46) 161.6,106.39 C840.2
  L10 w0.114: v2(76.02,102.16) arc(75.74,102.31) 75.62,102.59 arc(75.66,102.88) 75.82,103.13 76.69,104 arc(76.69,104.01) 76.7,104.01 arc(76.72,104.05) 76.72,104.09 76.72,105.46 arc(76.77,105.71) 76.91,105.92 arc(77.12,106.06) 77.37,106.11 78.45,106.11 arc(78.78,106.14) 79.1,106.24 79.39,106.36 arc(79.87,106.69) 80.18,107.18 arc(80.21,107.41) 80.33,107.6 80.39,107.66 arc(80.63,107.82) 80.92,107.87 82.61,107.87 arc(83.58,108.07) 84.4,108.62 84.95,109.17 arc(85.08,109.37) 85.13,109.6 arc(85.18,109.86) 85.33,110.08 86.65,111.4 arc(87.47,111.95) 88.44,112.14 89.24,112.14 arc(89.92,112.01) 90.49,111.62 arc(90.94,111.32) 91.48,111.21 arc(91.75,111.27) 91.98,111.42 arc(92.14,111.66) 92.19,111.93 92.19,112.17 arc(92.25,112.46) 92.41,112.71 95.57,115.87 arc(95.72,116.09) 95.77,116.35 arc(95.8,116.49) 95.88,116.6 96.25,116.97 arc(96.71,117.66) 96.87,118.46 96.87,118.7 arc(97.01,119.44) 97.43,120.06 97.74,120.37 arc(97.76,120.39) 97.79,120.39 97.97,120.52 arc(98.04,120.55) 98.11,120.59 98.73,120.85 arc(98.88,120.89) 99.02,120.9 99.69,120.9 arc(100.07,120.98) 100.4,121.2 arc(100.57,121.31) 100.76,121.35 102.94,121.35 arc(103.04,121.32) 103.11,121.24 103.21,121 arc(103.44,120.71) 103.77,120.55 105.08,120.55 arc(105.11,120.55) 105.13,120.54 105.16,120.53 arc(105.21,120.49) 105.24,120.45 105.32,120.29 arc(105.34,120.23) 105.35,120.17 105.35,117.93 arc(105.51,117.11) 105.97,116.42 arc(106.66,115.96) 107.47,115.8 114.66,115.8 arc(114.84,115.78) 115.02,115.73 arc(115.36,115.63) 115.72,115.61 118.34,115.61 119.95,115.61 arc(120.83,115.43) 121.58,114.93 121.61,114.9 arc(122.52,114.3) 123.58,114.08 148.86,114.08 arc(149.74,113.91) 150.48,113.41 151.36,112.54 arc(152.26,111.93) 153.33,111.72 156.03,111.72 arc(156.83,111.56) 157.51,111.11 arc(157.97,110.43) 158.13,109.62 158.13,108.93 arc(158.2,108.59) 158.39,108.3 arc(158.68,108.11) 159.02,108.04 159.18,108.04 arc(159.33,108.01) 159.46,107.92 159.61,107.78 arc(159.65,107.72) v1(159.66,107.65)
USB_TXP_R: length 4.9
  TOP w0.102: C840.1 162.5,106.07 arc(162.53,106.21) 162.61,106.33 162.65,106.37 arc(162.8,106.47) 162.99,106.51 163.09,106.51 arc(163.29,106.55) 163.46,106.66 164.67,107.88 arc(164.85,108) 165.06,108.04 165.36,108.04 arc(165.46,108.02) 165.54,107.96 arc(165.6,107.88) 165.62,107.78 SOC_USB.9
USBDN: length 107.9
  TOP w0.102: v1(159.64,111.02) 159.64,111.08 arc(159.67,111.24) 159.76,111.37 159.82,111.43 arc(159.89,111.48) 159.97,111.49 160.06,111.49 arc(160.25,111.53) 160.41,111.64 arc(160.43,111.65) 160.45,111.66 160.67,111.66 arc(160.84,111.62) 160.99,111.52 161.13,111.39 B24.2 ; U24.T2 76.52,100.67 arc(76.52,100.71) 76.53,100.75 76.55,100.79 arc(76.59,100.85) 76.66,100.89 76.69,100.91 arc(76.73,100.92) 76.77,100.92 v2(77.02,100.92)
  L10 w0.102: 75.55,104.29 75.55,104.26 75.54,104.26 75.54,103.94 arc(75.51,103.78) 75.42,103.64 75,103.23 arc(74.7,102.78) 74.6,102.26 74.6,102.14 arc(74.64,101.95) 74.75,101.78 arc(74.91,101.68) 75.1,101.64 76.3,101.64 arc(76.41,101.62) 76.49,101.56 76.52,101.53 arc(76.6,101.41) 76.63,101.27 76.63,101.12 arc(76.63,101.1) 76.63,101.07 76.63,101.07 76.63,101.02 76.63,101.01 arc(76.64,100.98) 76.66,100.95 arc(76.69,100.93) 76.72,100.92 v2(77.02,100.92)
  L10 w0.114: 75.55,104.29 75.55,104.92 arc(75.74,105.9) 76.29,106.72 77.2,107.63 arc(77.58,107.89) 78.03,107.98 78.51,107.98 arc(79.45,108.16) 80.25,108.69 80.38,108.83 arc(81.21,109.38) 82.18,109.58 82.43,109.58 arc(83.49,109.79) 84.39,110.39 86.41,112.41 arc(87.16,112.91) 88.04,113.08 90.33,113.08 arc(91.48,113.3) 92.46,113.94 94.41,115.9 arc(94.6,116.12) 94.74,116.37 arc(94.8,116.57) 94.82,116.77 94.82,118.2 arc(95.01,119.17) 95.56,120 95.73,120.16 arc(95.92,120.29) 96.14,120.33 arc(96.48,120.4) 96.77,120.59 97.2,121.02 arc(97.97,121.54) 98.87,121.72 99.26,121.72 arc(99.57,121.78) 99.83,121.95 arc(100.09,122.13) 100.4,122.19 103.28,122.19 arc(103.44,122.15) 103.58,122.06 103.6,122.04 arc(103.88,121.86) 104.21,121.79 104.46,121.79 arc(105.05,121.68) 105.54,121.35 105.76,121.12 arc(105.96,120.88) 106.11,120.61 106.14,120.54 arc(106.17,120.42) 106.18,120.3 106.18,118.09 arc(106.29,117.55) 106.6,117.09 arc(107.06,116.78) 107.6,116.67 115.49,116.67 arc(115.57,116.66) 115.63,116.62 arc(115.85,116.47) 116.11,116.42 118.01,116.42 118.01,116.42 120.73,116.42 arc(121.1,116.35) 121.42,116.14 arc(121.89,115.82) 122.45,115.71 138.49,115.71 arc(139.04,115.82) 139.52,116.14 arc(139.83,116.35) 140.2,116.42 150.41,116.42 arc(151.29,116.25) 152.03,115.75 153.53,114.25 arc(154.43,113.65) 155.5,113.44 155.63,113.44 arc(156.51,113.26) 157.25,112.76 158.07,111.94 arc(158.59,111.59) 159.19,111.44 arc(159.49,111.31) v1(159.64,111.02)
USBDN_R: length 11.2
  TOP w0.102: v1(162.79,110.03) 162.66,110.03 arc(162.54,110.06) 162.44,110.12 162.43,110.13 arc(162.36,110.25) 162.33,110.38 162.33,110.53 arc(162.28,110.8) 162.13,111.02 162.08,111.07 arc(161.99,111.21) 161.95,111.38 161.95,111.41 arc(161.97,111.5) 162.03,111.58 arc(162.1,111.63) 162.2,111.65 162.2,111.65 162.3,111.65 162.42,111.65 arc(162.53,111.63) 162.62,111.57 162.73,111.46 arc(162.84,111.39) B24.3
  BOTTOM w0.102: SOC_USB.2 167.12,111.04 arc(167.09,111.2) 167,111.33 arc(166.86,111.42) 166.71,111.46 166.67,111.46 arc(166.45,111.5) 166.27,111.62 165.95,111.94 arc(165.77,112.06) 165.56,112.1 164.8,112.1 arc(164.67,112.08) 164.55,112 arc(164.3,111.83) 164,111.77 163.67,111.77 arc(163.47,111.73) 163.29,111.62 arc(163.12,111.5) 162.92,111.46 D14.2 162.34,111.46 arc(162.27,111.45) 162.21,111.41 arc(162.17,111.35) 162.15,111.28 162.15,111.14 arc(162.18,111.01) 162.25,110.9 arc(162.3,110.85) 162.34,110.79 arc(162.38,110.67) 162.39,110.55 162.39,110.43 arc(162.42,110.31) 162.48,110.21 162.57,110.12 arc(162.67,110.06) v1(162.79,110.03)
USBDP: length 107.8
  TOP w0.102: v2(76.02,100.92) 75.52,100.42 U24.U2 ; v1(159.64,112.04) 159.64,111.93 159.74,111.82 arc(159.87,111.74) 160.01,111.71 160.06,111.71 arc(160.16,111.73) 160.25,111.79 arc(160.35,111.85) 160.45,111.87 160.65,111.87 arc(160.83,111.91) 160.98,112.01 161.13,112.16 B24.1
  L10 w0.102: v2(76.02,100.92) 76.2,100.92 arc(76.28,100.94) 76.34,100.98 arc(76.39,101.05) 76.4,101.12 76.4,101.27 arc(76.39,101.31) 76.37,101.34 76.33,101.38 arc(76.3,101.4) 76.26,101.41 75.1,101.41 arc(74.82,101.47) 74.58,101.62 arc(74.43,101.86) 74.37,102.14 74.37,102.26 arc(74.49,102.87) 74.84,103.39 75.26,103.81 arc(75.31,103.89) 75.31,103.98 arc(75.31,104) 75.31,104.01 arc(75.31,104.14) 75.3,104.26 75.3,104.29
  L10 w0.114: 75.3,104.29 75.3,104.92 arc(75.52,105.99) 76.12,106.89 77.03,107.8 arc(77.49,108.11) 78.03,108.22 78.51,108.22 arc(79.36,108.39) 80.08,108.86 80.21,109 arc(81.12,109.61) 82.18,109.82 82.43,109.82 arc(83.4,110.01) 84.22,110.56 86.24,112.58 arc(87.06,113.13) 88.04,113.32 90.33,113.32 arc(91.39,113.52) 92.29,114.12 94.24,116.07 arc(94.4,116.25) 94.52,116.46 arc(94.56,116.61) 94.58,116.77 94.58,118.2 arc(94.79,119.27) 95.39,120.17 95.56,120.33 arc(95.82,120.51) 96.14,120.57 arc(96.39,120.62) 96.6,120.76 97.03,121.2 arc(97.87,121.76) 98.87,121.96 99.26,121.96 arc(99.48,122) 99.66,122.12 arc(100,122.35) 100.4,122.43 103.28,122.43 arc(103.53,122.38) 103.75,122.23 103.77,122.22 arc(103.97,122.08) 104.21,122.03 104.46,122.03 arc(105.14,121.9) 105.71,121.52 105.93,121.29 arc(106.16,121.02) 106.33,120.7 106.36,120.63 arc(106.41,120.47) 106.43,120.3 106.43,118.09 arc(106.52,117.64) 106.77,117.26 arc(107.15,117.01) 107.6,116.92 115.49,116.92 arc(115.66,116.88) 115.8,116.79 arc(115.94,116.7) 116.11,116.66 117.91,116.66 117.91,116.66 120.73,116.66 arc(121.2,116.57) 121.59,116.31 arc(121.98,116.04) 122.45,115.95 138.49,115.95 arc(138.95,116.04) 139.34,116.31 arc(139.74,116.57) 140.2,116.66 150.41,116.66 arc(151.38,116.47) 152.2,115.92 153.7,114.42 arc(154.52,113.87) 155.5,113.68 155.63,113.68 arc(156.6,113.48) 157.42,112.93 158.24,112.11 arc(158.72,111.8) 159.28,111.68 arc(159.53,111.79) v1(159.64,112.04)
USBDP_R: length 11.2
  TOP w0.102: v1(161.77,110.03) 161.83,110.03 arc(161.88,110.04) 161.93,110.07 162,110.15 arc(162.09,110.27) 162.12,110.42 162.12,110.53 arc(162.08,110.72) 161.98,110.87 161.93,110.92 arc(161.79,111.13) 161.74,111.38 161.74,111.41 arc(161.77,111.58) 161.87,111.73 arc(162.02,111.83) 162.2,111.87 162.3,111.87 162.3,111.87 162.4,111.87 arc(162.48,111.89) 162.56,111.94 162.64,112.02 arc(162.8,112.12) B24.4
  BOTTOM w0.102: SOC_USB.3 167.12,112.04 arc(167.1,111.93) 167.04,111.84 166.99,111.8 arc(166.85,111.7) 166.69,111.67 166.67,111.67 arc(166.53,111.7) 166.42,111.77 166.1,112.1 arc(165.85,112.26) 165.56,112.32 164.8,112.32 arc(164.58,112.28) 164.4,112.15 arc(164.22,112.03) 164,111.99 163.7,111.99 arc(163.59,112.01) 163.49,112.07 arc(163.39,112.14) 163.28,112.16 D14.1 162.55,112.16 arc(162.53,112.16) 162.51,112.14 162.16,111.79 arc(162,111.55) 161.94,111.25 161.94,111.14 arc(161.98,110.93) 162.1,110.75 arc(162.12,110.72) 162.15,110.68 arc(162.17,110.62) 162.18,110.55 162.18,110.47 arc(162.15,110.3) 162.05,110.16 161.98,110.09 arc(161.92,110.05) 161.85,110.03 v1(161.77,110.03)
USBDRVVBUS: length 15.2
  TOP w0.102: U24.L3 81.52,99.42 v2(82.02,99.92)
  BOTTOM w0.102: 84.2,104.01 83.31,103.12 83.31,100.84 82.4,99.92 v2(82.02,99.92)
  BOTTOM w0.127: 84.2,104.01 84.58,104.39 87.63,104.39 90.49,107.25 90.49,107.89 89.97,108.4 R809.1
USBDRVVBUS_R: length 84.6
  L10 w0.114: v1(160.68,102.72) 157.12,102.72 154.37,105.47 154.37,108.14 149.99,112.52 144.02,112.52 143.18,113.36 133.81,113.36 v1(129.67,109.22)
  BOTTOM w0.127: R809.2 92.84,108.71 97.66,113.54 101.85,113.54 104.2,111.19 116.01,111.19 116.46,110.74 121.92,110.74 122.94,109.73 127.51,109.73 128.02,109.22 v1(129.67,109.22) ; U70.2 158.65,102.82 159.34,102.13 R813.1 v1(160.68,102.72)
USBVBUS: length 15.2
  TOP w0.406: R800.2 R799.1 79.27,110.67 80.16,109.78 80.16,107.92 79.83,107.59 v1(79.83,104.9) ; U24.T1 76.53,101.42 76.96,101.85 v2(77.09,101.85)
  BOTTOM w0.406: v2(77.09,101.85) 77.09,104.27 78.23,105.41 79.32,105.41 v1(79.83,104.9)
USBVDD3V3: length 0.6
  TOP w0.381: v2(72.07,89.87) U24.Y13
  vias: v1(37.34,89.03) v1(37.99,89.02) v1(49.89,87.83) v1(49.86,87.15)
VCTCXO_19.2M: length 9.1
  TOP w0.254: OSC3.3 56.05,119.89 58.04,119.89 58.15,120 58.15,120.34 58.32,120.51 58.66,120.51 58.92,120.77 58.92,123.57 TP37.1 58.86,123.64 CN13.2
VCTCXO_19.2M_R: length 2.8
  TOP w0.127: U14.11 55.23,126.6 56.29,125.54 CN13.1
VCTCXO_25M_CLKN: length 6.3
  TOP w0.102: R229.2 98.04,123.06 TP36.1 ; R229.2 99.31,122.74 99.31,122.1 99.08,121.86 C121.2 ; R229.2 98.99,123.59 98.6,123.97 98.6,124.59 98.41,124.78 CN11.2
VCTCXO_25M_CLKN_C: length 5.1
  TOP w0.102: C121.1 99.26,120.38 99.26,118.11 99.47,117.91 99.85,117.91 100.15,117.6 OSC2.5
VCTCXO_25M_CLKN_R: length 15.8
  TOP w0.102: v1(96.4,123.06) 96.12,122.78 95.73,122.78 95.38,123.14 95.38,126.64 96.22,127.48 98.37,127.48 98.53,127.33 98.53,127.23 98.42,127.13 97.05,127.13 96.98,127.05 CN11.1 ; U19.12 93.32,121.39 93.42,121.49 93.42,122.12 93.5,122.2 v1(93.83,122.2)
  BOTTOM w0.102: v1(93.83,122.2) 94.1,121.92 94.41,121.92 95.28,122.8 96.14,122.8 v1(96.4,123.06)
VCTCXO_25M_CLKP: length 6.2
  TOP w0.102: R229.1 100.71,123.06 TP34.1 ; R229.1 99.57,122.74 99.57,122.1 99.8,121.86 C122.2 ; R229.1 99.89,123.71 99.69,123.9 99.03,123.9 98.86,124.08 98.86,124.49 99.15,124.78 CN12.2
VCTCXO_25M_CLKP_C: length 5.1
  TOP w0.102: C122.1 99.52,120.4 99.52,118.22 99.57,118.16 99.9,118.16 99.97,118.24 99.97,118.64 100.2,118.87 OSC2.4
VCTCXO_25M_CLKP_R: length 15.7
  TOP w0.102: v1(93.85,121.56) 93.43,121.14 93.22,121.14 92.98,120.89 U19.11 ; v1(96.39,122.43) 96.29,122.53 95.63,122.53 95.12,123.03 95.12,126.75 96.11,127.74 98.48,127.74 98.93,127.28 99.44,127.28 99.85,126.88 99.85,126.86 CN12.1
  BOTTOM w0.102: v1(93.85,121.56) 93.96,121.67 94.52,121.67 95.39,122.54 96.28,122.54 v1(96.39,122.43)
VID_OEZ: length 237.9
  TOP w0.127: v1(135.76,115.06) 136.09,115.39 R262.1 ; U37.14 34.84,49.53 34.71,49.4 34.32,49.4 34.19,49.53 U37.15 34.19,51.16 33.53,51.82 32.63,51.82 32.09,52.35 32.09,54.78 30.88,55.99 v1(30.86,55.99) 30.71,55.99 30.3,55.57 R407.1
  L8 w0.114: v1(30.86,55.99) 29.8,54.92 29.8,50.24 24.71,45.15 24.71,36.76 30.38,31.08 135.79,31.08 138.92,34.21 138.92,49.55 137.39,51.08 137.39,52.01 135.74,53.66 135.74,82.06 133.73,84.07 133.73,105.52 133.74,105.53 133.74,105.9 133.73,105.91 133.73,113.03 v1(135.76,115.06)
VPHY1: length 6.9
  TOP w0.254: U3.4 161.18,163.1 C25.1 C26.1 164.46,162.49 B6.2
VPLL1: length 7
  TOP w0.254: B5.2 164.59,164.52 C21.1 C20.1 160.59,165.6 U3.9
VPP1V8: length 177.4
  TOP w0.254: 107.16,165.74 107.65,165.74 107.83,165.55 Q2.9
  TOP w0.381: v2(81.94,79.9) 81.94,80 U24.L22 U24.M21 ; R234.2 122.17,120.9 121.95,121.13 120.67,121.13 v3(120.11,120.56)
  L3 w1.016: v1(106.17,167.64) 104.25,165.72 104.25,159.26 105.31,158.2 105.31,149.34 107.47,147.19 108.42,147.19 111.3,144.31 111.3,141.53 112.32,140.51 112.32,135.08 119.63,127.76 119.63,125.86 120.11,125.39 v3(120.11,120.56) 120.16,120.51 120.16,115.1 120.19,115.06 v3(120.19,115.04) 120.19,114.99 120.55,114.63 v3(121.16,114.63)
  L5 w1.016: v3(120.19,115.04) 120.19,115.06 120.62,114.63 v3(121.16,114.63) 121.59,114.63 122.1,114.12 125.84,114.12 127.61,112.35 127.61,109.25 126.62,108.25 126.62,84.39 125.58,83.35 125.58,71.6 126.24,70.94 126.24,66.4 125.58,65.74 125.58,57.25 124.54,56.21 123.34,56.21 122.35,55.23 122.35,49.17 120.75,47.57 108.97,47.57 105.87,50.67 98.15,50.67 95.12,53.7 95.12,53.9 v1(94.74,54.28) v1(93.85,54.28)
  BOTTOM w0.381: C392.1 105.79,167.26 v1(106.17,167.64) ; C632.1 81.37,80.47 v2(81.94,79.9)
VPP1V8_MON: length 4.4
  TOP w0.254: R234.1 124.08,121.47 124.08,122.91 124.77,123.6 U13.46
WARM_RESETZ: length 56.1
  TOP w0.127: R233.2 C120.1 R217.1 170.87,124.73 v1(170.87,124.73) ; v1(162.05,153.24) 161.06,152.25 158.28,152.25 157.76,151.73 157.76,151.73 153.35,147.32 149.66,147.32 149.03,146.69 U7.14
  BOTTOM w0.127: v1(170.87,124.73) 173,126.86 173,141.76 169.29,145.47 169.29,149.33 165.59,153.03 162.25,153.03 v1(162.05,153.24)
ZD3_AIF0_RXN: length 84.1
  L3 w0.089: J2.E1 18.17,140.81 arc(18.26,140.79) 18.34,140.74 arc(18.4,140.66) 18.41,140.56 18.41,140.34 arc(18.45,140.15) 18.56,139.98 arc(18.73,139.87) 18.93,139.83 25.22,139.83 arc(25.45,139.79) 25.65,139.66 26.22,139.08 arc(26.27,139.01) 26.28,138.93 26.28,118.21 arc(26.29,118.12) 26.32,118.03 26.34,117.98 arc(26.38,117.9) 26.44,117.83 32.82,111.45 arc(32.98,111.22) 33.03,110.93 33.03,110.93 33.03,109.02 arc(33.12,108.56) 33.38,108.17 34.06,107.49 34.93,106.62 arc(35.09,106.39) 35.14,106.12 35.14,92.25 arc(35.08,91.96) 34.92,91.71 34.15,90.95 arc(33.82,90.45) 33.71,89.87 33.71,88.77 arc(33.77,88.44) 33.96,88.17 36.62,85.5 arc(37.02,85.23) 37.49,85.14 38.79,85.14 arc(39.16,85.22) 39.48,85.43 39.89,85.83 arc(40.06,86.09) 40.12,86.4 40.12,86.47 arc(40.14,86.55) 40.18,86.61 arc(40.36,86.73) v1(40.56,86.79)
  BOTTOM w0.102: v1(40.56,86.79) arc(40.28,86.75) 40.16,86.49 arc(40.12,86.23) 39.98,86 39.63,85.66 arc(39.47,85.41) 39.41,85.12 39.41,85.04 arc(39.47,84.75) 39.63,84.5 39.73,84.4 arc(39.98,84.23) 40.27,84.18 41.65,84.18 arc(41.94,84.12) 42.18,83.95 43.87,82.27 arc(44.12,82.1) 44.41,82.04 46.27,82.04 arc(46.64,82.19) C233.2
ZD3_AIF0_RXP: length 84.1
  L3 w0.089: v1(39.55,86.79) 39.64,86.79 arc(39.74,86.77) 39.83,86.72 arc(39.88,86.63) 39.9,86.53 39.9,86.4 arc(39.86,86.18) 39.73,85.99 39.33,85.58 arc(39.08,85.41) 38.79,85.36 37.49,85.36 arc(37.1,85.43) 36.78,85.65 34.11,88.32 arc(33.97,88.53) 33.92,88.77 33.92,89.86 arc(34.02,90.37) 34.31,90.8 35.07,91.56 arc(35.28,91.88) 35.36,92.25 35.36,106.12 arc(35.29,106.47) 35.09,106.77 34.21,107.65 33.54,108.32 arc(33.32,108.64) 33.25,109.02 33.25,110.93 arc(33.18,111.3) 32.97,111.61 26.6,117.98 arc(26.56,118.02) 26.54,118.06 26.52,118.11 arc(26.5,118.16) 26.5,118.21 26.5,138.93 arc(26.47,139.09) 26.37,139.24 26.04,139.57 25.8,139.81 arc(25.54,139.99) 25.22,140.05 18.93,140.05 arc(18.81,140.07) 18.72,140.13 arc(18.65,140.23) 18.63,140.34 18.63,140.34 18.63,140.55 arc(18.65,140.63) 18.72,140.69 arc(18.95,140.77) J2.F1
  BOTTOM w0.102: C235.2 46.79,81.6 arc(46.78,81.67) 46.74,81.73 arc(46.68,81.78) 46.6,81.79 44.41,81.79 arc(44.02,81.87) 43.69,82.09 42,83.77 arc(41.84,83.88) 41.65,83.92 40.27,83.92 arc(39.88,84) 39.55,84.22 39.45,84.32 arc(39.23,84.65) 39.15,85.04 39.15,85.12 arc(39.23,85.51) 39.45,85.84 39.8,86.18 arc(39.88,86.31) 39.9,86.47 arc(39.79,86.7) v1(39.55,86.79)
ZD3_AIF0_TXN: length 92.8
  TOP w0.102: v2(58.02,84.92) 58.52,85.42 U24.AP17
  L3 w0.089: J2.E2 18.15,143.31 arc(18.28,143.34) 18.39,143.41 arc(18.47,143.52) 18.49,143.65 18.49,143.96 arc(18.52,144.11) 18.6,144.23 18.74,144.37 arc(18.99,144.53) 19.28,144.59 24.35,144.59 arc(24.84,144.49) 25.25,144.22 25.37,144.1 arc(25.65,143.69) 25.74,143.2 25.74,142.44 arc(25.76,142.36) 25.8,142.29 28.05,140.05 arc(28.11,139.96) 28.13,139.87 28.13,119.09 arc(28.17,118.88) 28.29,118.7 36.62,110.38 arc(36.83,110.06) 36.9,109.68 36.9,103.6 arc(36.84,103.31) 36.68,103.06 36.6,102.98 arc(36.43,102.73) 36.37,102.44 36.37,89.19 arc(36.43,88.9) 36.6,88.65 36.91,88.34 arc(37.15,88.17) 37.45,88.12 40.22,88.12 40.23,88.13 40.77,88.13 40.85,88.05 41.2,87.85 43.34,85.71 arc(43.52,85.59) 43.72,85.55 57.02,85.55 arc(57.25,85.5) 57.44,85.38 57.44,85.37 arc(57.56,85.19) 57.61,84.97 57.61,84.78 arc(57.62,84.72) 57.66,84.66 57.7,84.61 arc(57.72,84.6) 57.75,84.59 arc(57.96,84.7) v2(58.02,84.92)
ZD3_AIF0_TXP: length 92.8
  TOP w0.102: v2(58.02,83.92) 58.02,84.32 58.12,84.42 U24.AP18
  L3 w0.089: v2(58.02,83.92) 58.02,84.12 arc(58,84.22) 57.94,84.3 arc(57.86,84.36) 57.76,84.38 arc(57.75,84.38) 57.75,84.38 arc(57.64,84.4) 57.55,84.46 57.5,84.51 arc(57.42,84.63) 57.39,84.78 57.39,84.97 arc(57.36,85.1) 57.29,85.22 57.28,85.22 arc(57.16,85.3) 57.02,85.33 43.72,85.33 arc(43.43,85.39) 43.19,85.55 41.06,87.68 40.71,87.88 40.68,87.91 40.32,87.91 40.31,87.9 37.45,87.9 arc(37.07,87.97) 36.75,88.19 36.44,88.5 arc(36.23,88.81) 36.16,89.19 36.16,102.44 arc(36.23,102.81) 36.44,103.13 36.53,103.21 arc(36.64,103.39) 36.69,103.6 36.69,109.68 arc(36.63,109.98) 36.46,110.22 28.13,118.55 arc(27.97,118.8) 27.91,119.09 27.91,139.87 arc(27.91,139.88) 27.9,139.89 25.65,142.14 arc(25.56,142.28) 25.53,142.44 25.53,143.2 arc(25.45,143.6) 25.22,143.94 25.1,144.06 arc(24.76,144.29) 24.35,144.37 19.28,144.37 arc(19.07,144.33) 18.89,144.21 18.76,144.08 arc(18.72,144.03) 18.71,143.96 18.71,143.65 arc(18.73,143.52) 18.81,143.41 arc(18.92,143.34) 19.05,143.31 J2.F2
ZD3_AIF1_RXN: length 82.5
  L3 w0.089: v1(40.46,92.63) 40.26,92.63 arc(40.19,92.65) 40.13,92.69 arc(40.08,92.76) 40.07,92.83 40.07,92.84 40.07,92.84 arc(40.07,92.86) 40.07,92.88 40.07,92.97 arc(40.04,93.09) 39.97,93.2 39.92,93.26 arc(39.75,93.37) 39.55,93.41 38.96,93.41 arc(38.67,93.47) 38.42,93.63 37.49,94.57 arc(37.32,94.82) 37.26,95.11 37.26,101.72 arc(37.29,101.87) 37.38,102 37.43,102.06 37.49,102.11 arc(37.66,102.36) 37.71,102.65 37.71,110.05 arc(37.64,110.42) 37.43,110.74 29.1,119.07 arc(28.98,119.25) 28.94,119.45 28.94,136.86 arc(29,137.14) 29.16,137.39 arc(29.25,137.53) 29.29,137.7 29.29,138.16 arc(29.26,138.29) 29.18,138.41 29.08,138.51 arc(29.03,138.59) 29.01,138.69 29.01,140.23 arc(28.99,140.33) 28.93,140.41 26.63,142.71 arc(26.58,142.79) 26.56,142.89 26.56,143.84 arc(26.5,144.11) 26.35,144.34 26.19,144.5 arc(26.14,144.57) 26.12,144.66 26.12,145.6 arc(26.01,146.17) 25.69,146.65 25.57,146.77 arc(25.09,147.09) 24.52,147.21 19.18,147.21 arc(18.92,147.15) 18.69,147 18.69,147 arc(18.54,146.78) 18.49,146.51 18.49,146.06 arc(18.42,145.88) 18.25,145.81 J2.E3
  BOTTOM w0.102: C577.2 46.79,85.87 arc(46.77,85.77) 46.72,85.68 arc(46.63,85.62) 46.53,85.6 44.46,85.6 arc(44.26,85.64) 44.1,85.75 42.24,87.61 arc(42.13,87.77) 42.09,87.97 42.09,90.92 arc(42.03,91.21) 41.87,91.46 41.8,91.52 arc(41.56,91.69) 41.26,91.74 40.4,91.74 arc(40.27,91.77) 40.16,91.85 40.12,91.88 arc(40.12,91.89) 40.12,91.89 40.06,92.02 arc(40.06,92.03) 40.06,92.05 40.06,92.24 arc(40.09,92.39) 40.17,92.52 40.22,92.57 arc(40.29,92.62) 40.37,92.63 v1(40.46,92.63)
ZD3_AIF1_RXP: length 82.5
  L3 w0.089: J2.F3 18.99,145.81 arc(18.88,145.83) 18.79,145.89 arc(18.73,145.98) 18.71,146.09 18.71,146.51 arc(18.74,146.69) 18.85,146.85 arc(19,146.95) 19.18,146.99 24.52,146.99 arc(25,146.89) 25.42,146.62 25.54,146.5 arc(25.81,146.09) 25.91,145.6 25.91,144.65 arc(25.94,144.49) 26.04,144.35 26.2,144.19 arc(26.3,144.03) 26.34,143.84 26.34,143.84 26.34,142.89 arc(26.38,142.71) 26.48,142.56 28.78,140.26 arc(28.79,140.24) 28.79,140.23 28.79,138.69 arc(28.83,138.51) 28.93,138.35 29.03,138.25 arc(29.06,138.21) 29.07,138.16 29.07,137.7 arc(29.05,137.61) 29.01,137.54 arc(28.8,137.23) 28.72,136.86 28.72,119.45 arc(28.78,119.16) 28.95,118.92 37.28,110.59 arc(37.44,110.34) 37.5,110.05 37.5,102.65 arc(37.46,102.44) 37.34,102.27 37.28,102.21 37.22,102.15 arc(37.09,101.95) 37.05,101.72 37.05,95.11 arc(37.12,94.73) 37.33,94.42 38.27,93.48 arc(38.59,93.27) 38.96,93.19 39.55,93.19 arc(39.66,93.17) 39.76,93.1 39.82,93.05 arc(39.84,93.01) 39.85,92.97 39.85,92.88 arc(39.84,92.79) 39.79,92.72 39.78,92.71 arc(39.69,92.65) 39.59,92.63 v1(39.45,92.63)
  BOTTOM w0.102: v1(39.45,92.63) 39.51,92.63 arc(39.57,92.62) 39.62,92.59 39.69,92.52 arc(39.77,92.39) 39.8,92.24 39.8,92.05 arc(39.81,91.99) 39.83,91.93 39.88,91.79 arc(39.91,91.75) 39.94,91.7 39.98,91.67 arc(40.17,91.54) 40.4,91.49 41.26,91.49 arc(41.46,91.45) 41.62,91.34 41.69,91.28 arc(41.8,91.11) 41.84,90.92 41.84,87.97 arc(41.89,87.68) 42.06,87.43 43.92,85.57 arc(44.17,85.4) 44.46,85.35 46.43,85.35 arc(46.57,85.32) 46.69,85.24 arc(46.77,85.12) 46.79,84.98 C589.2
ZD3_AIF1_TXN: length 94.6
  TOP w0.102: v2(57.99,85.85) 57.99,85.85 57.52,86.32 U24.AR16
  L10 w0.089: v2(57.99,85.85) 57.88,85.96 arc(57.83,86.04) 57.81,86.14 57.81,86.21 arc(57.82,86.25) 57.84,86.29 arc(57.88,86.31) 57.92,86.32 60.13,86.32 arc(60.23,86.34) 60.31,86.4 60.54,86.63 arc(60.6,86.71) 60.62,86.81 60.62,96.69 60.59,96.72 60.59,97.42 arc(60.57,97.52) 60.51,97.6 57.7,100.41 arc(57.62,100.47) 57.52,100.49 56.74,100.49 arc(56.55,100.52) 56.39,100.63 55.9,101.13 55.38,101.64 arc(55.2,101.76) 54.99,101.8 arc(54.4,101.92) 53.91,102.25 50.21,105.95 arc(49.81,106.22) 49.34,106.31 44.46,106.31 arc(44.16,106.37) 43.9,106.55 32.02,118.42 arc(31.8,118.75) 31.72,119.14 31.72,123.39 arc(31.66,123.72) 31.47,124 29.34,126.13 arc(29.12,126.46) 29.04,126.85 29.04,133.07 arc(28.97,133.46) 28.75,133.79 27.97,134.57 arc(27.75,134.9) 27.67,135.29 27.67,147.91 arc(27.59,148.3) 27.37,148.63 26.55,149.45 arc(26.22,149.67) 25.83,149.75 19.25,149.75 arc(18.61,149.47) 18.38,148.8 arc(18.28,148.48) J2.E4
ZD3_AIF1_TXP: length 94.8
  TOP w0.102: U24.AR17 57.61,85.51 57.61,85.87 57.45,86.03 v2(57.05,86.03)
  L10 w0.089: v2(57.05,86.03) arc(57.05,86.01) 57.07,85.99 arc(57.13,85.94) 57.21,85.93 57.48,85.93 arc(57.53,85.94) 57.57,85.96 arc(57.59,86) 57.59,86.03 57.59,86.21 arc(57.62,86.34) 57.69,86.44 arc(57.8,86.51) 57.92,86.54 60.13,86.54 arc(60.15,86.54) 60.16,86.55 60.39,86.78 arc(60.4,86.79) 60.4,86.81 60.4,96.58 arc(60.4,96.6) 60.39,96.61 60.37,96.63 60.37,97.42 arc(60.37,97.44) 60.36,97.45 57.55,100.26 arc(57.54,100.27) 57.52,100.27 56.74,100.27 arc(56.47,100.32) 56.24,100.48 55.74,100.97 55.23,101.49 arc(55.12,101.56) 54.99,101.59 arc(54.32,101.72) 53.75,102.1 50.06,105.8 arc(49.73,106.02) 49.34,106.1 44.46,106.1 arc(44.07,106.17) 43.74,106.39 31.87,118.27 arc(31.6,118.67) 31.51,119.14 31.51,123.13 31.51,123.39 arc(31.46,123.64) 31.32,123.85 29.19,125.98 arc(28.92,126.38) 28.83,126.85 28.83,133.07 arc(28.77,133.37) 28.59,133.63 27.81,134.42 arc(27.55,134.82) 27.45,135.29 27.45,147.91 arc(27.39,148.21) 27.22,148.47 26.4,149.3 arc(26.14,149.47) 25.83,149.53 19.25,149.53 arc(18.77,149.32) 18.59,148.82 arc(18.79,148.44) J2.F4
ZD3_AIF2_RXN: length 87.3
  L3 w0.089: v1(40.63,90.88) arc(40.35,90.92) 40.21,91.16 arc(40.23,91.37) 40.34,91.55 arc(40.56,91.69) 40.82,91.74 arc(41.08,91.8) 41.29,91.94 41.55,92.19 arc(41.71,92.44) 41.77,92.73 41.77,99.42 arc(41.71,99.71) 41.55,99.96 39.89,101.61 arc(39.73,101.86) 39.67,102.15 39.67,110.34 arc(39.56,110.88) 39.25,111.34 31.49,119.1 arc(31.48,119.12) 31.47,119.15 arc(31.47,119.15) 31.47,119.16 arc(31.47,119.17) 31.47,119.18 30.88,120.59 arc(30.84,120.73) 30.82,120.88 30.82,124.76 arc(30.9,125.13) 31.1,125.44 31.89,126.23 arc(32.04,126.44) 32.09,126.7 32.09,134.22 arc(31.97,134.8) 31.65,135.28 arc(31.39,135.66) 31.31,136.11 31.31,136.11 31.31,139.62 arc(31.16,140.34) 30.76,140.95 28.96,142.75 arc(28.67,143.17) 28.57,143.67 28.57,143.86 arc(28.48,144.36) 28.19,144.78 28.12,144.85 arc(27.99,145.05) 27.94,145.29 27.94,148.26 arc(27.85,148.73) 27.58,149.12 27.35,149.36 arc(27.19,149.59) 27.14,149.86 27.14,150.37 arc(27.08,150.69) 26.9,150.95 26.19,151.66 arc(25.64,152.03) 24.99,152.16 19.2,152.16 arc(18.66,151.93) 18.45,151.37 arc(18.45,151.29) 18.41,151.21 arc(18.24,150.98) J2.E5
  BOTTOM w0.102: v1(40.63,90.88) 40.47,90.88 arc(40.38,90.86) 40.31,90.8 40.29,90.78 arc(40.25,90.7) 40.23,90.61 40.23,89.55 arc(40.27,89.35) 40.38,89.19 40.91,88.66 arc(41.13,88.33) 41.2,87.94 41.2,87.59 arc(41.24,87.39) 41.35,87.23 43.07,85.51 arc(43.29,85.18) 43.37,84.79 43.37,84.24 arc(43.39,84.12) 43.46,84.02 43.51,83.98 arc(43.66,83.88) 43.84,83.85 arc(44.2,83.99) C590.2
ZD3_AIF2_RXP: length 87.3
  L3 w0.089: v1(39.61,90.88) arc(39.88,90.89) 39.99,91.13 arc(40.03,91.44) 40.19,91.7 arc(40.48,91.89) 40.82,91.96 arc(40.99,92) 41.14,92.09 41.39,92.35 arc(41.51,92.52) 41.55,92.73 41.55,99.42 arc(41.51,99.63) 41.39,99.8 39.74,101.46 arc(39.53,101.78) 39.45,102.15 39.45,110.34 arc(39.36,110.8) 39.1,111.19 31.34,118.95 arc(31.28,119.03) 31.26,119.12 30.68,120.51 arc(30.63,120.69) 30.61,120.88 30.61,124.76 arc(30.7,125.21) 30.95,125.59 31.74,126.38 arc(31.84,126.53) 31.87,126.69 31.87,134.22 arc(31.77,134.71) 31.5,135.13 arc(31.2,135.58) 31.09,136.11 31.09,139.62 arc(30.96,140.26) 30.61,140.79 28.8,142.6 arc(28.47,143.09) 28.36,143.67 28.36,143.86 arc(28.28,144.28) 28.04,144.63 27.97,144.7 arc(27.79,144.97) 27.73,145.29 27.73,148.26 arc(27.65,148.65) 27.43,148.97 27.19,149.21 arc(26.99,149.51) 26.92,149.86 26.92,150.37 arc(26.88,150.6) 26.74,150.8 26.04,151.51 arc(25.56,151.83) 24.99,151.94 19.2,151.94 arc(18.82,151.78) 18.67,151.38 arc(18.83,151) J2.F5
  BOTTOM w0.102: C596.2 44.31,83.48 arc(44.29,83.53) 44.25,83.57 arc(44.2,83.6) 44.14,83.6 43.85,83.59 arc(43.57,83.64) 43.33,83.8 43.28,83.84 arc(43.16,84.02) 43.12,84.24 43.12,84.79 43.12,84.79 arc(43.06,85.08) 42.89,85.33 41.17,87.05 arc(41.01,87.29) 40.95,87.59 40.95,87.94 arc(40.89,88.24) 40.73,88.48 40.2,89.01 arc(40.04,89.25) 39.98,89.55 39.98,90.37 arc(39.88,90.69) v1(39.61,90.88)
ZD3_AIF2_TXN: length 96.4
  TOP w0.102: v2(56.01,87.91) 56.03,87.91 U24.AT15
  L3 w0.089: v2(56.01,87.91) 56.01,87.81 arc(55.99,87.74) 55.95,87.67 arc(55.89,87.63) 55.81,87.62 55.75,87.62 arc(55.55,87.58) 55.38,87.46 54.65,86.74 arc(54.48,86.62) 54.27,86.58 53.64,86.58 arc(53.35,86.63) 53.1,86.8 52.78,87.13 arc(52.61,87.37) 52.55,87.67 52.55,89.02 arc(52.49,89.31) 52.33,89.56 51.89,89.99 arc(51.85,90.03) 51.82,90.06 arc(51.6,90.18) 51.35,90.22 43.73,90.22 arc(43.44,90.28) 43.19,90.44 42.81,90.82 arc(42.64,91.07) 42.58,91.36 42.58,99.98 arc(42.53,100.27) 42.36,100.52 40.71,102.17 arc(40.54,102.42) 40.48,102.71 40.48,110.9 arc(40.41,111.28) 40.2,111.6 32.37,119.42 arc(32.28,119.53) 32.21,119.67 31.69,120.91 arc(31.65,121.06) 31.64,121.2 31.64,124.63 arc(31.66,124.77) 31.74,124.88 31.88,125.02 32.62,125.76 arc(32.83,126.07) 32.9,126.44 32.9,134.66 arc(32.81,135.13) 32.54,135.53 32.38,135.69 arc(32.19,135.97) 32.13,136.3 32.13,140.43 arc(32.08,140.7) 31.93,140.92 31.62,141.23 arc(31.48,141.43) 31.43,141.68 31.43,142.06 arc(31.32,142.61) 31.01,143.07 30.35,143.74 30.07,144.02 29.06,145.02 arc(28.83,145.37) 28.75,145.77 28.75,148.75 arc(28.64,149.31) 28.33,149.78 arc(28.11,150.11) 28.03,150.5 28.03,150.93 arc(27.93,151.43) 27.65,151.85 25.32,154.19 arc(24.83,154.51) 24.26,154.62 19.23,154.62 arc(18.79,154.49) 18.52,154.12 arc(18.47,153.94) 18.45,153.74 arc(18.32,153.43) J2.E6
ZD3_AIF2_TXP: length 96.5
  TOP w0.102: v2(55.96,87) 56.24,87 56.52,86.71 U24.AT16
  L3 w0.089: v2(55.96,87) 55.96,87.27 arc(55.95,87.32) 55.92,87.36 arc(55.88,87.39) 55.83,87.4 55.75,87.4 55.75,87.4 arc(55.64,87.38) 55.54,87.31 54.81,86.58 arc(54.56,86.42) 54.27,86.36 53.64,86.36 arc(53.27,86.43) 52.95,86.65 52.62,86.97 arc(52.41,87.29) 52.34,87.67 52.34,89.02 arc(52.3,89.23) 52.18,89.4 51.74,89.84 arc(51.71,89.87) 51.68,89.89 arc(51.53,89.97) 51.35,90 43.73,90 arc(43.35,90.08) 43.04,90.29 42.65,90.67 arc(42.44,90.99) 42.37,91.36 42.37,99.98 arc(42.33,100.19) 42.21,100.36 40.55,102.02 arc(40.34,102.33) 40.27,102.71 40.27,110.9 arc(40.21,111.2) 40.04,111.44 32.22,119.27 arc(32.1,119.41) 32.01,119.58 31.49,120.83 arc(31.44,121.01) 31.42,121.2 31.42,124.63 arc(31.46,124.85) 31.59,125.04 31.72,125.17 32.46,125.91 arc(32.63,126.15) 32.68,126.44 32.68,134.66 arc(32.61,135.05) 32.38,135.38 32.23,135.54 arc(31.99,135.89) 31.91,136.3 31.91,140.43 arc(31.88,140.61) 31.77,140.77 31.47,141.07 arc(31.28,141.35) 31.22,141.68 31.22,142.06 arc(31.12,142.53) 30.86,142.92 28.91,144.87 arc(28.64,145.28) 28.54,145.77 28.54,148.75 arc(28.44,149.22) 28.18,149.62 arc(27.91,150.03) 27.81,150.5 27.81,150.93 arc(27.73,151.35) 27.5,151.7 25.16,154.03 arc(24.75,154.31) 24.26,154.41 19.23,154.41 arc(18.92,154.31) 18.72,154.05 arc(18.68,153.9) 18.67,153.75 arc(18.83,153.4) J2.F6
ZD3_AIF3_RXN: length 88.1
  L3 w0.089: v1(45.09,90.98) 45.05,90.98 arc(45.01,90.99) 44.98,91.01 44.84,91.15 arc(44.72,91.33) 44.68,91.55 44.68,92.56 arc(44.6,92.93) 44.39,93.25 43.56,94.09 arc(43.44,94.26) 43.4,94.47 43.4,100.48 arc(43.34,100.78) 43.17,101.02 41.52,102.68 arc(41.35,102.92) 41.3,103.22 41.3,111.73 arc(41.24,112.02) 41.07,112.27 38.76,114.58 arc(38.39,115.43) 38.26,116.36 38.26,122.19 arc(38.19,122.57) 37.98,122.88 33.87,126.99 arc(33.75,127.16) 33.71,127.37 33.71,135.19 arc(33.64,135.53) 33.45,135.81 arc(33.07,136.38) 32.94,137.05 32.94,140.72 arc(32.86,141.12) 32.64,141.45 32.55,141.54 arc(32.4,141.77) 32.35,142.04 32.35,143.19 arc(32.26,143.64) 32,144.02 29.84,146.18 arc(29.64,146.48) 29.57,146.85 29.57,150.72 arc(29.45,151.29) 29.13,151.77 26.29,154.61 arc(26.11,154.88) 26.05,155.2 26.05,155.63 arc(25.93,156.2) 25.61,156.68 25.53,156.77 arc(25.04,157.09) 24.48,157.21 19.3,157.21 arc(18.75,156.99) 18.5,156.45 18.49,156.28 18.5,156.17 arc(18.48,156.07) 18.41,155.98 arc(18.22,155.86) J2.E7
  BOTTOM w0.102: C227.2 44.38,87.65 arc(44.36,87.52) 44.28,87.41 44.25,87.38 arc(44.18,87.33) 44.09,87.31 43.99,87.31 arc(43.84,87.34) 43.71,87.43 43.12,88.02 arc(43.01,88.19) 42.97,88.38 42.97,89.59 arc(43,89.76) 43.1,89.91 arc(43.25,90.01) 43.42,90.04 44.16,90.04 arc(44.36,90.08) 44.52,90.19 44.56,90.23 arc(44.67,90.39) 44.7,90.58 44.7,90.77 arc(44.83,90.99) v1(45.09,90.98)
ZD3_AIF3_RXP: length 88.1
  L3 w0.089: v1(44.07,90.98) arc(44.14,91) 44.2,91.04 44.24,91.08 arc(44.4,91.32) 44.46,91.62 44.46,92.56 arc(44.4,92.85) 44.24,93.1 43.4,93.93 arc(43.24,94.18) 43.18,94.47 43.18,100.48 arc(43.14,100.69) 43.02,100.87 41.37,102.52 arc(41.15,102.84) 41.08,103.22 41.08,111.73 arc(41.04,111.94) 40.92,112.12 38.68,114.35 arc(38.62,114.4) 38.58,114.47 arc(38.18,115.38) 38.05,116.36 38.05,122.19 arc(37.99,122.48) 37.82,122.73 33.72,126.83 arc(33.55,127.08) 33.5,127.37 33.5,135.18 33.5,135.19 arc(33.44,135.44) 33.3,135.66 arc(32.87,136.3) 32.73,137.05 32.73,140.64 32.73,140.72 arc(32.66,141.04) 32.49,141.3 32.4,141.39 arc(32.2,141.68) 32.13,142.04 32.13,143.19 arc(32.06,143.56) 31.85,143.87 29.69,146.02 arc(29.44,146.4) 29.35,146.85 29.35,150.72 29.35,150.72 arc(29.25,151.2) 28.98,151.62 26.14,154.45 arc(25.91,154.8) 25.83,155.2 25.83,155.63 arc(25.74,156.12) 25.46,156.53 25.37,156.62 arc(24.96,156.89) 24.48,156.99 19.3,156.99 arc(18.9,156.83) 18.72,156.44 18.71,156.26 arc(18.85,155.92) J2.F7
  BOTTOM w0.102: C229.2 44.38,86.87 arc(44.37,86.94) 44.33,87 44.29,87.04 arc(44.27,87.05) 44.24,87.06 44.21,87.06 arc(44.21,87.06) 44.21,87.06 44.16,87.06 44.16,87.06 arc(44.12,87.06) 44.09,87.06 43.99,87.06 arc(43.74,87.11) 43.53,87.25 42.94,87.84 arc(42.77,88.09) 42.71,88.38 42.71,89.59 arc(42.77,89.86) 42.92,90.09 arc(43.15,90.24) 43.42,90.3 44.16,90.3 arc(44.26,90.32) 44.34,90.37 44.38,90.41 arc(44.43,90.49) 44.45,90.58 44.45,90.77 arc(44.43,90.85) 44.39,90.92 arc(44.32,90.97) 44.23,90.98 v1(44.07,90.98)
ZD3_AIF3_TXN: length 97.4
  TOP w0.102: U24.AP14 58.52,88.42 58.01,88.93 v2(58.01,89)
  L3 w0.089: v2(58.01,89) 58.01,88.83 arc(57.99,88.71) 57.92,88.61 arc(57.82,88.54) 57.7,88.51 54.74,88.51 arc(54.53,88.56) 54.35,88.67 52.2,90.82 arc(52.06,90.94) 51.9,91.03 arc(51.86,91.05) 51.82,91.06 arc(51.67,91.1) 51.51,91.11 49.26,91.11 arc(48.97,91.17) 48.72,91.33 47.45,92.6 arc(47.29,92.85) 47.23,93.14 47.23,97.94 arc(47.17,98.24) 47.01,98.48 42.39,103.1 arc(42.22,103.35) 42.16,103.64 42.16,112.1 arc(42.1,112.4) 41.94,112.65 arc(41.79,112.87) 41.74,113.12 41.74,113.54 arc(41.72,113.7) 41.66,113.86 arc(41.6,113.96) 41.53,114.05 39.16,116.41 arc(39.1,116.51) 39.08,116.62 39.08,123.47 arc(38.98,123.93) 38.72,124.32 37.06,125.98 36.82,126.22 arc(36.75,126.32) 36.73,126.44 arc(36.56,126.85) 36.14,127.03 36.07,127.03 arc(35.95,127.05) 35.85,127.12 35.76,127.2 35.72,127.24 arc(35.6,127.42) 35.56,127.63 35.56,135.47 arc(35.52,135.67) 35.41,135.84 34.66,136.59 arc(34.49,136.7) 34.29,136.74 34.2,136.74 arc(33.88,136.87) 33.75,137.19 33.75,141.1 arc(33.67,141.52) 33.43,141.88 33.43,141.88 arc(33.29,142.1) 33.24,142.36 33.24,143.51 arc(33.14,144.01) 32.85,144.44 30.61,146.69 arc(30.44,146.94) 30.38,147.23 30.38,151.17 arc(30.27,151.74) 29.95,152.22 27.34,154.83 arc(27.11,155.17) 27.03,155.57 27.03,157.31 arc(26.92,157.88) 26.6,158.37 25.7,159.26 arc(25.22,159.58) 24.65,159.69 19.13,159.69 arc(18.56,159.45) 18.35,158.86 arc(18.27,158.53) J2.E8
ZD3_AIF3_TXP: length 97.6
  TOP w0.102: U24.AP15 58.52,87.42 58.62,87.52 58.62,87.91 58.52,88.01 58.01,88.01 v2(57.94,87.93)
  L3 w0.089: v2(57.94,87.93) 57.94,88.12 arc(57.92,88.19) 57.89,88.25 arc(57.83,88.28) 57.76,88.3 54.74,88.3 arc(54.45,88.36) 54.2,88.52 52.05,90.67 arc(51.94,90.76) 51.82,90.83 arc(51.78,90.84) 51.75,90.86 arc(51.63,90.88) 51.51,90.89 49.26,90.89 arc(48.89,90.97) 48.57,91.18 47.3,92.45 arc(47.09,92.77) 47.02,93.14 47.02,97.94 arc(46.97,98.15) 46.86,98.33 42.23,102.95 arc(42.02,103.27) 41.95,103.64 41.95,112.1 arc(41.9,112.31) 41.78,112.5 arc(41.59,112.78) 41.52,113.12 41.52,113.54 arc(41.51,113.65) 41.47,113.77 arc(41.43,113.83) 41.38,113.89 39.01,116.26 arc(38.9,116.43) 38.86,116.62 38.86,123.47 arc(38.78,123.85) 38.57,124.17 36.91,125.83 36.67,126.07 arc(36.55,126.24) 36.51,126.44 arc(36.4,126.7) 36.14,126.81 36.07,126.81 arc(35.87,126.85) 35.7,126.96 35.61,127.05 35.57,127.09 arc(35.4,127.34) 35.34,127.63 35.34,135.38 arc(35.3,135.58) 35.19,135.75 35.05,135.89 34.51,136.44 arc(34.41,136.5) 34.29,136.53 34.2,136.53 arc(33.73,136.72) 33.54,137.19 33.54,141.1 arc(33.47,141.44) 33.28,141.73 33.28,141.73 arc(33.09,142.02) 33.02,142.36 33.02,143.51 arc(32.94,143.93) 32.7,144.29 30.45,146.53 arc(30.24,146.85) 30.16,147.23 30.16,151.17 arc(30.07,151.66) 29.79,152.07 27.19,154.67 arc(26.91,155.09) 26.82,155.57 26.82,157.31 arc(26.72,157.8) 26.45,158.21 25.55,159.11 arc(25.14,159.38) 24.65,159.48 19.13,159.48 arc(18.72,159.3) 18.57,158.88 arc(18.77,158.47) J2.F8
N863951: length 28.5
  TOP w0.508: 164.99,110.53 SOC_USB.7 ; SOC_USB.7 164.99,111.79 ; SOC_USB.7 166.25,110.53 ; SOC_USB.7 166.25,111.79 ; 169.12,106.38 SOC_USB.H1 170.44,105.91 ; SOC_USB.H2 170.44,119.05 ; SOC_USB.H2 167.8,116.41 ; SOC_USB.H2 167.8,119.05 ; SOC_USB.H2 170.44,116.41 ; 166.49,114.03 SOC_USB.4 ; SOC_USB.4 167.75,115.29 ; SOC_USB.4 167.75,114.03
  BOTTOM w0.508: SOC_USB.H2 170.44,116.41 ; SOC_USB.H2 167.8,116.41 ; SOC_USB.H2 167.8,119.05 ; SOC_USB.H2 170.44,119.05 ; 167.8,105.91 SOC_USB.H1 170.44,105.91
  vias: v3(169.8,115.19) v3(169.8,112.65) v3(169.8,109.98) v3(169.8,107.19) v3(171.58,117.47) v3(171.58,112.65) v3(171.7,104.78)
N7232080: length 3.5
  TOP w0.381: C364.2 102.17,41.97 101.74,41.54 101.24,41.54 100.78,42 R445.2 R443.2
N12619718: length 5
  TOP w0.127: FTDI_USB.1 171.16,163.79 169.87,162.5 v1(169.69,162.5) R26.2
  BOTTOM w0.127: R26.2 v1(169.69,162.5)
N12619936: length 9.8
  TOP w0.127: Y1.2 161.8,158.62 162.69,159.51 162.69,160.98 C33.2 162.78,161.69 162.78,161.71 162.65,161.84 161.05,161.84 160.56,161.34 159.93,161.34 159.38,161.88 159.38,162.05 159.33,162.1 U3.2
N12619940: length 10.1
  TOP w0.127: U3.3 159.12,162.6 159.36,162.36 159.46,162.36 159.64,162.18 159.64,161.99 160.03,161.59 160.45,161.59 160.95,162.09 162.75,162.09 163.03,161.81 163.03,161.77 C28.2 163.07,160.85 163.07,159.77 164.21,158.62 Y1.1
N12620028: length 2.8
  TOP w0.127: v1(156.08,161.16) 155.9,160.98 U3.63
  BOTTOM w0.127: U46.1 v1(156.08,161.16)
N12620040: length 3
  TOP w0.127: U3.62 155.4,161.15 v1(155.37,161.19)
  BOTTOM w0.127: v1(155.37,161.19) 154.81,161.74 U46.2
N12620052: length 9.7
  TOP w0.127: v1(153.29,163.32) 154.9,161.71 U3.61
  BOTTOM w0.127: U46.3 153.54,163.07 v1(153.29,163.32) 153.29,164.52 152.38,165.42 R482.2
N12620068: length 3.6
  BOTTOM w0.508: R482.1 R484.1 151.95,163.39 152.27,163.07 U46.4
N12620356: length 2.3
  TOP w0.254: v1(159.61,164.03) 159.54,164.1 U3.6
  BOTTOM w0.508: R483.2 160.15,164.57 v1(159.61,164.03)
N12620364: length 2.3
  TOP w0.127: TP6.1 154.4,157.33 U3.60
N12620368: length 6.3
  TOP w0.127: U3.36 146.19,167.6 145.82,167.97 145.82,169.39 146.38,169.95 146.38,171.37 TP1.1
N12620494: length 1.7
  BOTTOM w0.508: U46.6 153.54,169.48 R477.2
N12681623: length 2.8
  BOTTOM w0.127: R577.2 154.49,119.13 155.04,119.13 155.11,119.05 155.4,119.05 155.88,118.56 U56.12
N12681645: length 2.2
  BOTTOM w0.127: C490.2 158.19,110.18 157.19,111.19 U56.3
N12681649: length 2.9
  BOTTOM w0.127: C492.2 156.21,109.91 156.21,110.49 155.88,110.82 U56.5
N12681653: length 1.7
  BOTTOM w0.127: C492.1 155.23,110.52 U56.6
N12681665: length 6.8
  BOTTOM w0.127: C491.2 156.97,108.59 157.32,108.24 158.6,108.24 158.92,108.56 158.92,110.34 158.63,110.62 158.24,110.62 157.84,111.02 U56.2
N12681669: length 1.9
  BOTTOM w0.127: C491.1 156.88,110.18 156.5,110.57 156.5,110.93 156.54,110.97 U56.4
N12681685: length 1.8
  BOTTOM w0.127: U56.7 154.58,110.58 C493.2
N12681693: length 1.7
  BOTTOM w0.127: U56.16 158.49,119.19 R576.2
N12824739: length 1.7
  TOP w0.127: U22.8 125.04,104.39 R317.2
N12868999: length 4.4
  BOTTOM w0.102: PHY1.A6 137.36,73.1 137.15,72.88
  BOTTOM w0.127: R715.1 135.38,71.12 137.15,72.88
N12869003: length 3.7
  BOTTOM w0.102: 137.15,74.1 PHY1.A5
  BOTTOM w0.127: R704.1 134.75,74.1 137.15,74.1
N12869377: length 5
  BOTTOM w0.102: 146.61,79.1 146.61,78.82 146.76,78.66 146.76,77.65 147.14,77.26 PHY1.K2
  BOTTOM w0.127: TP75.1 146.61,81.08 146.61,79.1
N12934666: length 2
  TOP w0.381: R531.1 156.01,37.09 CN22.1
N12948447: length 1.4
  TOP w0.254: DBG_D1.1 R70.1
N12950191: length 1.4
  TOP w0.254: DBG_D3.2 179,140.06 R111.1
N12966915: length 2.8
  TOP w0.254: DBG_D2.2 179.2,143.46 178.74,143 v1(178.13,143)
  BOTTOM w0.254: R534.1 178.28,143.15 v1(178.13,143)
N13012268: length 2.6
  TOP w0.127: U7.96 151.96,153.89 v1(152.4,153.44)
  BOTTOM w0.127: v1(152.4,153.44) R515.1
N13251183: length 2.6
  TOP w0.254: R145.2 51.11,139.06 v1(50.7,139.47) 51.11,139.88 R134.2
  BOTTOM w0.254: v1(50.7,139.47) 51.11,139.88 R134.2
N13254474: length 5.8
  TOP w0.254: R146.2 R159.1 C80.1 110.94,130.99 110.89,130.94 U16.59
N13254570: length 2
  TOP w0.279: C100.1 119.89,127.38 119.13,126.62 119.12,126.62 B13.1
N13254654: length 3.3
  TOP w0.254: U16.61 109.89,130.06 108.71,131.24 R172.2
N13254658: length 6.7
  TOP w0.254: R151.2 109.47,134.18 109.47,131.02 110.39,130.1 U16.60
N13254770: length 8.4
  TOP w0.254: U16.50 115.39,129.74 115.82,130.18 117.73,130.18 119.07,131.51 C84.1 R150.1 R140.2
N13255208: length 5.2
  TOP w0.127: R202.1 104.03,127.69
  TOP w0.254: U16.3 106.82,127.21 106.79,127.23 106.32,127.23 105.86,127.69 C99.1 104.03,127.69 ; R202.1 R201.2
N13255844: length 7.6
  TOP w0.254: U16.1 107.25,128.21 106.81,128.65 106.81,130.61 C78.1 R171.1 R170.2
N13256024: length 6.3
  TOP w0.254: R195.2 R196.1 C90.1 106.3,128.84 106.3,128.14 106.73,127.71 U16.2
N13256156: length 2.1
  TOP w0.254: U16.9 105.73,124.21 R216.1
N13256184: length 4
  TOP w0.254: R224.2 119.76,122.56 118.11,124.21 U16.40
N13256738: length 7.5
  TOP w0.254: R139.2 R149.1 C83.1 117.04,131.64 116.33,130.94 115.32,130.94 114.39,130.01 U16.52
N13256834: length 6.5
  TOP w0.254: R138.2 R148.1 C82.1 115,131.9 113.39,130.28 U16.54
N13257002: length 6
  TOP w0.254: U16.56 112.39,130.93 112.97,131.51 C81.1 R147.1 R137.2
N13262989: length 5.2
  BOTTOM w0.254: R755.2 132.4,44.77 132.72,44.45 134.18,44.45 135.07,43.56 R760.2 135.07,42.41 135.37,42.11 R766.2
N13263083: length 2.6
  TOP w0.381: v1(124.55,36.3) 124.57,36.32 R468.1
  BOTTOM w0.254: v1(124.55,36.3) 124.59,36.26 C791.2
N13263091: length 14
  TOP w0.279: U44.30 134.26,37.69 v3(134.42,37.85) ; U44.37 130.31,40.44 v1(130.14,40.61)
  TOP w0.508: R461.1 136.84,38.41 136.12,37.69 134.57,37.69 v3(134.42,37.85)
  L10 w0.508: v3(134.42,37.85) 132.77,39.5 130.68,39.5 130.14,40.04 v1(130.14,40.61)
  BOTTOM w0.508: v1(130.14,40.61) 130.14,41.05 C775.2 130.61,41.53 C830.2
N13263135: length 8.6
  BOTTOM w0.254: R767.2 134.17,42.29 R760.1 134.17,43.56 133.79,43.94 129.73,43.94 R761.2 C749.1
N13263447: length 1.7
  TOP w0.279: R469.1 133.72,36.65 133.67,36.69 U44.28
N13268166: length 3.2
  TOP w0.254: v1(86.49,146.31) 86.49,146.37 86.06,146.79 85.4,146.79 85.39,146.79 U9.22
  BOTTOM w0.254: v1(86.49,146.31) 87.31,147.14 C423.2
N13268184: length 2.3
  TOP w0.254: C51.2 76.77,147.79 U9.3
N13268196: length 3.9
  TOP w0.279: 76.73,146.08 77.44,146.79 U9.5
  TOP w0.508: C57.1 76.69,146.03 76.73,146.08
N13268208: length 3.4
  TOP w0.254: C51.1 76.37,147.29 U9.4
N13268308: length 2.3
  TOP w0.254: C50.1 87.04,147.79 U9.24
N13268312: length 3.6
  TOP w0.254: U9.23 86.27,147.29 86.49,147.07 87.63,147.07 88.05,147.49 C50.2
N13662493: length 10
  TOP w0.127: R485.2 164.27,43 163.32,43.94 158.5,43.94 157.35,42.8 CN22.2
N13662497: length 9.3
  TOP w0.127: R491.2 164.27,41.66 163.83,42.09 163.83,42.8 163.07,43.56 159.64,43.56 158.62,42.55 CN22.4
N13662501: length 8.6
  TOP w0.127: CN22.6 159.89,42.29 160.78,43.18 162.81,43.18 163.58,42.42 163.58,40.89 164.27,40.2 R493.2
N13662505: length 8
  TOP w0.127: R506.2 164.27,38.8 163.19,39.88 163.19,42.29 162.69,42.8 161.8,42.8 161.16,42.16 CN22.8
N13662509: length 5.1
  TOP w0.127: CN22.10 162.43,40.01 163.32,39.12 163.32,37.78 R513.2
N14285737: length 4.5
  TOP w0.102: U24.AM21 59.91,82.03 v2(59.01,82.03)
  BOTTOM w0.102: R671.1 56.45,81.62 57.84,81.62 58.26,82.03 v2(59.01,82.03)
N14285795: length 1.5
  TOP w0.102: U24.AM23 60.09,79.85 v2(60.09,80.05)
  BOTTOM w0.102: TP76.1 59.72,80.42 v2(60.09,80.05)
N14335140: length 6.4
  TOP w0.254: R360.2 17.71,78.61 20.7,78.61 21.62,79.53 U25.60
N14335250: length 6.5
  TOP w0.254: R342.2 17.79,86.56 R343.1 C236.1 20.5,86.56 20.95,86.11 20.95,85.5 21.93,84.53 U25.50
N14335646: length 5.6
  TOP w0.254: v1(24.51,75.87) 24.55,75.91 U25.3
  BOTTOM w0.254: v1(24.51,75.87) 25.15,76.51 C663.1 R694.1 R693.2
N14335704: length 4.1
  TOP w0.254: U23.3 15.76,92.24 C221.2
N14335716: length 4.7
  TOP w0.254: U23.5 16.76,92.99 18.05,91.7 C226.1
N14335728: length 2.9
  TOP w0.254: C221.1 16.26,92.64 U23.4
N14335828: length 3.3
  TOP w0.254: C182.1 15.76,103.84 U23.24
N14335832: length 2.2
  TOP w0.254: U23.23 16.26,103.44 C182.2
N14336022: length 4.9
  TOP w0.254: v1(22.66,76.63) 22.8,76.78 U25.1
  BOTTOM w0.254: v1(22.66,76.63) 22.68,76.65 C653.1 R687.1 R683.2
N14336112: length 6.4
  TOP w0.254: v1(23.11,76.12) 23.27,75.97 23.85,75.97 24.06,76.18 U25.2
  BOTTOM w0.254: v1(23.11,76.12) 23.81,76.82 C652.1 R686.1 R682.2
N14336172: length 2.5
  TOP w0.254: R377.2 27.55,74.62 U25.9
N14336192: length 2
  TOP w0.254: R336.2 27.55,87.04 27.55,86.49 27.55,86.49 U25.40
N14336826: length 7.7
  TOP w0.254: U25.52 21.37,83.53 20.38,84.52 C239.1 R347.1 18.36,84.96 R345.2
N14336882: length 7.6
  TOP w0.254: R349.2 17.72,83.57 R353.1 C244.1 21.48,82.49 21.51,82.53 U25.54
N14336954: length 10.6
  TOP w0.254: U25.59 21.48,80.03 20.52,79.07 17.37,79.07 16.28,77.98 C260.1 R365.1 R370.2
N14336966: length 7.6
  TOP w0.254: U25.56 21.26,81.53 C252.1 R358.1 18.13,81.13 16.43,81.13 R356.2
N14337048: length 2.5
  TOP w0.279: U25.46 24.55,87.46 24,88.01
N14340048: length 3.9
  TOP w0.254: R114.2 115.97,139.66 v1(116.46,139.17)
  BOTTOM w0.254: R547.2 118.22,139.66 R545.2 116.59,139.66 116.46,139.52 v1(116.46,139.17)
N14340304: length 5.6
  TOP w0.254: R115.2 116.81,139.66 v1(116.28,140.18)
  BOTTOM w0.254: v1(116.28,140.18) 116.66,140.56 R545.1 117.26,140.23 118.02,140.23 C430.1 R538.2
N14340850: length 6.5
  TOP w0.279: R116.2 122.91,140.59 123.23,140.91 123.23,144.74 122.52,145.45 U8.5
N14340854: length 1.7
  TOP w0.254: R116.1 124.06,139.66 C63.2
N14340862: length 2.3
  TOP w0.254: U8.28 114.36,145.45 R85.1
N14344366: length 3.9
  TOP w0.254: C232.1 21.91,87.12 23.24,87.12 23.96,86.4 23.97,86.4 24.06,86.32 U25.47
N14344442: length 2.9
  TOP w0.254: U25.61 21.75,79.03 20.7,77.98 R361.2
N14416450: length 5.3
  TOP w0.254: U38.1 107.04,45.13 106.74,44.83 R442.1 C363.1 105.61,43.42 R441.2
N14462583: length 5.6
  TOP w0.102: v2(61.09,78.8) 60.9,78.8 U24.AM24
  BOTTOM w0.102: R685.1 57.47,79.69 57.66,79.5 58.14,79.5 58.39,79.25 58.39,79.02 58.6,78.8 v2(61.09,78.8)
N14462617: length 6.1
  TOP w0.102: U24.AM25 60.09,77.85 60.08,77.85 v2(60.03,77.91)
  BOTTOM w0.102: v2(60.03,77.91) 59.97,77.91 59.39,78.49 58.29,78.49 57.02,77.22 TP79.1
N14463052: length 6.8
  TOP w0.102: v2(61.09,77.98) 61.09,77 60.52,76.43 U24.AM26
  BOTTOM w0.102: R698.1 57.22,76.9 58.43,78.12 59.28,78.12 59.93,77.47 60.58,77.47 v2(61.09,77.98)
N14463097: length 3.6
  TOP w0.102: U24.AM28 60.02,74.92 v2(59.94,74.92)
  BOTTOM w0.102: v2(59.94,74.92) 59.6,74.92 59.36,74.68 58.9,74.68 58.14,75.44 TP86.1
N14463586: length 2.5
  TOP w0.102: U24.AM9 v2(60.02,93.92)
  BOTTOM w0.102: v2(60.02,93.92) 59.45,93.36 R635.1
N14463676: length 1.5
  TOP w0.102: U24.AN10 59.62,92.42 59.8,92.6 v2(60.01,92.81)
  BOTTOM w0.102: v2(60.01,92.81) 60.33,92.49 TP68.1
N14464320: length 5.2
  TOP w0.102: U24.AM6 60.52,95.96 59.99,95.44 v2(59.99,94.95)
  BOTTOM w0.102: R632.1 57.46,94.11 57.88,94.53 59.58,94.53 v2(59.99,94.95)
N14464350: length 3.3
  TOP w0.102: v2(61.01,95) 60.58,95.42 U24.AM7
  BOTTOM w0.102: TP67.1 60.48,95.52 v2(61.01,95)
N14466276: length 2.5
  TOP w0.102: U24.AM19 v2(60.02,83.92)
  BOTTOM w0.102: R667.2 59,83.38 59.54,83.92 v2(60.02,83.92)
N14466300: length 2.7
  TOP w0.102: v2(58.8,85.9) 59.32,86.42 U24.AN16
  BOTTOM w0.102: v2(58.8,85.9) 58.8,85.9 58.62,85.9 58.06,86.47 57.87,86.47 R656.2
N14466676: length 7.2
  TOP w0.127: TP43.1 74.12,106.65 74.12,105.56 75.11,104.57 75.64,104.57 77.52,102.7 U24.R1
N14466840: length 7.6
  TOP w0.127: R310.1 73.41,105.03 71.52,103.14 U24.AA1
N14469420: length 2.5
  TOP w0.254: U24.H10 84.54,92.42 v2(85.04,91.92)
  BOTTOM w0.254: R640.1 85.52,91.44 v2(85.04,91.92)
N14469428: length 1.4
  TOP w0.381: U24.H22 v2(85.02,79.92)
  BOTTOM w0.381: R684.1 85.5,80.41 v2(85.02,79.92)
N14469440: length 3.1
  TOP w0.305: U24.H16 84.54,86.42 v2(84.99,85.98)
  BOTTOM w0.305: R657.1 86.57,85.69 86.5,85.76 86.5,86.12 86.22,86.41 85.82,86.41 85.39,85.98 v2(84.99,85.98)
N14469681: length 10.2
  TOP w0.102: v2(89.02,89.92) 88.52,90.42 U24.D12
  BOTTOM w0.102: v2(89.02,89.92) 89.53,89.41 93.18,89.41
  BOTTOM w0.127: TP69.1 93.18,89.41
N14469715: length 1.4
  TOP w0.102: U24.D13 88.52,89.42 v2(89.02,88.92)
  BOTTOM w0.102: TP72.1 89.5,88.44 v2(89.02,88.92)
N14470453: length 3.7
  TOP w0.305: v2(71.02,71.92) U24.AA31
  BOTTOM w0.381: v2(71.02,71.92) 71.02,72.19 70.5,72.71 70.5,73.16 71.12,73.79 R716.1
N14470457: length 1.9
  TOP w0.305: v2(78.03,70.92) 78.52,70.43 U24.P32
  BOTTOM w0.381: R719.1 78.54,70.4 v2(78.03,70.92)
N14470652: length 11.5
  TOP w0.102: U24.AC38 70.1,63.84 70.1,62.71 71.22,61.59
  TOP w0.127: 71.22,61.59 71.22,59.16 70.61,58.55 70.61,54.74 TP56.1
N14470656: length 10.8
  TOP w0.102: U24.AC39 69.52,62.82 70.74,61.59
  TOP w0.127: TP54.1 69.72,55.37 69.72,58.28 70.74,59.3 70.74,61.59
N14470900: length 1.4
  TOP w0.102: U24.AD35 68.02,66.93 68.02,66.93 v2(68.02,66.92)
  BOTTOM w0.102: v2(68.02,66.92) 68.02,66.93 68.5,67.41 TP91.1
N14470904: length 2.6
  TOP w0.102: U24.AC34 69.51,68.41 v2(69.02,67.92)
  BOTTOM w0.102: TP89.1 69.51,67.72 69.31,67.92 v2(69.02,67.92)
N14479849: length 8.5
  TOP w0.254: R409.2 125.48,53.4 U34.5 127.96,53.4 128.35,53.01 128.35,50.05 127.89,49.59 U34.8
N14481980: length 3.5
  TOP w0.102: U24.AM16 59.99,85.89 v2(59.99,85.87)
  BOTTOM w0.102: v2(59.99,85.87) 59.35,85.87 58.88,85.39 TP73.1
N14482014: length 5.2
  TOP w0.102: U24.AM14 60.52,88.53 v2(60.02,89.03)
  BOTTOM w0.102: TP70.1 56.52,88.96 56.94,89.38 59.66,89.38 v2(60.02,89.03)
N14482176: length 2.5
  TOP w0.102: v2(59.02,88.04) 59.18,87.88 60.06,87.88 U24.AM15
  BOTTOM w0.102: R649.1 58.55,88.52 v2(59.02,88.04)
N14482239: length 2.2
  TOP w0.102: U24.AM11 60.14,91.04 59.04,91.04 v2(59.02,91.06)
  BOTTOM w0.102: v2(59.02,91.06) 58.95,90.98 R638.1
