# Allegro board 19C2830503-01-JOB.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SOC_DDR3B_EDQ57: length 37.9
  TOP w0.102: v2(59.02,65.92) U24.AN36
  TOP w0.127: U39.C3 45.55,46.5 45.67,46.62 45.67,46.79 45.55,46.9 v2(44.9,46.9)
  L10 w0.114: v2(44.9,46.9) 44.9,47.22 44.77,47.35 44.48,47.35 44.35,47.22 44.35,46.91 44.22,46.79 43.84,46.79 43.71,46.91 43.71,47.98 43.59,48.11 43.1,48.11 42.91,48.3 42.91,48.76 43.52,49.36 45.49,49.36 50.47,54.34 50.47,59.94 50.83,60.31 50.99,60.31 51.1,60.2 51.26,60.2 51.42,60.36 51.42,60.52 51.32,60.63 51.32,60.79 53.06,62.53 54.25,62.53 54.53,62.81 54.53,63.22 54.81,63.5 55.35,63.5 55.46,63.61 55.46,63.92 55.58,64.03 55.81,64.03 55.92,63.92 55.92,63.61 56.03,63.5 56.26,63.5 56.38,63.61 56.38,63.92 56.49,64.03 56.72,64.03 56.83,63.92 56.83,63.61 56.95,63.5 57.18,63.5 57.29,63.61 57.29,63.92 57.41,64.03 57.63,64.03 57.75,63.92 57.75,63.61 57.86,63.5 58.09,63.5 58.63,64.04 58.63,65.54 v2(59.02,65.92)
SOC_DDR3B_EDQ58: length 37.7
  TOP w0.102: v2(60.03,68.95) 59.99,68.95 U24.AN33 ; v2(48.1,46.9) 48.1,46.15 48.21,46.05 48.54,46.05 48.64,46.15 48.64,46.38 48.51,46.5 U39.C8
  L10 w0.102: 60.64,62.16 60.64,68.71 60.4,68.95 v2(60.03,68.95) ; 53.59,47.09 53.31,46.81 53.01,46.81
  L10 w0.114: v2(48.1,46.9) 47.74,46.55 47.74,46.37 48.03,46.08 48.21,46.08 48.62,46.48 50.01,46.48 50.34,46.81 51.27,46.81 51.39,46.93 51.39,47.45 51.51,47.57 51.72,47.57 51.84,47.45 51.84,46.93 51.96,46.81 52.19,46.81 52.3,46.93 52.3,47.47 52.43,47.6 52.63,47.6 52.76,47.47 52.76,46.93 52.87,46.81 53.01,46.81 ; 53.59,47.09 53.59,47.55 53.16,47.98 53.16,49.98 57.96,54.78 57.96,56.12 60.33,58.48 60.33,61.85 60.64,62.16
SOC_DDR3B_EDQ59: length 37.6
  TOP w0.102: U24.AM34 60.04,67.94 v2(60.02,67.94)
  TOP w0.127: U39.C2 v2(43.3,46.9)
  L10 w0.114: v2(60.02,67.94) 60.02,68.4 59.89,68.53 59.54,68.53 59.41,68.4 59.41,66.6 59.28,66.47 57.86,66.47 57.45,66.07 57.45,64.57 57.33,64.44 56.64,64.44 56.52,64.57 56.52,65.35 56.39,65.48 55.7,65.48 55.58,65.35 55.58,64.77 54.15,63.35 53.21,63.35 49.87,60.01 49.87,54.42 45.42,49.96 43.33,49.96 41.91,48.54 41.91,47.62 42.21,47.32 42.89,47.32 v2(43.3,46.9)
SOC_DDR3B_EDQ60: length 37.7
  TOP w0.102: U24.AM35 v2(60.02,66.92)
  TOP w0.127: v2(49.66,48.87) 49.02,49.5 48.06,49.5 47.7,49.15 U39.A7
  L10 w0.102: v2(60.02,66.92) 60.4,66.54 60.4,62.32 60.39,62.3
  L10 w0.114: v2(49.66,48.87) 50.16,48.36 50.16,47.93 50.29,47.8 50.89,47.8 51.01,47.93 51.01,48.64 50.38,49.27 50.38,49.44 50.54,49.6 50.7,49.6 51.82,48.47 52,48.47 52.15,48.62 52.15,48.8 51.02,49.92 51.02,50.08 51.18,50.24 51.35,50.24 52.37,49.22 52.55,49.22 52.69,49.37 52.69,49.54 51.67,50.57 51.67,50.73 51.83,50.89 51.99,50.89 52.63,50.25 52.79,50.25 57.51,54.97 57.51,56.31 59.87,58.67 59.87,61.78 60.39,62.3
SOC_DDR3B_EDQ61: length 37.8
  TOP w0.102: U24.AM38 60.14,64.04 60.14,62.15 60.03,62.05 59.74,62.05 59.66,62.13 v2(59.66,62.45)
  TOP w0.127: v2(43.3,48.5) 43.3,48.9 42.91,49.3 41.58,49.3 41.45,49.42 41.45,50.62 41.58,50.75 43.66,50.75 43.79,50.62 43.79,48.19 U39.A2
  L10 w0.102: v2(43.3,48.5) 44.09,48.5 44.47,48.13 45.58,48.13 46.22,48.77
  L10 w0.114: v2(59.66,62.45) 59.66,62.8 59.54,62.92 56.52,62.92 55.04,61.44 54.03,61.44 51.79,59.21 51.79,54.34 46.22,48.77
SOC_DDR3B_EDQ62: length 37.9
  TOP w0.102: v2(48.1,47.7) 48.5,47.3 U39.B8 ; v2(60.02,65.92) U24.AM36
  L10 w0.102: 59.34,61.59 60.13,62.39 60.13,63.91 59.56,64.48 59.56,65.47 v2(60.02,65.92)
  L10 w0.114: 59.34,61.59 59.11,61.37 59.11,59.43 59.37,59.17 59.37,58.99 59.23,58.85 59.05,58.85 58.39,59.51 58.19,59.51 58.06,59.38 58.06,59.2 58.8,58.45 58.8,58.27 58.66,58.13 58.48,58.13 57.69,58.91 57.51,58.91 57.37,58.77 57.37,58.59 58.12,57.84 58.12,57.63 57.05,56.57 57.05,56.27 56.93,56.15 56.63,56.15 56.52,56.04 56.52,55.81 56.63,55.7 56.93,55.7 57.05,55.58 57.05,55.19 54.84,52.98 54.68,52.98 54.12,53.54 53.94,53.54 53.8,53.39 53.8,53.21 54.35,52.66 54.35,52.5 54.19,52.34 54.03,52.34 53.39,52.98 53.21,52.98 53.06,52.83 53.06,52.65 53.7,52.01 53.7,51.85 53.54,51.69 53.38,51.69 52.69,52.38 52.51,52.38 52.37,52.24 52.37,52.06 53.06,51.37 53.06,51.2 52.9,51.04 52.73,51.04 52.2,51.58 51.68,51.58 48.52,48.42 48.52,48.12 v2(48.1,47.7)
SOC_DDR3B_EDQ63: length 37.8
  TOP w0.102: U24.AN37 v2(59.02,64.92)
  TOP w0.127: U39.A3 44.37,48.23 44.37,50.62 44.5,50.75 44.93,50.75 45.05,50.62 45.05,50.04 45.18,49.91 45.44,49.91 45.56,50.04 45.56,50.62 45.69,50.75 46.81,50.75 46.94,50.62 46.94,48.56 46.81,48.44 45,48.44 v2(44.92,48.51)
  L10 w0.114: v2(59.02,64.92) 59.02,63.39 58.83,63.2 56.11,63.2 54.79,61.87 53.94,61.87 53.62,62.19 53.46,62.19 53.29,62.03 53.29,61.87 53.4,61.77 53.4,61.6 53.24,61.44 53.08,61.44 52.97,61.55 52.81,61.55 52.65,61.39 52.65,61.22 52.75,61.12 52.75,60.96 52.59,60.8 52.43,60.8 52.32,60.9 52.16,60.9 52,60.74 52,60.58 52.11,60.47 52.11,60.31 51.16,59.36 51.16,54.38 45.29,48.51 v2(44.92,48.51)
SOC_DDR3B_EDQSN_0: length 37.7
  TOP w0.102: 80.96,62.75 80.9,62.81 80.9,63.8 80.79,63.91 80.61,63.91 80.52,63.82 U24.M39 ; v2(90.84,43.7) 91.24,43.3 U43.G3
  TOP w0.127: v1(83.21,59.54) 83.21,59.64 83.13,59.72 82.73,59.72 82.46,59.99 82.46,61.25 80.96,62.75
  L8 w0.114: v2(90.84,43.7) 90.94,43.7 91.17,43.94 91.17,44.23 91.52,44.58 91.95,44.58 92.2,44.83 92.2,47.5 91.62,48.08 91.62,49.38 91.87,49.64 92.63,49.64 92.76,49.77 92.76,50.13 92.63,50.26 91.87,50.26 91.62,50.52 91.62,51.22 92.06,51.66 92.06,51.84 91.79,52.1 91.62,52.1 91.23,51.71 90.85,51.71 90.44,52.12 90.44,52.5 90.83,52.89 90.83,53.07 90.57,53.33 90.39,53.33 90.02,52.95 89.64,52.95 89.23,53.35 89.23,53.73 89.61,54.11 89.61,54.29 89.35,54.55 89.17,54.55 88.73,54.11 88.35,54.11 87.95,54.51 87.95,54.89 88.39,55.33 88.39,55.51 88.13,55.77 87.95,55.77 87.55,55.38 87.17,55.38 86.04,56.52 85.32,56.52 85.07,56.76 85.07,57.57 84.96,57.68 84.58,57.68 84.33,57.94 84.33,58.53 84.58,58.79 84.96,58.79 85.07,58.9 85.07,59.32 84.61,59.78 83.35,59.78 83.21,59.64 v1(83.21,59.54)
SOC_DDR3B_EDQSN_1: length 37.3
  TOP w0.102: 77.9,62.95 77.9,63.72 78.52,64.34 U24.P38 ; U43.B7 94.22,47.3 v2(93.81,47.72)
  TOP w0.127: v1(83.08,58.24) 82.78,58.55 82.3,58.55 77.9,62.95
  L10 w0.114: v1(83.08,58.24) 83.24,58.39 83.67,58.39 84.07,57.99 84.07,57.58 84.32,57.34 85.01,57.34 85.26,57.6 85.26,59.83 85.38,59.94 85.77,59.94 85.89,59.83 85.89,57.6 86.14,57.34 87.33,57.34 87.88,56.78 88.25,56.78 88.84,57.38 89.02,57.38 89.28,57.12 89.28,56.94 88.69,56.34 88.69,55.98 89.11,55.56 89.47,55.56 90.21,56.3 90.39,56.3 90.65,56.04 90.65,55.86 89.91,55.12 89.91,54.76 94.23,50.43 94.23,47.5 94.11,47.37 93.94,47.37 93.81,47.5 v2(93.81,47.72)
SOC_DDR3B_EDQSN_2: length 33
  TOP w0.102: U42.G3 79.55,43.3 v2(79.15,43.7) ; 75.9,62.79 75.9,64.05 76.11,64.26 76.36,64.26 U24.T38
  TOP w0.127: 75.9,62.79 76.85,61.85 76.86,61.83 76.86,60.93 77.14,60.66 77.72,60.66 v1(77.82,60.55)
  L8 w0.114: v2(79.15,43.7) 79.41,43.44 79.41,43.19 79.68,42.93 80.26,42.93 80.9,43.56 80.9,44.96 80.26,45.59 79.72,45.59 79.11,46.2 79.11,49.92 77.94,51.09 77.24,51.09 77.11,51.22 77.11,51.86 77.24,51.99 78.23,51.99 78.49,52.25 78.49,52.84 78.23,53.1 77.17,53.1 77.04,53.22 77.04,53.59 77.17,53.72 78.23,53.72 78.49,53.97 78.49,54.57 78.23,54.82 77.64,54.82 77.22,55.24 77.22,60.62 77.32,60.72 77.65,60.72 v1(77.82,60.55)
SOC_DDR3B_EDQSN_3: length 35.2
  TOP w0.102: v2(82.35,47.7) 82.35,47.54 82.59,47.3 U42.B7 ; U24.V38 74.52,64.21 74.33,64.02 74.17,64.02 74.03,63.89 73.9,63.75 73.9,62.85 73.89,62.84
  TOP w0.127: v1(74.6,61.01) 74.37,61.24 74.14,61.24 73.63,61.75 73.63,62.59 73.89,62.84
  L10 w0.114: v1(74.6,61.01) 74.45,61.16 74.45,61.15 74.14,61.15 74.07,61.08 74.07,59.99 73.66,59.59 72.99,59.59 72.69,59.3 72.69,55.38 72.84,55.24 73.24,55.24 74.2,56.19 74.58,56.19 74.98,55.79 74.98,55.41 73.52,53.96 73.52,53.78 73.79,53.52 73.97,53.52 74.8,54.35 75.17,54.35 75.58,53.95 75.58,53.57 74.84,52.83 74.84,52.65 75.1,52.39 75.28,52.39 76.09,53.2 76.47,53.2 76.87,52.8 76.87,52.42 76.53,52.08 76.53,51.67 76.57,51.64 78.34,51.64 78.59,51.38 78.59,51.2 78.72,51.08 80.58,51.08 81.65,50.01 81.65,47.6 81.76,47.49 82.13,47.49 v2(82.35,47.7)
SOC_DDR3B_EDQSN_4: length 37.5
  TOP w0.102: 66.14,62.46 66.12,62.48 66.12,63.86 66.2,63.95 66.42,63.95 66.52,63.86 U24.AF39 ; U40.G3 v2(56.58,43.7)
  TOP w0.127: 66.14,62.46 66.14,57.79 66.8,57.13 66.8,55.98 66.53,55.7 63.47,55.7 63.2,55.98 63.2,57.13 63.47,57.4 64.28,57.4 64.44,57.56 64.44,58.89 64.34,58.99 63.44,58.99 v1(63.25,58.8)
  L8 w0.114: v2(56.58,43.7) 56.26,44.03 56.26,45.47 56.08,45.64 56.08,48.99 59.32,52.22 59.32,55.43 62.93,59.04 63,59.04 v1(63.25,58.8)
SOC_DDR3B_EDQSN_5: length 32.9
  TOP w0.102: 62.89,63.03 62.9,63.04 62.9,63.76 63.16,64.02 63.44,64.02 63.52,64.11 U24.AJ38 ; U40.B7 v2(58.98,47.7)
  TOP w0.127: v1(63.23,60.43) 63.05,60.6 62.4,60.6 62.13,60.88 62.13,62.27 62.89,63.03
  L10 w0.114: v2(58.98,47.7) 58.98,47.56 59.18,47.36 59.34,47.36 59.45,47.47 59.45,48.12 59.05,48.51 59.05,51.19 60.02,52.16 60.73,52.16 61.52,52.94 61.52,53.38 60.85,54.05 60.85,54.43 61.34,54.92 61.72,54.92 62.54,54.11 62.72,54.11 62.98,54.37 62.98,54.55 61.92,55.6 61.92,55.97 62.34,56.38 62.7,56.38 63.8,55.29 63.98,55.29 64.24,55.55 64.24,55.73 63.15,56.83 63.15,57.19 63.44,57.48 64.49,57.48 64.62,57.6 64.62,58.07 64.49,58.2 63.98,58.2 63.72,58.47 63.72,59.04 63.98,59.3 64.44,59.3 64.54,59.41 64.54,60.52 64.47,60.59 63.39,60.59 v1(63.23,60.43)
SOC_DDR3B_EDQSN_6: length 40.4
  TOP w0.102: U24.AL38 61.52,64.26 61.33,64.08 61.18,64.08 60.91,63.8 60.91,62.03 60.9,62.02
  TOP w0.127: U39.G3 44.5,43.3 v2(44.1,43.7) ; v1(58.39,61.35) 58.58,61.16 60.04,61.16 60.9,62.02
  L8 w0.114: v2(44.1,43.7) 44.32,43.93 44.32,44.96 44.27,45.02 44.27,48.77 45.03,49.53 46.86,49.53 47.66,50.33 49.58,50.33 49.8,50.55 49.8,50.71 49.54,50.97 49.54,51.35 49.94,51.75 50.32,51.75 50.58,51.49 50.74,51.49 51.02,51.77 51.02,51.93 50.31,52.64 50.31,53.02 50.72,53.42 51.1,53.42 51.81,52.7 51.99,52.7 52.25,52.96 52.25,53.14 51.93,53.47 51.93,53.83 52.35,54.25 53.19,54.25 53.38,54.44 53.38,54.99 53.26,55.1 52.6,55.1 52.34,55.37 52.34,55.94 52.6,56.21 53.26,56.21 53.38,56.32 53.38,56.72 53.26,56.83 52.86,56.83 52.6,57.09 52.6,57.68 52.86,57.93 53.26,57.93 53.38,58.05 53.38,58.7 55.91,61.23 58.27,61.23 v1(58.39,61.35)
SOC_DDR3B_EDQSN_7: length 37.8
  TOP w0.102: U39.B7 47.07,47.3 v2(46.79,47.58) ; U24.AN39 59.52,63.71 59.38,63.85 59.27,63.85 59.13,63.7 59.13,63.2 58.01,62.08 58.01,61.67
  TOP w0.127: v1(57.4,60.2) 57.15,60.45 57.15,60.81 57.93,61.59 58.01,61.67
  L10 w0.114: v2(46.79,47.58) 47,47.37 47.16,47.37 47.26,47.47 47.26,48.33 53.28,54.36 54.99,54.36 55.66,55.03 55.66,56.32 55.55,56.43 53.37,56.43 53.1,56.7 53.1,57.27 53.37,57.54 56.62,57.54 56.74,57.66 56.74,58.03 56.62,58.16 53.6,58.16 53.33,58.43 53.33,58.99 53.6,59.26 55.55,59.26 55.66,59.38 55.66,60.5 56.12,60.96 56.92,60.96 57.18,60.71 57.18,60.43 v1(57.4,60.2)
SOC_DDR3B_EDQSN_8: length 37
  TOP w0.102: U24.AE38 67.52,64.16 67.43,64.08 67.17,64.08 66.9,63.81 66.9,63.11 66.88,63.08 ; U41.G3 67.82,43.3 v2(67.38,43.74)
  TOP w0.127: 66.88,63.08 66.88,58.26 67.15,57.99 68.1,57.99 68.38,58.26 68.38,61.01 68.54,61.17 69,61.17 v1(69.09,61.09)
  L8 w0.114: v2(67.38,43.74) 67.59,43.96 67.59,44.94 68.83,46.19 68.83,49.54 68.72,49.65 67.95,49.65 67.69,49.91 67.69,50.5 67.95,50.76 68.72,50.76 68.83,50.87 68.83,51.17 69.09,51.42 69.75,51.42 69.86,51.54 69.86,51.93 69.75,52.04 69.09,52.04 68.83,52.3 68.83,52.89 69.17,53.22 69.75,53.22 69.86,53.34 69.86,53.73 69.75,53.84 69.17,53.84 68.91,54.1 68.91,54.69 69.17,54.95 69.75,54.95 69.86,55.06 69.86,60.89 69.47,61.28 69.28,61.28 v1(69.09,61.09)
SOC_DDR3B_EDQSP_0: length 37.7
  TOP w0.102: U24.M38 80.52,64.28 80.68,64.11 80.88,64.11 81.1,63.89 81.1,62.97 81.14,62.93 ; U43.F3 v2(91.64,43.7)
  TOP w0.127: v1(83.21,60.2) 83.21,60.15 83.03,59.97 82.84,59.97 82.71,60.1 82.71,61.36 81.14,62.93
  L8 w0.114: v1(83.21,60.2) 83.21,60.15 83.34,60.02 84.71,60.02 85.31,59.42 85.31,58.8 85.06,58.55 84.68,58.55 84.57,58.43 84.57,58.04 84.68,57.92 85.06,57.92 85.31,57.67 85.31,56.86 85.42,56.76 86.14,56.76 87.27,55.62 87.45,55.62 87.85,56.01 88.23,56.01 88.63,55.61 88.63,55.23 88.19,54.79 88.19,54.61 88.45,54.35 88.63,54.35 89.07,54.79 89.45,54.79 89.85,54.39 89.85,54.01 89.47,53.63 89.47,53.45 89.74,53.19 89.92,53.19 90.29,53.57 90.67,53.57 91.07,53.17 91.07,52.79 90.68,52.4 90.68,52.22 90.95,51.95 91.13,51.95 91.51,52.34 91.89,52.34 92.3,51.94 92.3,51.56 91.86,51.12 91.86,50.62 91.97,50.5 92.73,50.5 93,50.23 93,49.67 92.73,49.4 91.97,49.4 91.86,49.28 91.86,48.18 92.44,47.6 92.44,44.73 92.05,44.34 91.62,44.34 91.41,44.13 91.41,43.87 91.58,43.7 v2(91.64,43.7)
SOC_DDR3B_EDQSP_1: length 37.3
  TOP w0.102: U43.C7 94.26,46.5 v2(93.81,46.96) ; U24.P39 78.52,63.72 78.4,63.84 78.3,63.84 78.1,63.64 78.1,63.1 78.16,63.04
  TOP w0.127: v1(83.08,58.88) 83.01,58.8 82.4,58.8 78.16,63.04
  L10 w0.114: v2(93.81,46.96) 93.98,47.13 94.21,47.13 94.48,47.4 94.48,50.53 90.15,54.86 90.15,55.02 90.89,55.76 90.89,56.14 90.49,56.54 90.11,56.54 89.37,55.8 89.21,55.8 88.93,56.08 88.93,56.24 89.53,56.84 89.53,57.22 89.12,57.62 88.74,57.62 88.15,57.02 87.98,57.02 87.43,57.58 86.24,57.58 86.13,57.7 86.13,59.93 85.87,60.19 85.28,60.19 85.02,59.93 85.02,57.7 84.91,57.58 84.42,57.58 84.32,57.68 84.32,58.09 83.77,58.64 83.32,58.64 v1(83.08,58.88)
SOC_DDR3B_EDQSP_2: length 32.9
  TOP w0.102: 76.13,62.93 76.1,62.95 76.1,63.97 76.19,64.06 76.4,64.06 76.52,63.95 U24.T39 ; U42.F3 79.53,44.08 79.53,43.79 79.65,43.66 79.91,43.66 v2(79.95,43.7)
  TOP w0.127: 76.13,62.93 77.11,61.94 77.11,61.04 77.24,60.91 77.55,60.91 v1(77.85,61.21)
  L8 w0.114: v2(79.95,43.7) 79.78,43.7 79.65,43.58 79.65,43.29 79.78,43.17 80.16,43.17 80.66,43.66 80.66,44.86 80.16,45.35 79.62,45.35 78.87,46.1 78.87,49.82 77.84,50.85 77.14,50.85 76.87,51.12 76.87,51.96 77.14,52.23 78.13,52.23 78.24,52.35 78.24,52.74 78.13,52.85 77.07,52.85 76.8,53.12 76.8,53.69 77.07,53.96 78.13,53.96 78.24,54.07 78.24,54.47 78.13,54.58 77.54,54.58 76.98,55.14 76.98,60.73 77.22,60.96 77.66,60.96 77.85,61.15 v1(77.85,61.21)
SOC_DDR3B_EDQSP_3: length 35.2
  TOP w0.102: 74.1,62.69 74.1,63.67 74.18,63.75 74.25,63.82 74.42,63.82 74.45,63.78 74.52,63.72 U24.V39 ; U42.C7 v2(82.35,46.9)
  TOP w0.127: 74.1,62.69 73.89,62.48 73.89,61.85 74.22,61.52 74.47,61.52 v1(74.6,61.65)
  L10 w0.114: v2(82.35,46.9) 82.01,47.24 81.66,47.24 81.41,47.5 81.41,49.91 80.48,50.84 78.62,50.84 78.35,51.1 78.35,51.28 78.24,51.4 76.47,51.4 76.29,51.57 76.29,52.18 76.63,52.52 76.63,52.7 76.37,52.96 76.19,52.96 75.38,52.14 75,52.14 74.59,52.55 74.59,52.93 75.34,53.67 75.34,53.85 75.07,54.11 74.9,54.11 74.07,53.28 73.69,53.28 73.28,53.68 73.28,54.06 74.74,55.51 74.74,55.69 74.48,55.95 74.3,55.95 73.34,55 72.74,55 72.45,55.28 72.45,59.4 72.89,59.83 73.56,59.83 73.83,60.09 73.83,61.18 74.04,61.39 74.35,61.39 v1(74.6,61.65)
SOC_DDR3B_EDQSP_4: length 37.5
  TOP w0.102: 65.89,62.46 65.91,62.48 65.91,63.95 66.12,64.15 66.45,64.15 66.52,64.22 U24.AF38 ; U40.F3 v2(55.79,43.7)
  TOP w0.127: v1(63.25,59.44) 63.44,59.25 64.44,59.25 64.69,59 64.69,57.45 64.39,57.15 63.58,57.15 63.45,57.02 63.45,56.08 63.58,55.96 66.42,55.96 66.55,56.08 66.55,57.02 65.89,57.68 65.89,62.46
  L8 w0.114: v1(63.25,59.44) 63.25,59.41 63.12,59.28 62.83,59.28 59.08,55.54 59.08,52.32 55.84,49.09 55.84,45.54 56.02,45.37 56.02,43.94 v2(55.79,43.7)
SOC_DDR3B_EDQSP_5: length 32.9
  TOP w0.102: v2(58.97,46.89) 59,46.89 U40.C7 ; U24.AJ39 63.52,63.71 63.4,63.82 63.24,63.82 63.1,63.68 63.1,62.89
  TOP w0.127: 63.1,62.89 62.38,62.17 62.38,60.99 62.51,60.86 63.08,60.86 63.2,60.99 v1(63.2,61.06)
  L10 w0.114: v2(58.97,46.89) 59.2,47.12 59.44,47.12 59.69,47.37 59.69,48.22 59.3,48.61 59.3,51.09 60.12,51.92 60.83,51.92 61.76,52.84 61.76,53.48 61.09,54.15 61.09,54.33 61.44,54.68 61.62,54.68 62.44,53.87 62.82,53.87 63.22,54.27 63.22,54.65 62.16,55.7 62.16,55.87 62.44,56.14 62.6,56.14 63.7,55.05 64.08,55.05 64.48,55.45 64.48,55.83 63.39,56.93 63.39,57.09 63.54,57.24 64.59,57.24 64.86,57.5 64.86,58.17 64.59,58.44 64.08,58.44 63.96,58.57 63.96,58.94 64.08,59.06 64.54,59.06 64.78,59.31 64.78,60.62 64.57,60.83 63.43,60.83 v1(63.2,61.06)
SOC_DDR3B_EDQSP_6: length 40.3
  TOP w0.102: 61.11,61.87 61.11,63.72 61.26,63.87 61.45,63.87 61.52,63.8 U24.AL39
  TOP w0.127: U39.F3 v2(44.9,43.7) ; v1(58.4,60.7) 58.61,60.91 60.15,60.91 61.11,61.87
  L8 w0.114: v1(58.4,60.7) 58.11,60.99 56.01,60.99 53.62,58.6 53.62,57.95 53.36,57.69 52.96,57.69 52.84,57.58 52.84,57.19 52.96,57.07 53.36,57.07 53.62,56.82 53.62,56.22 53.36,55.97 52.7,55.97 52.58,55.84 52.58,55.47 52.7,55.34 53.36,55.34 53.62,55.09 53.62,54.34 53.29,54.01 52.45,54.01 52.17,53.73 52.17,53.57 52.49,53.24 52.49,52.86 52.09,52.46 51.71,52.46 51,53.18 50.82,53.18 50.56,52.92 50.56,52.74 51.26,52.03 51.26,51.67 50.84,51.25 50.48,51.25 50.22,51.51 50.04,51.51 49.78,51.25 49.78,51.07 50.04,50.81 50.04,50.45 49.68,50.09 47.76,50.09 46.96,49.29 45.13,49.29 44.51,48.67 44.51,45.12 44.56,45.06 44.56,44.04 v2(44.9,43.7)
SOC_DDR3B_EDQSP_7: length 37.8
  TOP w0.102: 57.79,61.81 57.8,61.83 57.8,62.17 58.92,63.29 58.92,63.79 59.19,64.05 59.43,64.05 59.52,64.14 U24.AN38 ; U39.C7 47.3,46.9 v2(46.74,46.9)
  TOP w0.127: 57.79,61.81 56.9,60.92 56.9,60.33 v1(56.77,60.2)
  L10 w0.114: v2(46.74,46.9) 46.95,47.12 47.24,47.12 47.5,47.37 47.5,48.23 53.38,54.11 55.09,54.11 55.91,54.93 55.91,56.42 55.65,56.67 53.47,56.67 53.34,56.8 53.34,57.17 53.47,57.29 56.72,57.29 56.98,57.56 56.98,58.13 56.72,58.4 53.7,58.4 53.57,58.53 53.57,58.89 53.7,59.02 55.65,59.02 55.91,59.28 55.91,60.4 56.22,60.72 56.82,60.72 56.93,60.61 56.93,60.36 56.9,60.33 v1(56.77,60.2)
SOC_DDR3B_EDQSP_8: length 37
  TOP w0.102: U41.F3 v2(68.22,43.7) ; U24.AE39 67.52,63.72 67.36,63.87 67.25,63.87 67.11,63.73 67.11,63.11 67.13,63.08
  TOP w0.127: 67.13,63.08 67.13,58.37 67.26,58.24 68,58.24 68.12,58.37 68.12,61.11 68.44,61.43 68.8,61.43 69.09,61.72 v1(69.09,61.72)
  L8 w0.114: v2(68.22,43.7) 68.08,43.7 67.83,43.95 67.83,44.84 69.08,46.09 69.08,49.64 68.82,49.89 68.05,49.89 67.93,50.01 67.93,50.4 68.05,50.51 68.82,50.51 69.08,50.77 69.08,51.07 69.19,51.18 69.85,51.18 70.1,51.44 70.1,52.03 69.85,52.28 69.19,52.28 69.08,52.4 69.08,52.79 69.27,52.98 69.85,52.98 70.1,53.24 70.1,53.83 69.85,54.09 69.27,54.09 69.15,54.2 69.15,54.59 69.27,54.71 69.85,54.71 70.1,54.96 70.1,60.99 69.57,61.52 69.18,61.52 69.09,61.61 v1(69.09,61.72)
SOC_DDR3B_EMRESETN: length 119.5
  TOP w0.102: v2(69.09,69.98) 69.52,70.41 U24.AC32 ; v2(90.83,35.69) 90.83,35.71 U43.T2 ; U42.T2 v2(79.17,35.69) ; v2(55.8,35.69) U40.T2 ; U41.T2 v2(67.44,35.69)
  TOP w0.127: U39.T2 43.7,35.83 43.48,35.61 v2(43.43,35.61) ; v1(99.09,35.41) 99.65,35.41 R470.1
  L3 w0.102: v2(43.43,35.61) 42.98,36.07 ; 55.75,61.59 58.42,64.27 58.42,65.86 59.1,66.54 59.18,66.54 59.4,66.77 59.4,66.84 59.94,67.39 64.02,67.39 64.4,67.77 64.4,67.84 64.86,68.3 64.94,68.3 65.56,68.92 65.56,70.01 66.23,70.68 68.38,70.68 v2(69.09,69.98) ; 42.8,36.07 41.83,36.07
  L3 w0.114: 55.75,61.59 48.93,54.78 48.93,54.26 46.1,51.44 41.86,51.44 40.01,49.58 40.01,37.9 41.83,36.07 ; 42.98,36.07 42.8,36.07
  L5 w0.102: v2(90.83,35.69) 90.58,35.43
  L5 w0.114: 90.58,35.43 89.79,34.65 80.21,34.65 v2(79.17,35.69) 78.13,34.65 68.48,34.65 v2(67.44,35.69) 66.61,34.86 56.63,34.86 v2(55.8,35.69) 54.97,34.86 45.54,34.86 44.83,35.56 43.48,35.56 v2(43.43,35.61)
  L8 w0.114: v1(99.09,35.41) 98.93,35.56 90.96,35.56 v2(90.83,35.69)
SOC_DDR3B_EODT_0: length 130.2
  TOP w0.102: U42.K1 77.96,40.9 v2(78.36,40.51) ; v2(90.04,40.51) 89.84,40.51 89.64,40.71 U43.K1 ; U40.K1 54.59,40.64 54.72,40.5 v2(54.99,40.5) ; v2(66.62,40.51) 66.23,40.9 U41.K1 ; v2(68.96,68.96) 69.42,69.42 U24.AC33
  TOP w0.127: U39.K1 42.76,40.9 42.7,40.84 42.7,40.59 42.82,40.46 43.26,40.46 v2(43.31,40.51)
  L3 w0.102: v2(68.96,68.96) 69.06,68.96 69.47,68.55 69.47,67.61 69.34,67.49 68.55,67.49 68.43,67.61 68.43,68.43 68.3,68.55 67.72,68.55 67.63,68.47 67.63,64.8 ; 42.93,42.42 42.93,40.89 v2(43.31,40.51)
  L3 w0.114: 67.63,64.8 67.63,64.26 66.98,63.6 65.7,63.6 65.45,63.36 65.45,62.92 65.33,62.79 65.12,62.79 65,62.92 65,63.36 64.88,63.47 64.65,63.47 64.54,63.36 64.54,62.89 64.41,62.76 64.21,62.76 64.08,62.89 64.08,63.36 63.97,63.47 63.74,63.47 63.63,63.36 63.63,62.94 63.5,62.81 63.3,62.81 63.17,62.94 63.17,63.36 63.05,63.47 62.79,63.47 62.67,63.36 62.67,62.56 62.55,62.43 62.29,62.43 62.17,62.56 62.17,63.25 62.04,63.37 61.79,63.37 61.66,63.25 61.66,62.48 61.53,62.36 61.28,62.36 61.15,62.48 61.15,63.35 61.02,63.47 60.68,63.47 60.55,63.35 60.55,62.1 59.7,61.25 59.7,60.21 57.89,58.39 55.41,58.39 46.74,49.73 44.21,49.73 44.08,49.6 44.08,49.25 43.95,49.12 43.75,49.12 43.63,49.25 43.63,49.6 43.5,49.73 43.04,49.73 42.91,49.6 42.91,48.23 43.04,48.11 43.61,48.11 43.74,47.98 43.74,47.42 43.61,47.29 43.07,47.29 42.91,47.14 42.91,46.63 43.04,46.51 43.61,46.51 43.74,46.38 43.74,45.84 43.61,45.72 43.05,45.72 42.92,45.59 42.92,44.68 42.91,44.67 42.91,42.43 42.93,42.42
  L5 w0.102: 44.58,40.13 43.94,40.13 43.56,40.51 v2(43.31,40.51)
  L5 w0.114: v2(90.04,40.51) 89.64,40.11 86.54,40.11 81.9,40.11 81.78,39.99 81.78,39.84 81.67,39.73 81.44,39.73 81.33,39.84 81.33,39.99 81.21,40.11 80.98,40.11 80.87,39.99 80.87,39.84 80.76,39.73 80.53,39.73 80.41,39.84 80.41,39.99 80.3,40.11 78.76,40.11 v2(78.36,40.51) 77.61,39.76 73.2,39.76 73.09,39.87 73.09,40.09 72.97,40.21 72.74,40.21 72.63,40.09 72.63,39.87 72.51,39.76 71.71,39.76 71.39,40.08 67.05,40.08 v2(66.62,40.51) 66.21,40.09 62.32,40.09 62.2,39.98 62.2,39.81 62.09,39.7 61.86,39.7 61.74,39.81 61.74,39.98 61.63,40.09 61.4,40.09 61.29,39.98 61.29,39.81 61.17,39.7 60.94,39.7 60.83,39.81 60.83,39.98 60.72,40.09 58.49,40.09 58.38,39.98 58.38,39.88 58.25,39.75 58.05,39.75 57.92,39.88 57.92,39.98 57.81,40.09 57.58,40.09 57.47,39.98 57.47,39.84 57.35,39.73 57.12,39.73 57.01,39.84 57.01,39.98 56.89,40.09 55.4,40.09 v2(54.99,40.5) 54.58,40.09 52.05,40.09 51.94,39.98 51.94,39.81 51.82,39.7 51.59,39.7 51.48,39.81 51.48,39.98 51.36,40.09 44.62,40.09 44.58,40.13
  BOTTOM w0.127: R765.1 99.88,41.84 99.5,41.47 97.1,41.47 96.06,42.5 94.68,42.5 93.98,43.21 92.09,43.21 91.21,42.32 91.21,41.12 90.59,40.51 v2(90.04,40.51)
SOC_DDR3B_ERAS#: length 131.7
  TOP w0.102: v2(91.67,42.1) 91.64,42.1 U43.J3 ; v2(68.06,70.1) 68.07,70.1 68.39,70.42 U24.AD32 ; U42.J3 79.95,42.1 v2(79.98,42.1) ; v2(56.62,42.1) 56.59,42.1 U40.J3 ; v2(68.25,42.1) 67.85,41.7 U41.J3
  TOP w0.127: v2(44.09,41.27) 44.09,41.43 44.38,41.71 44.5,41.71 U39.J3
  L3 w0.102: v2(68.06,70.1) 68.06,69.7 67.96,69.6 66.78,69.6 66.64,69.46 66.64,65.95 66.63,65.94 ; v2(44.09,41.27) 43.69,40.87 43.69,39.37 43.43,39.12 43.28,39.12
  L3 w0.114: 66.63,65.94 66.09,65.41 60.76,65.41 60.45,65.1 60.45,64.81 60.18,64.54 60.12,64.54 59.61,64.03 59.61,63.87 59.82,63.66 59.82,63.5 59.65,63.34 59.49,63.34 59.29,63.54 59.12,63.54 58.96,63.38 58.96,63.22 59.17,63.01 59.17,62.85 59.01,62.69 58.85,62.69 58.64,62.9 58.48,62.9 57.35,61.77 57.35,61.61 57.9,61.06 57.9,60.9 57.74,60.73 57.58,60.73 57.03,61.28 56.86,61.28 55.59,60.01 55.59,59.85 55.76,59.68 55.76,59.52 55.59,59.35 55.43,59.35 55.26,59.52 54.96,59.52 49.96,54.53 49.96,54.08 46.41,50.53 42.27,50.53 40.86,49.12 40.86,48.85 40.98,48.74 41.31,48.74 41.43,48.62 41.43,48.4 41.31,48.28 40.98,48.28 40.86,48.17 40.86,47.94 40.98,47.82 41.31,47.82 41.43,47.71 41.43,47.48 41.31,47.37 40.98,47.37 40.86,47.25 40.86,47.02 40.98,46.91 41.31,46.91 41.43,46.8 41.43,46.57 41.31,46.45 40.98,46.45 40.86,46.34 40.86,42.94 40.98,42.82 41.47,42.82 41.58,42.71 41.58,42.48 41.47,42.37 40.98,42.37 40.86,42.25 40.86,40.18 41.19,39.85 42.01,39.85 42.75,39.12 43.28,39.12
  L8 w0.114: v2(44.09,41.27) 44.54,41.72 53.82,41.72 54.21,42.1 v2(56.62,42.1) 57,41.72 63.46,41.72 64.26,40.91 65.17,40.91 66.04,41.78 67.93,41.78 v2(68.25,42.1) 68.65,41.7 74.38,41.7 74.49,41.82 74.49,42.15 74.61,42.27 74.84,42.27 74.95,42.15 74.95,41.82 75.07,41.7 75.29,41.7 75.41,41.82 75.41,42.15 75.52,42.27 75.75,42.27 75.87,42.15 75.87,41.82 75.98,41.7 79.58,41.7 v2(79.98,42.1) 80.28,41.81 82.77,41.81 82.88,41.7 86.06,41.7 86.49,41.27 88.82,41.27 89.28,41.73 91.3,41.73 v2(91.67,42.1) 92.04,41.73 93.09,41.73 93.93,40.89 99.31,40.89 100.13,41.71 102.03,41.71 102.62,42.29 104.32,42.29 v1(105.03,43)
  BOTTOM w0.127: v1(105.03,43) 105.03,42.87 R763.1
SOC_DDR3B_EWE#: length 132.4
  TOP w0.102: v2(68.25,40.5) 67.85,40.1 U41.L3
  TOP w0.114: U43.L3 91.64,40.5 v2(91.67,40.5) ; U40.L3 56.58,40.5 v2(56.62,40.5) ; U42.L3 79.95,40.5 v2(79.98,40.5) ; U24.AC37 v2(69.02,64.92)
  TOP w0.127: U39.L3 44.5,40.09 v2(44.11,39.7)
  L3 w0.102: 68.61,64.34 68.61,65.42 68.73,65.55 68.94,65.55 69.06,65.42 69.06,64.97 v2(69.02,64.92) ; 96.59,39.99 96.33,39.99 96.2,40.12 92.05,40.12 v2(91.67,40.5) ; 45.72,48.77 45.47,48.51 45.47,45.21 45.28,45.03 45.28,43.55 44.7,42.97 44.7,40.3 v2(44.11,39.7)
  L3 w0.114: 96.59,39.99 97.66,39.99 97.67,40 100.08,40 101.78,38.3 102.8,38.3 103.24,38.73 105.92,38.73 v1(106.05,38.86) ; 68.61,64.34 67.28,63.02 66.55,63.02 65.49,61.96 65.49,61.59 65.29,61.39 64.72,61.39 64.59,61.26 64.59,61 64.72,60.87 65.63,60.87 65.76,60.74 65.76,60.54 65.63,60.41 64.76,60.41 64.63,60.28 64.63,60.08 64.76,59.95 65.63,59.95 65.76,59.83 65.76,59.62 65.63,59.5 64.57,59.5 64.44,59.37 64.44,59.17 64.57,59.04 65.63,59.04 65.76,58.91 65.76,58.71 65.63,58.58 64.44,58.58 64.31,58.46 64.31,57.48 64.44,57.35 64.77,57.35 64.9,57.23 64.9,56.97 64.77,56.85 63.22,56.85 63.09,56.97 63.09,57.12 62.97,57.25 62.74,57.25 62.61,57.12 62.61,57 62.48,56.87 62.27,56.87 62.14,57 62.14,57.9 62.03,58.01 61.8,58.01 61.69,57.9 61.69,56.97 61.56,56.85 61.36,56.85 61.23,56.97 61.23,57.9 61.11,58.01 60.89,58.01 60.77,57.9 60.77,56.97 60.65,56.85 60.44,56.85 60.31,56.97 60.31,58.52 60.19,58.65 59.98,58.65 59.86,58.52 59.86,57.15 59.73,57.02 59.53,57.02 59.4,57.15 59.4,58.19 59.27,58.32 59.07,58.32 58.94,58.19 58.94,57.7 58.8,57.56 55.73,57.56 47.05,48.88 45.83,48.88 45.72,48.77
  L8 w0.114: v2(91.67,40.5) 91.28,40.12 80.37,40.12 v2(79.98,40.5) 79.59,40.11 77.98,40.11 77.62,39.75 77.26,39.75 77.14,39.87 77.14,40.25 77.03,40.36 76.8,40.36 76.68,40.25 76.68,39.87 76.57,39.75 76.34,39.75 76.23,39.87 76.23,40.25 76.11,40.36 75.88,40.36 75.77,40.25 75.77,39.87 75.66,39.75 71.5,39.75 71.15,40.11 68.65,40.11 v2(68.25,40.5) 67.86,40.12 66.46,40.12 66.45,40.13 65.28,40.13 65.02,39.88 61.34,39.88 61.1,40.12 57,40.12 v2(56.62,40.5) 56.19,40.08 44.49,40.08 v2(44.11,39.7)
  BOTTOM w0.127: v1(106.05,38.86) 106.05,39.06 105.61,39.5 R779.1
SOC_EMIFA00: length 7
  TOP w0.127: CN3.6 31.36,128.2 30.58,127.42 30.58,126.5 30.19,126.11 v1(30.19,125.96)
  BOTTOM w0.127: v1(30.19,125.96) 30.25,125.96 30.73,125.48 31.72,125.48 32,125.76 U63.2
SOC_EMIFA01: length 8.6
  TOP w0.127: v1(30.83,126.13) 30.83,125.98 30.37,125.51 30,125.51 29.74,125.77 29.74,126.14 30.32,126.72 30.32,127.61 31.42,128.7 CN3.8
  BOTTOM w0.127: U63.3 31.75,126.26 31.47,125.98 30.98,125.98 v1(30.83,126.13)
SOC_EMIFA02: length 6.9
  TOP w0.127: CN3.10 31.48,129.2 30.07,127.79 30.07,127.43 v1(29.86,127.22)
  BOTTOM w0.127: U63.5 29.91,127.26 v1(29.86,127.22)
SOC_EMIFA03: length 8.1
  TOP w0.127: CN3.12 31.43,129.7 31.35,129.78 29.74,129.78 29.32,129.36 29.32,128.78 v1(29.76,128.33)
  BOTTOM w0.127: v1(29.76,128.33) 30.33,127.76 U63.6
SOC_EMIFA04: length 3.9
  TOP w0.127: v1(34.16,128.72) 34.16,128.72 34.16,129.46 33.42,130.2 CN3.14
  BOTTOM w0.127: U63.8 34.11,128.76 v1(34.16,128.72)
SOC_EMIFA05: length 5
  TOP w0.127: v1(30.58,130.3) 30.63,130.26 31.04,130.26 31.48,130.7 CN3.16
  BOTTOM w0.127: U63.9 32.99,129.34 32.28,129.34 31.93,129.69 31.19,129.69 v1(30.58,130.3)
SOC_EMIFA06: length 4.6
  TOP w0.127: CN3.18 31.48,131.2 31.22,130.94 v1(30.63,130.94)
  BOTTOM w0.127: v1(30.63,130.94) 31.31,130.26 U63.11
SOC_EMIFA07: length 3.3
  TOP w0.127: v1(34.14,131.45) 34.14,131.44 33.88,131.7 CN3.20
  BOTTOM w0.127: v1(34.14,131.45) 34.14,131.19 33.72,130.76 U63.12
SOC_EMIFA08: length 5.3
  TOP w0.127: v1(30.41,131.54) 30.38,131.54 30.38,131.57 30.85,131.57 31.48,132.2 CN3.22
  BOTTOM w0.127: v1(30.41,131.54) 30.38,131.54 30.38,131.57 31.01,131.57 31.07,131.51 31.51,131.51 31.75,131.26 U63.13
SOC_EMIFA09: length 8.3
  TOP w0.127: v1(29.87,130.99) 29.9,131.01 29.9,131.95 30.17,132.23 31.01,132.23 31.12,132.34 31.12,132.34 31.48,132.7 CN3.24
  BOTTOM w0.127: U63.14 31.18,131.76 30.76,132.18 30.07,132.18 29.9,132 29.9,131.01 v1(29.87,130.99)
SOC_EMIFA10: length 4.7
  TOP w0.127: CN3.26 30.96,133.2 30.63,132.87 v1(30.63,132.68)
  BOTTOM w0.127: U63.16 30.93,132.76 30.91,132.74 30.63,132.74 v1(30.63,132.68)
SOC_EMIFA11: length 6
  TOP w0.127: CN3.28 31,133.7 30.27,132.97 v1(29.98,132.97)
  BOTTOM w0.127: U63.17 30.56,133.26 30.45,133.15 30.45,133.12 30.4,133.07 30.02,133.07 30.01,133.05 30,133.05 30,133 29.99,133 29.99,132.97 v1(29.98,132.97)
SOC_EMIFA12: length 3.4
  TOP w0.127: v1(34.15,133.61) 33.56,134.2 CN3.30
  BOTTOM w0.127: v1(34.15,133.61) 34.02,133.75 34.02,133.96 33.72,134.26 U63.19
SOC_EMIFA13: length 4.5
  TOP w0.127: v1(34.67,133.98) 34.67,133.98 34.42,133.98 33.7,134.7 CN3.32
  BOTTOM w0.127: U63.20 33.72,134.76 34.5,133.98 34.67,133.98 v1(34.67,133.98)
SOC_EMIFA14: length 3.8
  TOP w0.127: CN3.34 33.75,135.2 33.98,135.43 v1(34.56,135.43)
  BOTTOM w0.127: U63.22 33.73,135.76 34.06,135.43 v1(34.56,135.43)
SOC_EMIFA15: length 3
  TOP w0.127: v1(34.16,135.97) 33.89,135.7 CN3.36
  BOTTOM w0.127: v1(34.16,135.97) 33.86,136.26 U63.23
SOC_EMIFA16: length 8.4
  TOP w0.127: CN3.38 30.79,136.2 30.63,136.37 v1(29.46,136.37)
  BOTTOM w0.127: v1(29.46,136.37) 30.6,136.37 32.03,137.79 32.03,138.79 32.27,139.02 U64.2
SOC_EMIFA17: length 8.7
  TOP w0.127: v1(29.4,137) 29.93,137 30.23,136.7 CN3.40
  BOTTOM w0.127: U64.3 32.13,139.52 31.78,139.17 31.78,137.9 30.85,136.97 29.43,136.97 v1(29.4,137)
SOC_EMIFA18: length 6.6
  TOP w0.127: v1(30.66,137.41) 30.87,137.2 CN3.42
  BOTTOM w0.127: U64.5 32.01,140.52 31.69,140.2 31.69,139.53 31.52,139.36 31.52,138.27 v1(30.66,137.41)
SOC_EMIFA19: length 6.6
  TOP w0.127: v1(30.66,138.05) 30.66,138.04 31,137.7 CN3.44
  BOTTOM w0.127: U64.6 31.83,141.02 31.44,140.63 31.44,139.64 31.27,139.47 31.27,138.65 v1(30.66,138.05)
SOC_EMIFA20: length 9.9
  TOP w0.127: v1(29.46,139.06) 29.84,139.06 30.35,138.56 30.86,138.56 31.21,138.2 CN3.46
  BOTTOM w0.127: U64.8 31.71,142.02 31.38,142.35 30.53,142.35 29.78,141.6 29.78,140.5 29.89,140.39 29.89,139.5 v1(29.46,139.06)
SOC_EMIFA21: length 9.3
  TOP w0.127: CN3.48 31.48,138.7 31.37,138.81 30.45,138.81 v1(29.44,139.82)
  BOTTOM w0.127: v1(29.44,139.82) 29.46,139.83 29.46,141.64 30.42,142.61 31.51,142.61 31.6,142.52 U64.9
SOC_EMIFA22: length 10.4
  TOP w0.127: CN3.50 31.36,139.2 31.1,139.46 31.1,139.65 29.01,141.74 29.01,143.41 v1(29.08,143.49)
  BOTTOM w0.127: v1(29.08,143.49) 29.11,143.49 29.18,143.41 31.33,143.41 31.45,143.52 U64.11
SOC_EMIFA23: length 10.9
  TOP w0.127: CN3.52 31.41,139.7 29.86,141.26 29.86,142.56 30,142.71 30,143.2 29.1,144.1 29.08,144.1 v1(29.06,144.12)
  BOTTOM w0.127: v1(29.06,144.12) 29.11,144.12 29.56,143.66 31.19,143.66 31.55,144.02 U64.12
SOC_EMIFBE0Z: length 11.9
  TOP w0.127: CN3.49 37.22,139.2 36.86,138.84 36.86,138.38 36.55,138.07 v1(36.55,138.02)
  BOTTOM w0.127: U64.13 34.45,144.52 34.84,144.13 34.84,139.67 34.67,139.51 34.67,138.94 35.59,138.02 v1(36.55,138.02)
SOC_EMIFBE1Z: length 11.5
  TOP w0.127: v1(36.41,138.68) 36.45,138.72 36.45,138.81 36.86,139.22 36.86,139.34 37.22,139.7 CN3.51
  BOTTOM w0.127: U64.14 34.53,145.02 35.09,144.46 35.09,139.15 35.73,138.52 36.25,138.52 v1(36.41,138.68)
SOC_EMIFCE0Z: length 20.3
  TOP w0.127: v1(50.24,162.92) 48.69,162.92 47.73,161.95 43.84,161.95 43.36,161.47 R27.1 43.13,161.52 42.39,161.52 41.59,160.72 40.47,160.72 v2(40.23,160.48)
  BOTTOM w0.102: v2(40.23,160.48) 39.67,161.04 36.37,161.04 36.11,160.78 36.11,157.78 35.78,157.45 NAND1.C6
  BOTTOM w0.127: v1(50.24,162.92) 50.7,163.37 U69.2
SOC_EMIFCE1Z: length 12.8
  TOP w0.127: v1(36.32,139.32) 35.97,138.97 35.97,137.97 36.36,137.58 36.74,137.58 36.87,137.7 CN3.43
  BOTTOM w0.127: U64.16 34.47,146.02 35.35,145.14 35.35,140.3 v1(36.32,139.32)
SOC_EMIFCE2Z: length 14.7
  TOP w0.127: CN3.45 39.34,138.2 39.71,137.83 v1(39.72,137.83)
  BOTTOM w0.127: v1(39.72,137.83) 39.71,137.83 39.24,138.3 38.38,138.3 36.85,139.83 36.32,139.83 35.6,140.55 35.6,145.25 34.33,146.52 U64.17
SOC_EMIFCE3Z: length 15.1
  TOP w0.127: v1(39.72,138.46) 39.69,138.46 39.44,138.7 CN3.47
  BOTTOM w0.127: v1(39.72,138.46) 39.47,138.46 38.87,139.06 38.1,139.06 37.08,140.08 36.42,140.08 35.85,140.65 35.85,145.86 34.19,147.52 U64.19
SOC_EMIFD0: length 3.7
  TOP w0.127: CN3.9 39.24,129.2 39.36,129.09 40.15,129.09 40.49,129.43 U65.18
SOC_EMIFD1: length 3.6
  TOP w0.127: U65.17 39.39,129.93 39.16,129.7 CN3.11
SOC_EMIFD2: length 3.6
  TOP w0.127: U65.16 40.89,130.43 40.66,130.2 39.43,130.2 39.42,130.2 CN3.13
SOC_EMIFD3: length 3.8
  TOP w0.127: CN3.15 39.28,130.7 39.53,130.45 40.03,130.45 40.51,130.93 U65.15
SOC_EMIFD4: length 3.6
  TOP w0.127: CN3.17 39.37,131.2 39.6,131.43 U65.14
SOC_EMIFD5: length 3.6
  TOP w0.127: CN3.19 39.37,131.7 39.6,131.93 U65.13
SOC_EMIFD6: length 3.6
  TOP w0.127: U65.12 39.7,132.43 39.47,132.2 CN3.21
SOC_EMIFD7: length 4.6
  TOP w0.127: CN3.23 41.12,132.7 41.18,132.76 42.51,132.76 U65.11
SOC_EMIFD8: length 5
  TOP w0.127: U68.18 41.18,135.53 40.99,135.34 40.99,134.44 39.75,133.2 CN3.25
SOC_EMIFD9: length 4.9
  TOP w0.127: CN3.27 39.72,133.7 40.73,134.71 40.73,135.53 41.23,136.03 U68.17
SOC_EMIFD10: length 4.9
  TOP w0.127: U68.16 41.15,136.53 40.48,135.85 40.48,135.09 39.59,134.2 CN3.29
SOC_EMIFD11: length 4.9
  TOP w0.127: CN3.31 39.58,134.7 40.22,135.35 40.22,136.03 41.23,137.03 U68.15
SOC_EMIFD12: length 4.9
  TOP w0.127: U68.14 41.23,137.53 40.99,137.29 40.99,137.15 39.97,136.13 39.97,135.47 39.7,135.2 CN3.33
SOC_EMIFD13: length 4.9
  TOP w0.127: CN3.35 39.44,135.7 39.72,135.98 39.72,136.24 40.73,137.25 40.73,137.76 41,138.03 U68.13
SOC_EMIFD14: length 4.8
  TOP w0.127: CN3.37 39.32,136.2 40.48,137.36 40.48,137.99 41.01,138.53 U68.12
SOC_EMIFD15: length 5.8
  TOP w0.127: U68.11 41.11,139.03 40.22,138.14 40.22,137.51 39.42,136.7 CN3.39
SOC_EMIFOEZ: length 15.5
  TOP w0.127: v1(36.61,140.53) 36.64,140.53 36.96,140.2 CN3.53
  BOTTOM w0.127: v1(36.61,140.53) 36.61,141.07 36.13,141.55 36.13,141.92 36.39,142.18 37.17,142.18 37.91,142.92 37.91,143.93 37.94,143.96 37.94,145.12 37.29,145.77 37.29,148 36.39,148.89 35.28,148.89 35.15,149.02 U64.22
SOC_EMIFRNW: length 5.5
  TOP w0.127: v1(36.22,148.41) 36.43,148.2 CN3.65
  BOTTOM w0.127: U64.20 33.95,148.02 34.52,148.59 36.04,148.59 36.22,148.41 36.22,148.41 v1(36.22,148.41)
SOC_EMIFWAIT1: length 3.5
  TOP w0.127: U67.2 40.94,149.33 40.64,149.63 39.67,149.63 39.25,149.2 CN3.69
SOC_EMIFWEZ: length 15.3
  TOP w0.127: CN3.55 37.1,140.7 36.58,141.22 v1(36.58,141.73)
  BOTTOM w0.127: v1(36.58,141.73) 37.08,141.73 38.16,142.81 38.16,143.82 38.56,144.21 38.56,147.09 36.5,149.15 35.38,149.15 35.01,149.52 U64.23
SOC_EMU_00: length 136.9
  TOP w0.127: v1(76.28,111.1) 76.28,111.33 75.9,111.71 74.49,111.71 74,111.22 74,107.67 73.74,107.4 73.74,104.34 72.01,102.62 72.01,100.92 71.52,100.42 U24.AA2
  L8 w0.114: v1(148.22,133.79) 148.22,134.07 148.22,134.08 148.22,134.55 148.02,134.75 146.56,134.75 146.25,134.44 142.09,134.44 141.87,134.66 139.33,134.66 138.16,133.48 134.78,133.48 133.27,131.98 123.66,131.98 123.64,131.96 121.21,131.96 121.01,132.16 119.3,132.16 118.36,131.22 113.93,131.22 112.58,129.87 110.01,129.87 108.32,131.55 103.41,131.55 103.39,131.57 103.03,131.57 102.43,130.97 102.43,130.44 101.11,129.12 101.11,126.68 98.63,124.2 98.63,119.12 98.36,118.85 98.36,115.48 98.36,115.47 98.36,115.11 97.77,114.52 96.6,114.52 96.09,115.04 93.04,115.04 92.47,115.61 86.17,115.61 85.27,116.51 83.96,116.51 83.91,116.56 81.1,116.56 80.24,115.7 80.24,115.2 78.41,113.37 78.41,111.96 78.15,111.7 76.88,111.7 v1(76.28,111.1)
  BOTTOM w0.127: v1(148.22,133.79) 148.22,133.96 148.26,134 148.26,134.98 147.02,136.23 147.02,140.84 147.32,141.15 147.32,141.83 148.15,142.66 148.15,145.2 143.81,149.53 143.13,149.53 142.57,148.97 141.36,148.97 140.84,149.49 140.84,149.97 141.38,150.5 141.38,151.21 143.88,153.71 U49.17
SOC_EMU_01: length 132.2
  TOP w0.102: U24.AB2 70.52,100.42 71.07,100.98 v2(71.07,100.99)
  L8 w0.102: 73.36,104.01 72.83,103.49 72.83,103.46 71.07,101.7 v2(71.07,100.99)
  L8 w0.114: v1(146.94,131.71) 146.94,131.72 145.67,132.99 141.49,132.99 141.29,133.2 139.92,133.2 138.83,132.11 138.83,132 137.74,130.91 137.06,130.91 136.68,130.53 125.09,130.53 123.67,129.11 122.81,129.11 122.23,129.69 118,129.69 116.2,127.89 104.24,127.89 103.49,128.64 103.07,128.64 102.55,128.12 102.55,126.07 100.08,123.6 100.08,118.52 99.89,118.33 99.89,114.4 99.82,114.33 98.32,112.83 95.96,112.83 95.55,113.23 92.97,113.23 92.92,113.18 86.21,113.18 85.52,113.87 85.52,114.21 85.23,114.5 84.82,114.5 84.61,114.28 83.58,114.28 83.29,113.99 83.29,113.64 81.58,111.93 81.58,111.67 80.81,110.9 80.19,110.9 79.53,110.23 77.81,110.23 77.55,109.97 77.55,109 76.61,108.06 75.42,108.06 73.61,106.24 73.61,104.26 73.36,104.01
  BOTTOM w0.127: U49.21 142.94,151.71 141.1,149.86 141.1,149.61 141.16,149.54 141.16,149.53 141.45,149.24 142.48,149.24 143.03,149.78 143.92,149.78 148.4,145.3 148.4,142.55 147.7,141.86 147.7,141.17 147.31,140.78 147.31,137.65 148.79,136.17 148.79,133.43 148.34,132.97 148.34,132.95 148.01,132.61 148.01,132.23 147.55,131.78 147.01,131.78 v1(146.94,131.71)
SOC_EMU_02: length 66.8
  TOP w0.102: U24.Y3 72.52,99.42 v2(73.02,99.92)
  TOP w0.127: v1(89.76,153.29) R47.1
  L5 w0.114: v1(89.76,153.29) 88.67,152.19 88.67,148.38 90.4,146.64 90.4,145.9 89.74,145.24 89.74,134.29 88.84,133.38 88.84,131.94 87.41,130.52 85.62,130.52 85.24,130.14 80.55,130.14 80.05,129.64 80.05,127.24 77.74,124.93 77.74,118.41 77.06,117.73 77.06,107.77 75.43,106.14 75.43,104.34 73.4,102.31 73.4,100.76 73.02,100.38 v2(73.02,99.92)
SOC_EMU_02_R: length 4.9
  TOP w0.127: R47.2 92.2,152.34 92.2,150.7 92.72,150.18 EMU1.13
SOC_EMU_03: length 67.8
  TOP w0.102: U24.Y4 72.52,98.42 v2(73.02,98.92)
  TOP w0.127: R53.2 88.07,152.46 88.49,152.88 v1(88.49,152.88)
  L5 w0.114: v1(88.49,152.88) 88.42,152.82 88.42,148.28 90.16,146.54 90.16,146.04 89.5,145.38 89.5,134.39 88.6,133.48 88.6,132.04 87.31,130.76 82.12,130.76 81.74,130.38 80.45,130.38 79.81,129.74 79.81,127.34 77.5,125.03 77.5,118.51 76.82,117.83 76.82,107.91 75.19,106.28 75.19,104.64 72.63,102.08 72.63,99.31 v2(73.02,98.92)
SOC_EMU_03_R: length 6.4
  TOP w0.127: EMU1.17 92.7,149.18 91.69,150.19 91.69,150.76 91.15,151.31 89.55,151.31 R53.1
SOC_EMU_04: length 62.7
  TOP w0.102: U24.W3 74.02,98.92 v2(74.02,98.91)
  L5 w0.102: 74.43,100.52 74.43,100.52 74.43,99.32 v2(74.02,98.91)
  L5 w0.114: 74.43,100.52 74.43,101.36 74.63,101.56 74.63,102.67 75.91,103.95 75.91,105.84 77.55,107.47 77.55,110.16 78.59,111.2 78.59,115.76 78.74,115.91 78.74,117.6 78.25,118.09 78.25,123.33 81.78,126.86 82.65,126.86 85.82,130.04 87.61,130.04 89.32,131.74 89.32,133.18 90.23,134.09 90.23,144.71 90.89,145.37 90.89,147.4 89.76,148.53 89.54,148.53 v1(89.1,148.97)
  BOTTOM w0.127: R520.2 90.35,150.2 89.13,148.97 v1(89.1,148.97)
SOC_EMU_04_R: length 4.7
  TOP w0.127: EMU1.23 92.55,147.68 91.87,148.36 v1(91.87,148.92)
  BOTTOM w0.127: v1(91.87,148.92) 91.87,149.88 R520.1
SOC_EMU_05: length 63.7
  TOP w0.102: U24.W4 73.64,98.42 v2(74.07,97.99)
  TOP w0.127: v1(89.6,148.07) 89.7,148.07 90.35,148.72 R66.1
  L5 w0.114: v2(74.07,97.99) 73.63,98.43 73.63,101.01 74.38,101.76 74.38,102.94 75.67,104.24 75.67,105.98 77.3,107.61 77.3,117.63 77.98,118.31 77.98,124.38 80.29,126.7 80.29,129.54 80.65,129.9 85.34,129.9 85.72,130.28 87.51,130.28 89.08,131.84 89.08,133.28 89.99,134.19 89.99,144.98 90.65,145.64 90.65,147.02 v1(89.6,148.07)
SOC_EMU_05_R: length 3.7
  TOP w0.127: R66.2 91.26,148.6 92.67,147.18 EMU1.25
SOC_EMU_06: length 60.5
  TOP w0.102: v2(75.02,98.92) 74.52,98.42 U24.V4
  L5 w0.102: v2(75.02,98.92) 74.65,99.29 74.65,101 74.65,101.01
  L5 w0.114: v1(89.77,148.97) 89.77,148.89 91.13,147.53 91.13,145.27 90.47,144.61 90.47,133.99 89.56,133.08 89.56,131.64 87.71,129.79 85.92,129.79 82.75,126.62 81.88,126.62 79.67,124.41 79.67,114.83 78.92,114.07 78.92,109.7 78.42,109.2 78.41,109.2 78.12,108.91 78.12,108.91 77.82,108.6 77.82,107.38 76.29,105.85 76.29,103.72 75.4,102.84 75.4,101.76 74.65,101.01
  BOTTOM w0.127: v1(89.77,148.97) 89.89,149.1 R523.1
SOC_EMU_06_R: length 4.3
  TOP w0.127: EMU1.27 92.49,146.68 92.49,146.74 v1(91.9,147.32)
  BOTTOM w0.127: v1(91.9,147.32) 91.9,147.98 91.26,148.62 R523.2
SOC_EMU_07: length 59.8
  TOP w0.102: v2(76.02,98.92) 75.52,98.42 U24.U4
  L5 w0.114: v1(90.8,148.51) 91.37,147.94 91.37,144.01 90.95,143.6 90.95,133.79 90.07,132.91 90.07,130.12 86.58,126.63 83.91,126.63 82.55,125.27 82.55,122.52 81.66,121.63 81.66,119.25 80.25,117.84 80.25,114.17 80.11,114.03 80.11,110.31 79.44,109.65 79.44,106.5 77.47,104.52 77.47,103.63 76.4,102.57 76.4,101.86 75.63,101.08 75.63,99.31 v2(76.02,98.92)
  BOTTOM w0.127: R527.1 90.35,147.97 90.8,148.41 v1(90.8,148.51)
SOC_EMU_07_R: length 3.5
  TOP w0.127: EMU1.29 92.32,146.18 v1(92.23,146.28)
  BOTTOM w0.127: R527.2 91.26,147.25 v1(92.23,146.28)
SOC_EMU_08: length 57.7
  TOP w0.102: U24.U3 75.52,99.42 v2(76.02,99.92)
  TOP w0.127: R71.1 89.28,146.63 89.28,145.28 88.96,144.95 88.96,137.81 91.73,135.04 v1(91.73,134.37)
  L5 w0.114: v2(76.02,99.92) 76.41,100.32 76.41,101.17 76.63,101.39 76.63,102.16 78.86,104.39 78.86,105.16 79.9,106.2 79.9,109.07 80.37,109.54 80.37,113.94 80.49,114.07 80.49,117.74 81.9,119.15 81.9,120.8 83.57,122.47 83.57,124.4 85.11,125.94 86.86,125.94 90.76,129.84 90.76,132.61 91.73,133.58 v1(91.73,134.37)
SOC_EMU_08_R: length 4.1
  TOP w0.127: R71.2 91.26,147.12 91.69,146.69 91.69,146.18 92.08,145.8 92.58,145.8 92.7,145.68 EMU1.31
SOC_EMU_09: length 59.6
  TOP w0.102: U24.T3 76.52,99.42 76.94,99.84 v2(76.94,99.97)
  TOP w0.127: v1(93.76,133.78) 93.35,133.78 89.21,137.92 89.21,144.58 90.35,145.73 R78.1
  L5 w0.114: v2(76.94,99.97) 77.41,100.45 77.41,101.23 80.39,104.21 80.39,108.88 82.56,111.05 83.52,111.05 85.67,113.21 85.67,114.26 86.63,115.21 90.11,115.21 91.85,116.95 91.85,122.84 92.32,123.31 92.32,125.28 92.51,125.48 92.51,129.04 94.17,130.7 94.17,132.84 94.13,132.88 94.13,133.41 v1(93.76,133.78)
SOC_EMU_09_R: length 3.5
  TOP w0.127: EMU1.33 92.69,145.18 92.35,145.52 91.47,145.52 91.26,145.73 R78.2
SOC_EMU_10: length 60
  TOP w0.102: v2(71.02,98.92) 70.52,98.42 U24.AB4
  L5 w0.114: v1(89.73,146.29) 89.73,145.95 89.26,145.48 89.26,134.85 87.5,133.1 82.07,133.1 79.43,130.46 79.43,127.31 77.25,125.13 77.25,118.61 76.07,117.42 76.07,115.57 75.69,115.19 75.69,114.26 74.75,113.31 74.75,104.58 72.4,102.24 72.4,99.76 72.18,99.54 71.63,99.54 v2(71.02,98.92)
  BOTTOM w0.127: R529.1 90.35,146.29 v1(89.73,146.29)
SOC_EMU_10_R: length 3.5
  TOP w0.127: EMU1.35 92.53,144.68 v1(92.15,145.06)
  BOTTOM w0.127: v1(92.15,145.06) 91.26,145.96 R529.2
SOC_EMU_11: length 66.9
  TOP w0.102: v2(72.02,99.92) 71.52,99.42 U24.AA3
  L5 w0.114: v1(88.61,146.28) 86.57,148.32 79.15,148.32 75.18,144.35 75.18,143 74.35,142.16 74.35,134.06 77.01,131.39 77.01,119.67 75.76,118.42 75.76,115.6 75.44,115.28 75.44,114.35 74.5,113.41 74.5,104.68 72.08,102.25 72.08,99.99 v2(72.02,99.92)
  BOTTOM w0.127: v1(88.61,146.28) 89.98,144.91 R532.1
SOC_EMU_11_R: length 3.1
  TOP w0.127: v1(92.16,144.36) 92.35,144.18 EMU1.37
  BOTTOM w0.127: v1(92.16,144.36) 91.5,144.36 91.26,144.61 R532.2
SOC_EMU_12: length 55.3
  TOP w0.102: v2(76.02,97.92) 75.52,97.42 U24.U5
  L5 w0.114: v2(76.02,97.92) 76.02,97.95 75.41,98.55 75.41,101.17 75.63,101.39 75.63,102.55 77.09,104.01 77.09,104.52 79.2,106.64 79.2,111.44 79.19,111.45 79.19,113.91 79.96,114.67 79.96,123.02 84.22,127.28 84.7,127.28 86.91,129.49 87.75,129.49 89.83,131.58 89.83,133.01 90.71,133.89 90.71,143.97 v1(90.91,144.17)
  BOTTOM w0.127: v1(90.91,144.17) 90.35,143.62 R535.1
SOC_EMU_12_R: length 2.7
  TOP w0.127: EMU1.39 v1(92.19,143.68)
  BOTTOM w0.127: R535.2 92.02,143.51 v1(92.19,143.68)
SOC_EMU_13: length 59.8
  TOP w0.102: v2(77.02,98.92) 76.52,98.42 U24.T4
  TOP w0.127: v1(93.57,134.85) 92.64,134.85 89.47,138.02 89.47,144.02 R87.1
  L5 w0.114: v1(93.57,134.85) 93.32,134.59 93.32,133.35 93.93,132.74 93.93,130.8 93.67,130.54 93.67,130.54 92.27,129.14 92.27,125.58 92.08,125.38 92.08,123.41 90.84,122.17 86.68,122.17 84.95,120.44 84.95,116.67 83.77,115.49 83.59,115.49 83.17,115.06 83.17,114.28 82.93,114.05 82.93,111.76 80.14,108.97 80.14,105.99 79.25,105.11 79.25,104.39 78.23,103.38 78.23,102.36 77.19,101.31 76.86,101.31 76.63,101.08 76.63,100.22 76.55,100.13 76.55,99.4 77.02,98.93 v2(77.02,98.92)
SOC_EMU_13_R: length 4
  TOP w0.127: EMU1.41 91.95,143.18 91.64,143.49 91.64,144.53 R87.2
SOC_EMU_14: length 78.8
  TOP w0.102: v2(71.02,99.92) 70.52,99.42 U24.AB3
  L5 w0.114: v2(71.02,99.92) 71.02,100.05 71.65,100.68 71.65,102.81 74,105.16 74,110.8 73.44,111.35 73.44,117.1 73.61,117.28 73.61,130.05 73.62,130.06 73.62,143.09 74.42,143.89 74.42,144.79 75.89,146.26 75.89,148.64 78.69,151.43 78.69,152.73 80.5,154.54 84.96,154.54 v1(86,153.49)
  BOTTOM w0.127: v1(86,153.49) 87.05,152.44 87.05,151.59 88.16,150.48 88.16,145.01 89.97,143.2 89.97,143.19 90.2,142.96 90.21,142.96 90.35,142.82 R539.1
SOC_EMU_14_R: length 2.9
  TOP w0.127: EMU1.43 v1(92.33,142.68)
  BOTTOM w0.127: R539.2 91.76,142.11 v1(92.33,142.68)
SOC_EMU_15: length 56.1
  TOP w0.102: v2(78.02,100.03) 78.02,99.92 77.52,99.42 U24.R3
  TOP w0.127: R94.1 89.72,142.88 89.72,138.13 92.31,135.54 v1(94.67,135.54)
  L5 w0.114: v1(94.67,135.54) 94.61,135.48 94.61,133.08 94.65,133.04 94.65,130.5 93.03,128.88 93.03,125.1 92.8,124.87 92.8,123.11 92.33,122.64 92.33,116.75 90.21,114.63 88.14,114.63 82.79,109.28 82.79,105.48 78.45,101.15 78.45,100.46 v2(78.02,100.03)
SOC_EMU_15_R: length 3.5
  TOP w0.127: EMU1.45 92.13,142.18 91.26,143.06 R94.2
SOC_EMU_16: length 58.1
  TOP w0.102: v2(77.02,97.92) 76.52,97.42 U24.T5
  TOP w0.127: R103.1 89.97,141.73 89.97,138.23 92.33,135.88 94.38,135.88 94.49,135.98 94.5,135.98 v1(94.69,136.17)
  L5 w0.114: v2(77.02,97.92) 77.64,98.54 78.14,98.54 78.56,98.97 78.56,100.08 79.02,100.54 79.18,100.54 83.03,104.39 83.03,109.18 88.24,114.39 90.31,114.39 92.57,116.65 92.57,122.54 93.04,123.01 93.04,124.77 93.91,125.64 93.91,129.41 94.89,130.4 94.89,133.14 94.86,133.18 94.86,135.11 95.11,135.36 95.11,135.72 94.82,136.01 94.82,136.05 v1(94.69,136.17)
SOC_EMU_16_R: length 2.8
  TOP w0.127: EMU1.47 91.69,141.68 R103.2
SOC_EMU_17: length 53.4
  TOP w0.102: v2(78.01,98.96) 77.52,98.47 U24.R4
  TOP w0.127: v1(93.88,136.32) 92.66,136.32 90.35,138.63 R109.1
  L5 w0.114: v2(78.01,98.96) 78.01,99.03 77.63,99.41 77.63,101.11 81.53,105.01 81.53,108.7 87.8,114.96 90.2,114.96 92.09,116.85 92.09,122.74 92.56,123.21 92.56,124.97 92.75,125.16 92.75,128.94 94.41,130.6 94.41,132.94 94.37,132.98 94.37,133.51 94.34,133.54 94.34,135.25 93.88,135.71 v1(93.88,136.32)
SOC_EMU_17_R: length 2.8
  TOP w0.127: EMU1.49 91.72,141.18 R109.2
SOC_EMU_18: length 76.6
  TOP w0.102: U24.AA4 v2(72.02,97.92)
  L5 w0.114: v2(72.02,97.92) 71.95,97.92 71.53,98.35 71.04,98.35 70.63,98.76 70.63,99.08 71.08,99.54 71.18,99.54 71.5,99.86 71.5,100.23 71.86,100.59 71.86,102.52 74.24,104.9 74.24,113.54 75.2,114.5 75.2,115.38 75.52,115.7 75.52,118.52 76.77,119.77 76.77,131 74.11,133.67 74.11,142.43 74.93,143.26 74.93,144.43 79.05,148.56 86.67,148.56 88.32,146.91 88.6,146.91 89.05,146.46 89.05,145.82 88.04,144.81 v1(88.04,143.71)
  BOTTOM w0.127: v1(88.04,143.71) 89.06,143.71 89.97,142.8 89.97,141.68 90.35,141.3 R542.1
SOC_EMU_18_R: length 2.7
  TOP w0.127: v1(92.08,140.65) 92.11,140.68 EMU1.51
  BOTTOM w0.127: v1(92.08,140.65) 92.01,140.72 R542.2
SOC_EMU_19: length 91
  TOP w0.102: v2(93.01,70.05) 92.94,70.13 91.81,70.13 U24.A32
  TOP w0.127: R157.1 94.8,132.84 96.06,132.84 97.76,134.54 100.18,134.54 102.35,136.71 104.7,136.71 v1(104.71,136.71)
  L5 w0.102: 93.18,70.01 93.15,70.05 v2(93.01,70.05)
  L5 w0.114: v1(104.71,136.71) 104.71,135.82 105.27,135.25 105.27,127.95 105.93,127.29 105.93,121.36 106.38,120.91 107.13,120.91 107.47,120.57 107.47,117.09 106.65,116.28 106.65,107.62 99.31,100.27 99.31,74.17 97.26,72.11 97.26,70.75 95.44,68.94 94.26,68.94 93.18,70.01
SOC_EMU_19_R: length 10.6
  TOP w0.127: EMU1.53 92.58,140.18 91.95,139.55 91.95,138.3 92.48,137.77 94.48,137.77 95.35,136.9 95.35,135.17 R157.2
SOC_EMU_20: length 88.6
  TOP w0.102: 93.18,70.51 92.78,70.51 92.51,70.79 92.46,70.84 90.1,70.84 U24.C31
  TOP w0.127: v1(100.99,136.45) 100.99,135.89 100.03,134.92 97.4,134.92 R158.1 ; 93.18,70.51 94.13,70.51 v1(95.26,69.38)
  L5 w0.114: v1(95.26,69.38) 95.07,69.57 95.07,80.36 97.61,82.9 97.61,100.7 103.7,106.79 103.7,111.76 99.94,115.53 99.94,120.61 103.82,124.49 103.82,128.4 103.65,128.57 103.65,129.5 103.69,129.54 103.69,130.56 103.65,130.6 103.65,131.83 103.01,132.47 100.99,134.49 v1(100.99,136.45)
SOC_EMU_20_R: length 9.5
  TOP w0.127: R158.2 95.76,137.03 94.64,138.15 92.64,138.15 92.33,138.46 92.33,139.32 92.69,139.68 EMU1.55
SOC_EMU_21: length 106.2
  TOP w0.102: v2(92.99,69.44) 92.48,69.44 92.1,69.82 91.12,69.82 U24.B32
  TOP w0.127: v1(105.33,136.8) 105.41,136.88 105.79,136.88 107.95,139.04 111.42,139.04 112.07,139.69 112.07,140.95 111.06,141.95 111.06,143.64 111.13,143.71 111.13,146.94 107.16,150.91 104.55,150.91 104.01,150.38 104.01,150.37 R63.2
  L5 w0.102: v2(92.99,69.44) 93.01,69.44 93.18,69.27
  L5 w0.114: v1(105.33,136.8) 105.33,136.37 105.61,136.09 105.61,128.09 106.91,126.79 106.91,121.61 107.81,120.71 107.81,116.7 107,115.89 107,107.47 100.78,101.26 100.78,80.86 100.9,80.75 100.9,74.75 100.29,74.14 99.79,74.14 97.6,71.96 97.6,70.61 95.59,68.59 93.86,68.59 93.18,69.27
SOC_EMU_21_R: length 3
  TOP w0.127: EMU1.18 100.98,149.18 102.04,150.24 R63.1
SOC_EMU_22: length 102.6
  TOP w0.102: v2(92.99,68.85) 92.49,68.85 91.92,69.42 U24.A33
  TOP w0.127: v1(105.46,137.57) 105.84,137.57 107.75,139.47 111.31,139.47 111.69,139.85 111.69,140.79 110.68,141.8 110.68,143.79 110.75,143.86 110.75,146.78 107.17,150.37 R64.1
  L5 w0.102: 93.18,68.66 v2(92.99,68.85)
  L5 w0.114: 93.18,68.66 93.61,68.23 96.47,68.23 97.94,69.71 97.94,70.8 99.6,72.46 100.77,72.46 101.61,73.31 101.61,75.14 101.73,75.25 101.73,101.6 107.39,107.26 107.39,113.76 108.15,114.52 108.15,120.85 107.59,121.42 107.59,126.6 105.96,128.23 105.96,137.07 v1(105.46,137.57)
SOC_EMU_22_R: length 5.8
  TOP w0.127: EMU1.20 101.03,148.68 102.02,149.67 104.01,149.67 R64.2
