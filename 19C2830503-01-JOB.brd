# Allegro board 19C2830503-01-JOB.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FARM1_PWM-2A: length 311
  TOP w0.254: U8.38 v1(119.6,141.5) ; v1(32.76,78.7) 32.76,78.69 32.61,78.53 U25.19
  L3 w0.254: v1(32.76,78.7) 31.49,77.42 24.56,77.42 24.09,77.89 20.82,77.89 18.1,75.17 16.9,75.17 16.5,75.58 11.94,75.58 11.16,74.8 11.16,63.58 14.52,60.22 14.52,53.56 23.85,44.22 23.85,37.03 25.51,35.37 25.51,32.79 27.87,30.43 136.18,30.43 139.33,33.58 139.33,47.66 137.05,49.95 137.05,53.25 136.4,53.9 136.4,90.53 134.87,92.05 134.87,102.62 138,105.74 138,117.97 134.44,121.53 133.98,121.53 133.32,122.18 133.32,122.23 133.17,122.38 133.17,131.03 128.01,136.19 125.08,136.19 119.77,141.5 v1(119.6,141.5)
FARM1_PWM-3A: length 31.1
  TOP w0.254: v1(33.65,80.02) 33.51,80.02 33.15,79.65 32.47,79.65 32.45,79.63 32.44,79.63 32.34,79.53 U25.21 ; U23.1 14.76,93.36 v1(14.73,93.33)
  L3 w0.254: v1(33.65,80.02) 33.65,80.46 28.26,85.85 18.67,85.85 14.48,90.04 14.48,93.07 v1(14.73,93.33)
FARM1_PWM-4A: length 46.6
  TOP w0.254: v1(32.68,80.59) 32.63,80.53 U25.23 ; v1(16.38,105.66) 16.25,105.79 15.16,105.79 14.25,104.88 14.25,103.23 14.76,102.71 U23.26
  L3 w0.254: v1(16.38,105.66) 16.38,104.49 15.57,103.68 15.57,96.46 13.88,94.77 13.88,89.8 18.42,85.26 28.01,85.26 v1(32.68,80.59)
FARM1_RDLY2: length 2.2
  TOP w0.254: U8.39 120.1,141.71 120.27,141.53 R113.2
FARM1_SRE_A1: length 2
  TOP w0.279: U27.3 23.11,65.63 R386.1
FARM1_SRE_A2: length 2
  TOP w0.254: R92.1 114.38,143.95 U8.31
FARM1_SRE_A3: length 3.1
  TOP w0.254: R329.1 15.26,92.93 U23.2
FARM1_SRE_A4: length 2.3
  TOP w0.254: U23.25 15.26,103.29 R318.1
FARM1_SW_SHAPE1: length 5.4
  TOP w0.279: C292.1 20.64,65.93 21.36,66.65 21.36,67.79 21.59,68.03 U27.6
FARM1_SW_SHAPE2: length 7.1
  TOP w0.508: 124.43,142.75 C63.1
  L5 w0.254: v1(121.18,142.04) 121.31,142.16 121.31,142.46 121.93,143.08 123.95,143.08 v1(124.08,143.22)
  BOTTOM w0.254: v1(121.18,142.04) 120.9,141.76 120.51,141.76 120.31,141.96 R538.1
FARM1_UCD_EAN1: length 31.1
  TOP w0.254: v1(15.53,87.24) 15.53,86.32 16.2,85.66 R343.2 C236.2 20.26,85.66 21.89,84.03 U25.51
  L8 w0.254: v1(15.53,87.24) 15.64,87.35 18.49,87.35 v1(20.02,88.87)
  BOTTOM w0.254: R668.1 33.27,89.05 31.6,90.73 29.74,90.73 29.29,90.27 21.28,90.27 20.02,89.01 v1(20.02,88.87)
FARM1_UCD_EAN2: length 185.3
  TOP w0.254: v1(13.46,87.44) 13.42,87.44 12.85,86.88 12.85,85.87 14.37,84.35 17.73,84.35 18.46,83.62 R347.2 C239.2 20.52,83.62 21.11,83.03 U25.53
  L5 w0.254: v1(13.46,87.44) 11.55,89.36 8.47,89.36 7.38,88.27 7.38,36.97 8.29,36.07 15.37,36.07 16.78,34.66 22.37,34.66 23.88,33.15 105.34,33.15 107.7,35.5 107.7,41.15 v1(107.19,41.66)
  BOTTOM w0.254: v1(107.19,41.66) 107.19,42.16 108.46,43.43 109.47,43.43 110.04,44 R756.1
FARM1_UCD_EAN3: length 5.6
  TOP w0.254: R352.1 R353.2 C244.2 20.63,82.03 U25.55
FARM1_UCD_EAN4: length 6
  TOP w0.254: U25.57 21.66,81.03 C252.2 R358.2 R357.1
FARM1_UCD_EAP1: length 22.8
  TOP w0.254: v1(16.13,86.74) 16.51,86.36 R342.1
  L8 w0.254: v1(16.13,86.74) 18.92,86.74 20.68,88.49 v1(20.68,88.95)
  BOTTOM w0.254: R670.1 34.3,88.65 33.05,88.65 31.34,90.35 30.02,90.35 29.37,89.7 21.35,89.7 20.68,89.03 v1(20.68,88.95)
FARM1_UCD_EAP2: length 171.7
  TOP w0.254: v1(13.49,86.79) 13.24,86.54 13.24,86.03 14.3,84.96 R345.1
  L5 w0.254: v1(107.19,40.89) 107.19,35.53 105.19,33.53 24.13,33.53 22.61,35.05 16.92,35.05 15.52,36.45 8.45,36.45 7.76,37.13 7.76,85.26 10.68,88.17 12.14,88.17 12.91,87.4 12.91,86.94 13.06,86.79 v1(13.49,86.79)
  BOTTOM w0.254: R757.1 108.98,43.89 107.14,43.89 106.43,43.18 106.43,41.53 107.19,40.77 v1(107.19,40.89)
FARM1_UCD_EAP3: length 1.1
  TOP w0.254: R349.1 R348.1
FARM1_UCD_EAP4: length 1.1
  TOP w0.254: R356.1 R355.1
FARM1_UCD_EN: length 256.2
  TOP w0.254: v1(128.35,115.14) 128.91,115.7 R246.1 ; v1(36.93,83.95) 36.55,84.33 R346.2
  L3 w0.254: v1(26.01,49.68) 29.39,46.3 29.39,42.95 29.29,42.85 29.29,33.71 30.33,32.66 105.96,32.66 110.01,36.71 110.01,41.55 114.69,46.22 124.26,46.22 125.25,45.24 126.68,45.24 126.97,45.53 126.97,47.8 131.5,52.33 131.5,82.95 131.16,83.29 131.16,111.21 128.35,114.02 v1(128.35,115.14)
  L8 w0.254: v1(26.01,49.68) 25.39,50.3 23.29,50.3 19.82,53.77 19.82,70.87 20.94,71.99 25.1,71.99 27.64,74.53 36.25,74.53 36.7,74.98 36.7,75.61 35,77.32 35,82.01 v1(36.93,83.95)
FARM1_UCD_EN_L: length 4.9
  TOP w0.254: R346.1 35.24,84.32 R351.2 35.14,83.03 U25.28
FARM1_UCD_EN_R: length 2.2
  TOP w0.254: U13.5 128.66,119.95 R246.2
FARM1_UCD_TEMP1: length 11.4
  TOP w0.254: U25.5 25.55,75.21 25.26,74.92 24.75,74.92 24.2,74.36 C280.2 23.55,74.36 23.24,74.68 v1(23.24,74.97)
  TOP w0.279: C723.2 22.55,71.3 22.8,71.05 22.8,71.05 v1(23.11,70.74) U27.10
  BOTTOM w0.254: v1(23.24,74.97) 22.86,74.59 22.86,74.21 22.58,73.93 22.58,71.27 v1(23.11,70.74)
FARM1_UCD_TEMP2: length 295.9
  TOP w0.254: U25.6 26.06,75.05 25.37,74.36 C281.2 24.83,74.36 24.41,73.94 24.41,73.13 v1(24.64,72.9)
  L3 w0.254: v1(119.41,44.83) 118.75,44.17 113.17,44.17 111.06,42.06 111.06,37.22 106.11,32.28 28.45,32.28 27.22,33.5 27.22,38.4 27.79,38.97 27.79,42.36 27.41,42.75 27.41,47.5 25.16,49.74 25.16,61.93 23.95,63.14 17.03,63.14 15.62,64.55 15.62,70.65 17.19,72.21 23.95,72.21 v1(24.64,72.9)
  L5 w0.254: v1(122.74,151.2) 122.05,151.89 111.51,151.89 110.49,150.88 110.49,146.69 114.6,142.57 114.6,141.04 115.97,139.67 116.67,139.67 120.19,136.15 120.19,131.5 120.37,131.33 120.37,130.9 120.19,130.73 120.19,128.96 124.18,124.97 124.18,119.46 127.05,116.59 127.84,115.8 127.84,114.93 129.06,113.71 129.06,84.71 127.41,83.06 127.41,82.07 128.57,80.91 128.57,66.2 127.99,65.61 127.99,52.84 119.98,44.83 v1(119.41,44.83)
  BOTTOM w0.254: v1(122.74,151.2) 122.8,151.14 Q15.3
FARM1_UCD_TEMP3: length 55.3
  TOP w0.254: U25.62 21.89,78.53 20.7,77.34 17.4,77.34 17.08,77.02 C269.2 17.08,76.24 v1(17.55,75.77) 19.89,75.77 22.15,78.03 U25.63 ; v1(19.05,103.76) 19.62,103.76 C186.1 19.23,103.12 18.67,103.12 18.31,102.77 18.31,102.18 18.26,102.13 U23.19
  L3 w0.254: v1(19.05,103.76) 16.97,105.83 16.97,105.91 16.62,106.26 16.14,106.26 14.95,105.07 14.95,96.79 13.28,95.12 13.28,88.57 17.55,84.3 v1(17.55,75.77)
FARM1_UCD_VIN: length 7.5
  TOP w0.254: U25.4 25.06,75.65 24.77,75.36 23.98,75.36 23.86,75.48 22.65,75.48 22.23,75.06 C279.1 R376.1 19.95,74.36 R375.2
FARM1_VGG2: length 1.3
  TOP w0.279: U8.3 v1(122.61,144.45)
FT2232HL_RESET#1: length 2.4
  TOP w0.127: R16.2 160.2,168.8 159.51,168.1 U3.14
FTDI_MCU_U0RX: length 51.2
  TOP w0.127: v1(142.15,138.09) 142.31,138.09 142.39,138.17 U12.2 ; U3.38 145.9,166.6 145.84,166.66 145.7,166.66 145.7,166.66 143.62,166.66 143.13,166.17 143.13,164.59 143.33,164.39 v1(143.45,164.39)
  L8 w0.114: v1(142.15,138.09) 142.18,138.09 143.28,139.19 151.03,139.19 156.08,144.25 156.08,146.05 155.44,146.7 155.44,150.09 153.25,152.28 151.43,152.28 151.28,152.42 148.91,152.42 146.9,154.42 146.9,154.96 144.5,157.36 144.5,163.35 v1(143.45,164.39)
FTDI_SOC_U0RX: length 147.8
  TOP w0.127: U3.16 156.97,169.1 156.97,169.11 v1(156.94,169.14) ; v1(82.73,114.47) 82.65,114.54 81.7,114.54 80.87,113.72 80.87,113.41 80.62,113.16 U55.2
  L8 w0.114: v1(156.94,169.14) 156.87,169.08 156.87,167.36 159.76,164.47 164.74,164.47 165.99,163.22 165.99,161.8 166.37,161.42 166.37,155.98 165.6,155.21 165.6,149.98 163.49,147.87 163.49,145.78 162,144.3 162,141.92 161.05,140.97 159.77,140.97 156.03,137.23 156.03,135.02 154.39,133.39 154.39,123.02 v1(152.78,121.41)
  L10 w0.114: v1(82.73,114.47) 82.91,114.65 82.91,115.29 83.87,116.25 84.4,116.25 84.91,116.76 84.91,117.19 84.98,117.25 84.98,120.95 86.11,122.09 91.73,122.09 94.5,124.85 102.78,124.85 102.92,124.71 103.67,124.71 104.52,125.56 104.88,125.56 105.14,125.3 105.14,125.1 106.1,124.14 106.59,124.14 110.79,119.94 115.67,119.94 117.17,118.44 138.23,118.44 139.33,119.55 142.46,119.55 143.21,120.29 147.17,120.29 148.29,121.41 v1(152.78,121.41)
FULL_RESETZ: length 40
  TOP w0.127: R152.2 170.18,134.37 170.81,135 172.21,135 172.72,135.51 172.72,141.35 168.24,145.83 CN8.1 ; R152.2 R161.1 ; R152.2 C77.1 ; U7.87 156.46,153.83 157.06,153.22 161.35,153.22 v1(161.35,153.23)
  BOTTOM w0.127: CN8.1 168.56,145.83 169.04,146.3 169.04,149.22 165.48,152.78 161.8,152.78 v1(161.35,153.23)
GPS_ENABLE: length 14.8
  TOP w0.102: 142.42,44.96 147.07,44.96 147.78,44.24 GPS1.C4
  TOP w0.127: 142.42,44.96 140.59,44.96 139.12,46.42 R433.2 ; GPS1.C4 v2(148.57,44.99)
  BOTTOM w0.127: R762.1 149.35,44.21 v2(148.57,44.99)
GPS_PPS: length 154.1
  TOP w0.102: v2(147.27,39.19) 147.82,39.74 GPS1.C1
  BOTTOM w0.102: 146.57,38.49 v2(147.27,39.19)
  BOTTOM w0.127: 146.57,38.49 145.92,37.85 143.23,37.85 136.22,30.84 34.37,30.84 30.48,34.72 30.48,42.37 24.89,47.96 24.89,59.07 23.77,60.2 22.4,60.2 CN17.1
GPS_RF: length 27.9
  TOP w0.127: C369.1 L11.2 170.38,35.88 169.42,34.92 165.81,34.92 165.38,35.36 153.7,35.36 GPS1.B1
GPS_RTC_CLK: length 5.6
  TOP w0.127: R423.1 149.35,49.78 148.62,49.05 148.62,46.54 GPS1.C5
GPS_RTC_CLK_R: length 5.7
  TOP w0.127: OSC4.3 148.45,55.69 149.35,54.79 R423.2
GPS_UARTRXD: length 155.3
  TOP w0.127: U21.2 76.2,116.45 75.82,116.08 75.82,114.63 v1(76.17,114.28)
  L3 w0.102: 79.63,104.01 81.53,102.11 v2(81.74,102.11)
  L3 w0.114: 79.63,104.01 78.99,104.65 78.99,104.85 77.11,106.73 77.11,113.33 v1(76.17,114.28)
  L10 w0.102: v2(81.74,102.11) 82.37,102.74
  L10 w0.114: v2(147.07,41.99) 147.61,41.99 151.73,46.11 151.73,54.38 146.55,59.56 144.09,59.56 140.8,62.85 136.7,62.85 135.41,64.14 135.41,77.16 125.86,86.72 125.86,110.35 123.7,112.51 119.74,112.51 118.22,110.99 116.6,110.99 115.95,111.63 115.95,111.63 115.8,111.78 103.74,111.78 101.98,113.54 97.99,113.54 91.38,106.93 87.88,106.93 85.72,104.78 84.4,104.78 82.37,102.74
  BOTTOM w0.114: v2(147.07,41.99) 146.81,42.25 R774.1
GPS_UARTRXD_R: length 2.8
  TOP w0.102: GPS1.C3 v2(148.57,43.49)
  BOTTOM w0.102: v2(148.57,43.49) 148.56,43.5 R774.2
GPS_UARTTXD: length 150
  TOP w0.114: GPS1.B3 v2(150.07,43.49)
  TOP w0.127: U26.4 108.65,63.1 109.1,62.65 v1(109.2,62.65)
  L5 w0.114: v1(115.24,113.03) 115.24,112.58 113.11,110.44 113.11,69.52 109.55,65.97 109.55,63 v1(109.2,62.65)
  L10 w0.114: v1(115.24,113.03) 115.42,113.21 119.23,113.21 119.59,112.85 123.69,112.85 126.18,110.37 126.18,86.73 135.66,77.26 135.66,64.24 136.8,63.09 140.9,63.09 144.05,59.94 146.69,59.94 152.25,54.38 152.25,45.68 v2(150.07,43.49)
GTX_CLK: length 9.2
  BOTTOM w0.127: R592.2 139.35,108.63 139.35,105.07 141.6,102.81 141.6,102.11 142.15,101.57 PHY2.E2
GTX_CLK_0: length 9.9
  BOTTOM w0.127: PHY1.E2 141.71,77.54 141.71,78.41 141.15,78.97 139.93,78.97 139.35,79.55 139.35,84.23 R663.2
HEAD_UCD_CNTRL_L: length 19.8
  TOP w0.254: U16.28 113.89,118.77 114.17,118.49 114.91,118.49 115.34,118.92 116.26,118.92 116.99,118.19 116.99,117.44 R268.2 118.36,117.41 R267.1 118.55,114.48 117.92,113.86 111.42,113.86 110.83,114.44 110.83,115.38 111.12,115.67 D7.2
HYPER0_LINK_CLKN: length 72
  TOP w0.102: v1(90.56,124.26) 90.56,124.08 90.66,123.98 90.77,123.98 90.87,123.88 90.87,123 90.62,122.76 U19.15
  L8 w0.102: v1(90.56,124.26) 90.58,124.26 90.74,124.42 arc(90.79,124.49) 90.81,124.58 arc(90.8,124.64) 90.77,124.69 arc(90.76,124.71) 90.75,124.72 arc(90.72,124.73) 90.7,124.74 76.8,124.74 arc(76.41,124.66) 76.08,124.44 74.01,122.37 arc(73.44,121.52) 73.24,120.52 73.24,115.73 arc(73.17,115.34) 72.95,115.01 72.48,114.55 arc(72.37,114.38) 72.33,114.19 72.33,110.28 arc(72.31,110.11) 72.27,109.93 72.12,109.55 arc(72.02,109.34) 71.87,109.17 71.82,109.11 arc(71.81,109.11) 71.81,109.1 71.21,108.5 arc(70.88,108.28) 70.49,108.2 70.19,108.2 arc(69.9,108.15) 69.65,107.98 65.15,103.47 arc(64.9,103.31) 64.61,103.25 52.92,103.25 arc(52.75,103.23) 52.59,103.17 arc(52.58,103.17) 52.58,103.17 52.56,103.16 arc(52.54,103.15) 52.53,103.14 arc(52.45,103.09) 52.38,103.03 51.37,102.02 51.37,102.02 44.98,95.63 arc(44.82,95.38) 44.76,95.1 44.75,94.97 arc(44.75,94.93) 44.76,94.89 arc(44.91,94.61) v1(45.21,94.49)
  BOTTOM w0.102: v1(45.21,94.49) 44.88,94.49 44.78,94.39 44.78,94.21 44.96,94.03 45.75,94.03 46.13,94.41 46.32,94.41 46.41,94.41 46.42,94.4 46.42,94.41 46.52,94.4 46.67,94.4 46.79,94.52 C534.1
HYPER0_LINK_CLKP: length 72
  TOP w0.102: U19.14 91.12,124.19 v1(91.19,124.26)
  L8 w0.102: v1(91.19,124.26) 91.13,124.31 arc(91.08,124.4) 91.06,124.5 91.06,124.58 arc(91.04,124.72) 90.97,124.84 arc(90.95,124.87) 90.93,124.9 arc(90.82,124.97) 90.7,124.99 76.8,124.99 arc(76.31,124.9) 75.9,124.62 73.83,122.55 arc(73.21,121.62) 72.99,120.52 72.99,115.73 arc(72.93,115.44) 72.77,115.19 72.3,114.73 arc(72.13,114.48) 72.07,114.19 72.07,110.28 arc(72.06,110.15) 72.03,110.02 71.89,109.63 arc(71.81,109.48) 71.7,109.35 71.64,109.29 arc(71.64,109.29) 71.63,109.28 71.03,108.68 arc(70.78,108.52) 70.49,108.46 70.19,108.46 arc(69.8,108.38) 69.47,108.16 64.97,103.65 arc(64.8,103.54) 64.61,103.5 52.92,103.5 arc(52.69,103.48) 52.48,103.4 arc(52.47,103.4) 52.46,103.39 arc(52.45,103.39) 52.44,103.39 arc(52.42,103.37) 52.4,103.36 arc(52.29,103.29) 52.2,103.21 51.63,102.63 44.8,95.81 arc(44.58,95.48) 44.5,95.1 44.5,94.98 arc(44.41,94.69) v1(44.2,94.49)
  BOTTOM w0.102: C524.1 46.5,94.14 46.4,94.15 46.31,94.16 46.23,94.16 45.85,93.78 44.85,93.78 44.53,94.1 44.53,94.4 44.43,94.49 v1(44.2,94.49)
HYPER0LINKCLKN_C: length 13.1
  TOP w0.102: v2(56.06,91.88) 56.06,91.96 U24.AT10
  BOTTOM w0.102: v2(56.06,91.88) 56.26,92.08 56.6,92.08 56.9,92.38 56.9,93.2 56.54,93.55 55.47,93.55 54.89,92.96 51.59,92.96 50.8,93.75 49.56,93.75 48.66,94.65 48.3,94.65 C534.2
HYPER0LINKCLKP_C: length 13.1
  TOP w0.102: v2(56.06,92.84) 56.69,92.84 56.79,92.94 56.79,93.15 U24.AT9
  BOTTOM w0.102: C524.2 48.24,94.39 48.55,94.39 49.45,93.5 50.69,93.5 51.48,92.71 54.99,92.71 55.58,93.29 56.44,93.29 56.64,93.09 56.64,92.49 56.49,92.34 56.39,92.34 56.06,92.67 v2(56.06,92.84)
HYPER1_LINK_CLKN: length 48.4
  TOP w0.102: v1(89.81,125.58) 89.71,125.48 89.71,123.5 89.99,123.22 89.99,122.84 90.12,122.71 U19.16 ; C191.1 57.89,109.64 57.89,110.47 v1(57.81,110.55)
  L8 w0.102: v1(57.81,110.55) 57.88,110.62 57.88,111.32 58.29,111.74 58.29,112.77 61.47,115.95 61.47,120.65 63.16,122.34 69.18,122.34 72.87,126.03 82.93,126.03 83.39,126.49 89.46,126.49 89.79,126.16 89.79,125.6 v1(89.81,125.58)
HYPER1_LINK_CLKP: length 48.2
  TOP w0.102: U19.17 89.62,122.73 89.74,122.85 89.74,123.11 89.46,123.39 89.46,125.27 v1(89.18,125.55) ; v1(58.44,110.56) 58.14,110.26 58.14,109.5 58.48,109.16 C187.1
  L8 w0.102: v1(89.18,125.55) 89.18,125.55 89.53,125.91 89.53,126.06 89.35,126.24 83.49,126.24 83.04,125.78 72.98,125.78 69.29,122.09 63.27,122.09 61.72,120.54 61.72,116.08 61.73,116.07 61.73,115.85 58.55,112.67 58.55,111.63 58.13,111.22 58.13,110.84 58.41,110.56 v1(58.44,110.56)
HYPER1LINKCLKN_C: length 13.9
  TOP w0.102: C191.2 57.85,107.82 57.85,107.36 52.39,101.9 52.39,98.49 53.14,97.74 53.47,97.74 53.52,97.69 U24.AW5
HYPER1LINKCLKP_C: length 13.9
  TOP w0.102: U24.AW4 53.52,98.09 53.42,97.99 53.24,97.99 52.64,98.59 52.64,101.79 58.1,107.25 58.1,107.94 58.42,108.26 C187.2
HYPERLINK0_RXFLCLK: length 69.7
  L8 w0.114: v1(32.15,121.79) 32.13,121.79 31.98,121.95 30.64,121.95 28.01,119.32 14.99,119.32 J1.C3
  BOTTOM w0.127: R628.2 62.87,98.42 62.53,98.75 62.53,99.16 62.12,99.57 61.14,100.55 59.61,100.55 59.39,100.33 58.1,100.33 58.06,100.29 56.2,100.29 51.14,105.35 43.27,105.35 40.63,107.99 40.63,114.54 38.73,116.43 38.73,121.54 36.7,123.57 34.01,123.57 32.38,121.95 32.3,121.95 v1(32.15,121.79)
HYPERLINK0_RXFLCLK_R: length 1.2
  TOP w0.102: U24.AJ5 63.07,96.98 v2(63.04,96.98)
  BOTTOM w0.102: v2(63.04,96.98) 62.99,97.03 R628.1
HYPERLINK0_RXFLDAT: length 68.7
  TOP w0.102: U24.AJ4 63.04,98.9 v2(63.04,99.01)
  L8 w0.114: J1.D3 15.95,119.56 27.91,119.56 30.54,122.19 31.92,122.19 31.97,122.23 32.04,122.23 v1(32.23,122.43)
  BOTTOM w0.127: v1(32.23,122.43) 32.38,122.58 32.66,122.58 33.91,123.82 36.81,123.82 38.99,121.64 38.99,116.53 40.88,114.64 40.88,108.28 43.47,105.69 51.31,105.69 56.45,100.54 57.96,100.54 58,100.58 59.13,100.58 59.49,100.94 61.11,100.94 v2(63.04,99.01)
HYPERLINK0_RXN0: length 61.6
  TOP w0.102: J1.B4 10.13,123.31 arc(10.06,123.3) 10,123.26 9.83,123.09 arc(9.76,122.98) 9.73,122.84 9.72,122.83 9.73,122.84 9.73,122.57 arc(9.76,122.39) 9.87,122.24 arc(10.02,122.14) 10.2,122.1 26.31,122.1 arc(26.55,122.05) 26.75,121.92 arc(26.88,121.72) 26.92,121.49 26.92,120.79 arc(26.72,120.3) 26.24,120.1 arc(25.93,119.97) 25.81,119.67 25.81,119.54 arc(25.9,119.33) 26.11,119.24 26.24,119.24 arc(26.92,118.55) 26.24,117.86 arc(25.93,117.74) 25.81,117.43 25.81,117.31 arc(25.9,117.09) 26.11,117 26.24,117 arc(26.72,116.8) 26.92,116.32 26.92,116.07 arc(26.96,115.89) 27.06,115.74 arc(27.22,115.63) 27.4,115.6 29.63,115.6 arc(30.02,115.52) 30.35,115.3 31.77,113.87 arc(32.45,113.32) 33.22,112.91 arc(33.48,112.83) 33.76,112.8 34.89,112.8 arc(35.18,112.74) 35.43,112.58 37.41,110.59 arc(38.18,109.44) 38.46,108.07 38.46,107.3 arc(38.67,106.24) 39.27,105.33 39.41,105.19 39.99,104.62 arc(40.21,104.29) 40.28,103.9 40.28,103.57 arc(40.11,103.16) 39.7,102.99 38.86,102.99 arc(38.43,102.56) 38.86,102.13 39.6,102.13 arc(40.08,101.93) 40.28,101.45 40.28,100.64 arc(40.64,98.85) 41.65,97.34 42.48,96.51 arc(42.63,96.39) 42.81,96.29 42.87,96.27 arc(42.93,96.24) 42.99,96.23 43.04,96.22 arc(43.06,96.22) 43.08,96.22 45.03,96.22 arc(45.23,96.26) 45.4,96.39 45.42,96.4 arc(45.5,96.54) 45.52,96.69 C216.1
HYPERLINK0_RXN0_C: length 11.9
  TOP w0.102: U24.AW10 53.52,92.31 arc(53.5,92.21) 53.44,92.13 arc(53.36,92.07) 53.26,92.05 52.66,92.05 arc(52.37,91.99) 52.12,91.83 51.5,91.21 arc(51.25,91.04) 50.96,90.98 50.1,90.98 arc(49.81,91.04) 49.56,91.21 49.33,91.45 arc(49.11,91.7) 48.96,92 arc(48.91,92.13) 48.87,92.27 48.83,92.48 arc(48.82,92.55) 48.82,92.62 48.82,92.62 48.82,93.95 arc(48.81,94.08) 48.79,94.22 48.71,94.64 arc(48.65,94.88) 48.56,95.12 48.54,95.18 arc(48.34,95.55) 48.08,95.86 47.79,96.16 47.77,96.16 arc(47.48,96.31) 47.16,96.37 46.89,96.37 arc(46.53,96.53) C216.2
HYPERLINK0_RXN1: length 57.5
  TOP w0.102: C210.1 43.11,97.9 arc(43.04,97.73) 42.88,97.66 arc(42.66,97.71) 42.48,97.83 42.1,98.21 arc(41.79,98.59) 41.56,99.02 41.45,99.27 arc(41.37,99.5) 41.31,99.74 41.19,100.37 arc(41.16,100.56) 41.15,100.76 41.15,104.95 arc(41.12,105.25) 41.03,105.54 40.96,105.71 arc(40.64,106.31) 40.22,106.82 39.77,107.27 arc(39.61,107.52) 39.55,107.81 39.55,108.69 arc(39.29,109.98) 38.56,111.07 36.7,112.94 arc(36.32,113.25) 35.88,113.48 35.66,113.58 arc(35.44,113.64) 35.21,113.66 34.33,113.66 arc(34.05,113.69) 33.78,113.77 arc(33,114.19) 32.31,114.76 30.81,116.26 arc(30.56,116.43) 30.26,116.48 28.7,116.48 arc(28.38,116.62) 28.24,116.94 28.24,117.78 arc(28.27,117.92) 28.35,118.04 28.47,118.16 arc(28.62,118.39) 28.68,118.65 28.68,122.05 arc(28.6,122.45) 28.37,122.79 28.24,122.92 arc(28,123.08) 27.71,123.14 26.96,123.14 arc(26.67,123.2) 26.42,123.36 26.37,123.42 arc(26.2,123.66) 26.14,123.95 26.14,126.07 arc(26.09,126.37) 25.92,126.61 25.61,126.92 arc(25.37,127.09) 25.08,127.14 10.13,127.14 arc(9.98,127.17) 9.85,127.26 arc(9.76,127.39) 9.73,127.55 9.73,127.8 arc(9.86,128.14) J1.B6
HYPERLINK0_RXN1_C: length 15
  TOP w0.102: C210.2 44.01,98.16 arc(44.03,98.06) 44.09,97.97 arc(44.18,97.91) 44.28,97.89 46.9,97.89 arc(47.13,97.87) 47.36,97.8 47.6,97.7 arc(48.03,97.47) 48.41,97.16 50.88,94.69 50.88,94.69 51.07,94.5 arc(51.21,94.29) 51.26,94.05 51.26,94.02 arc(51.31,93.75) 51.46,93.52 51.7,93.28 arc(51.76,93.23) 51.82,93.19 arc(51.87,93.16) 51.92,93.13 arc(52.08,93.08) 52.24,93.06 53.03,93.06 arc(53.09,93.04) 53.15,93.01 53.55,93.01 arc(53.76,92.97) 53.94,92.85 arc(54.06,92.67) 54.1,92.46 54.1,92.18 arc(54.11,92.14) 54.13,92.11 54.15,92.08 arc(54.21,92.05) 54.28,92.03 55.28,92.03 arc(55.37,92.05) 55.45,92.1 arc(55.5,92.18) 55.52,92.27 U24.AU10
HYPERLINK0_RXN2: length 60.7
  TOP w0.102: C200.1 45.6,99.95 arc(45.65,99.93) 45.67,99.88 45.67,99.63 arc(45.58,99.41) 45.35,99.31 43.9,99.31 arc(43.61,99.37) 43.36,99.54 42.37,100.53 arc(42.21,100.77) 42.15,101.06 42.15,105.41 arc(42.12,105.74) 42.02,106.05 41.88,106.41 arc(41.61,106.9) 41.26,107.33 40.89,107.7 arc(40.72,107.95) 40.67,108.24 40.67,109.21 arc(40.66,109.3) 40.65,109.39 40.59,109.66 arc(40.53,109.9) 40.45,110.13 40.37,110.34 arc(40.11,110.82) 39.76,111.24 36.91,114.09 arc(36.53,114.4) 36.1,114.64 35.75,114.78 arc(35.43,114.88) 35.09,114.91 34.48,114.91 arc(34.4,114.91) 34.32,114.93 34.31,114.93 arc(33.76,115.09) 33.26,115.36 arc(32.8,115.71) 32.37,116.09 29.89,118.57 arc(29.73,118.82) 29.67,119.11 29.67,122.75 arc(29.61,123.04) 29.44,123.29 27.43,125.3 arc(27.26,125.55) 27.2,125.84 27.2,130.09 arc(27.15,130.38) 26.98,130.63 25.72,131.88 arc(25.48,132.05) 25.18,132.11 10.09,132.11 arc(9.94,132.14) 9.82,132.22 arc(9.73,132.35) 9.7,132.49 9.7,132.55 arc(9.76,132.84) 9.92,133.09 10.13,133.29 arc(10.15,133.3) 10.17,133.31 J1.B8
HYPERLINK0_RXN2_C: length 11.6
  TOP w0.102: C200.2 46.42,99.53 arc(46.44,99.45) 46.48,99.39 arc(46.54,99.35) 46.61,99.34 47.33,99.34 arc(47.54,99.32) 47.73,99.26 47.94,99.17 arc(48.32,98.97) 48.65,98.7 48.95,98.4 52.38,94.97 52.36,94.95 53.16,94.15 arc(53.28,94.07) 53.42,94.03 53.59,94.01 arc(53.81,93.94) 54,93.79 arc(54.1,93.61) 54.13,93.4 arc(54.15,93.24) 54.25,93.12 arc(54.33,93.09) 54.41,93.12 arc(54.51,93.25) U24.AV9
HYPERLINK0_RXN3: length 62.1
  TOP w0.102: C190.1 43.62,101.58 arc(43.6,101.51) 43.56,101.45 arc(43.5,101.41) 43.43,101.4 43.42,101.4 arc(43.34,101.41) 43.27,101.46 43.19,101.54 arc(43.09,101.69) 43.05,101.87 43.05,105.79 arc(43.02,106.15) 42.91,106.49 42.66,107.09 arc(42.48,107.42) 42.24,107.72 42.01,107.96 arc(41.84,108.2) 41.78,108.49 41.78,108.89 arc(41.78,109.04) 41.75,109.19 41.64,109.75 arc(41.51,110.27) 41.33,110.78 41.13,111.25 arc(40.88,111.73) 40.53,112.15 37.66,115.03 arc(37.24,115.37) 36.76,115.63 36.47,115.75 arc(36.15,115.84) 35.82,115.87 35.09,115.87 arc(35,115.88) 34.92,115.89 34.65,115.94 arc(34.31,116.05) 34,116.21 33.62,116.47 arc(32.96,116.95) 32.36,117.5 31.06,118.8 arc(30.89,119.05) 30.84,119.34 30.84,123.26 arc(30.78,123.55) 30.61,123.79 28.54,125.86 arc(28.38,126.11) 28.32,126.4 28.32,134.58 arc(28.26,134.88) 28.1,135.12 26.33,136.89 arc(26.09,137.05) 25.79,137.11 10.34,137.11 arc(10.13,137.15) 9.94,137.27 9.88,137.34 arc(9.76,137.51) 9.72,137.72 arc(9.72,137.76) 9.73,137.79 arc(9.88,138.13) J1.B10
HYPERLINK0_RXN3_C: length 12.6
  TOP w0.102: U24.AW7 53.52,95.28 arc(53.5,95.18) 53.44,95.1 arc(53.39,95.06) 53.33,95.05 arc(53.29,95.06) 53.26,95.08 53.19,95.15 arc(53.11,95.26) 53.09,95.39 53.09,95.49 arc(53.01,95.88) 52.79,96.21 47.7,101.3 arc(47.37,101.52) 46.98,101.6 45.05,101.6 arc(44.85,101.64) 44.68,101.76 44.59,101.84 arc(44.54,101.92) 44.52,102.01 C190.2
HYPERLINK0_RXP0: length 61.6
  TOP w0.102: J1.A4 arc(9.07,123.3) 9.13,123.26 9.36,123.03 arc(9.44,122.9) 9.47,122.74 9.47,122.57 arc(9.53,122.29) 9.69,122.06 arc(9.92,121.9) 10.2,121.85 26.31,121.85 arc(26.45,121.82) 26.57,121.74 arc(26.64,121.63) 26.67,121.49 26.67,120.79 arc(26.54,120.48) 26.24,120.35 arc(25.75,120.15) 25.55,119.67 25.55,119.54 arc(25.72,119.15) 26.11,118.98 26.24,118.98 arc(26.67,118.55) 26.24,118.12 arc(25.75,117.92) 25.55,117.43 25.55,117.31 arc(25.72,116.91) 26.11,116.75 26.24,116.75 arc(26.54,116.62) 26.67,116.32 26.67,116.07 arc(26.73,115.79) 26.88,115.56 arc(27.12,115.4) 27.4,115.34 29.63,115.34 arc(29.92,115.28) 30.17,115.12 31.6,113.69 arc(32.31,113.11) 33.12,112.67 arc(33.43,112.58) 33.75,112.55 34.89,112.55 arc(35.08,112.51) 35.25,112.4 37.23,110.42 arc(37.95,109.34) 38.2,108.07 38.2,107.3 arc(38.43,106.14) 39.09,105.15 39.81,104.44 arc(39.97,104.19) 40.03,103.9 40.03,103.57 arc(39.93,103.34) 39.7,103.25 38.86,103.25 arc(38.18,102.56) 38.86,101.88 39.6,101.88 arc(39.9,101.75) 40.03,101.45 40.03,100.64 arc(40.4,98.75) 41.47,97.16 42.3,96.33 arc(42.49,96.17) 42.71,96.06 42.77,96.03 arc(42.86,96) 42.94,95.98 43,95.97 arc(43.04,95.96) 43.08,95.96 45.03,95.96 arc(45.33,95.87) C218.1
HYPERLINK0_RXP0_C: length 11.9
  TOP w0.102: U24.AW11 53.52,91.71 arc(53.51,91.74) 53.49,91.77 arc(53.46,91.79) 53.43,91.8 52.66,91.8 arc(52.47,91.76) 52.3,91.65 51.68,91.03 arc(51.35,90.81) 50.96,90.73 50.1,90.73 arc(49.71,90.81) 49.38,91.03 49.15,91.27 arc(48.9,91.56) 48.72,91.9 arc(48.67,92.06) 48.63,92.22 48.58,92.43 arc(48.57,92.52) 48.56,92.62 48.56,93.95 arc(48.56,94.06) 48.54,94.17 48.46,94.59 arc(48.4,94.81) 48.33,95.02 48.3,95.08 arc(48.13,95.4) 47.9,95.68 47.66,95.92 arc(47.66,95.93) 47.65,95.93 47.62,95.96 arc(47.4,96.07) 47.16,96.11 46.93,96.11 arc(46.58,95.97) C218.2
HYPERLINK0_RXP1: length 57.5
  TOP w0.102: J1.A6 arc(9.12,128.29) 9.22,128.22 9.33,128.11 arc(9.44,127.95) 9.47,127.76 9.47,127.55 arc(9.52,127.3) 9.67,127.08 arc(9.88,126.94) 10.13,126.89 25.08,126.89 arc(25.27,126.85) 25.43,126.74 25.74,126.43 arc(25.85,126.27) 25.89,126.07 25.89,123.95 arc(25.97,123.57) 26.19,123.24 26.24,123.18 arc(26.57,122.96) 26.96,122.89 27.71,122.89 arc(27.9,122.85) 28.06,122.74 28.19,122.61 arc(28.36,122.35) 28.42,122.05 28.42,118.65 arc(28.39,118.48) 28.29,118.34 28.17,118.22 arc(28.04,118.02) 27.99,117.78 27.99,116.94 arc(28.2,116.44) 28.7,116.23 30.26,116.23 arc(30.46,116.19) 30.63,116.08 32.13,114.58 arc(32.86,113.98) 33.68,113.54 arc(34,113.44) 34.33,113.41 35.21,113.41 arc(35.39,113.39) 35.56,113.34 35.78,113.25 arc(36.18,113.04) 36.52,112.76 38.38,110.89 arc(39.06,109.88) 39.29,108.69 39.29,107.81 arc(39.37,107.42) 39.59,107.09 40.04,106.64 arc(40.43,106.16) 40.72,105.62 40.79,105.44 arc(40.87,105.2) 40.89,104.95 40.89,100.76 arc(40.9,100.54) 40.94,100.32 41.06,99.69 arc(41.13,99.43) 41.22,99.17 41.32,98.93 arc(41.58,98.45) 41.92,98.03 42.3,97.65 arc(42.31,97.64) 42.31,97.64 42.37,97.58 arc(42.57,97.45) 42.8,97.41 arc(43.06,97.3) C215.1
HYPERLINK0_RXP1_C: length 15.1
  TOP w0.102: C215.2 44.01,97.32 arc(44.04,97.44) 44.1,97.55 arc(44.21,97.61) 44.33,97.64 46.9,97.64 arc(47.09,97.62) 47.26,97.57 47.5,97.47 arc(47.89,97.26) 48.23,96.98 50.62,94.59 50.89,94.32 arc(50.97,94.2) 51,94.05 51,94.02 arc(51.08,93.65) 51.29,93.34 51.52,93.1 arc(51.6,93.04) 51.67,92.98 arc(51.74,92.93) 51.82,92.9 arc(52.02,92.83) 52.24,92.8 53.55,92.8 arc(53.68,92.78) 53.8,92.7 arc(53.87,92.59) 53.9,92.46 53.9,92.18 arc(53.92,92.06) 53.99,91.96 54.01,91.94 arc(54.13,91.86) 54.28,91.83 55.18,91.83 arc(55.44,91.71) U24.AU11
HYPERLINK0_RXP2: length 60.7
  TOP w0.102: J1.A8 9.03,133.31 9.24,133.1 arc(9.39,132.87) 9.45,132.6 9.45,132.49 arc(9.5,132.25) 9.64,132.04 arc(9.84,131.9) 10.09,131.85 25.18,131.85 arc(25.38,131.81) 25.54,131.7 26.8,130.45 arc(26.91,130.28) 26.95,130.09 26.95,125.84 arc(27.03,125.45) 27.25,125.12 29.26,123.11 arc(29.37,122.94) 29.41,122.75 29.41,119.11 arc(29.49,118.72) 29.71,118.39 32.19,115.91 arc(32.64,115.51) 33.12,115.15 arc(33.67,114.86) 34.26,114.68 34.27,114.68 arc(34.37,114.66) 34.48,114.66 35.09,114.66 arc(35.38,114.63) 35.66,114.54 36,114.4 arc(36.39,114.19) 36.73,113.91 39.59,111.06 arc(39.9,110.68) 40.13,110.24 40.22,110.04 arc(40.29,109.83) 40.34,109.61 40.4,109.34 arc(40.41,109.27) 40.41,109.21 40.41,108.24 arc(40.49,107.85) 40.71,107.52 41.08,107.15 arc(41.4,106.76) 41.64,106.31 41.79,105.96 arc(41.87,105.69) 41.9,105.41 41.9,101.06 arc(41.97,100.68) 42.19,100.35 43.18,99.36 arc(43.51,99.14) 43.9,99.06 45.25,99.06 arc(45.36,99.04) 45.44,98.98 arc(45.5,98.89) 45.52,98.79 C203.1
HYPERLINK0_RXP2_C: length 11.6
  TOP w0.102: C203.2 46.42,98.64 arc(46.46,98.81) 46.55,98.95 arc(46.7,99.05) 46.87,99.09 47.33,99.09 arc(47.49,99.07) 47.63,99.02 47.84,98.94 arc(48.18,98.76) 48.47,98.52 48.77,98.22 52.2,94.79 52.22,94.81 53.02,94.01 arc(53.19,93.89) 53.39,93.83 53.57,93.81 arc(53.72,93.76) 53.84,93.66 arc(53.91,93.54) 53.92,93.41 arc(53.97,93.16) 54.13,92.95 arc(54.23,92.9) 54.34,92.89 arc(54.6,92.72) U24.AV10
HYPERLINK0_RXP3: length 62.1
  TOP w0.102: C199.1 43.62,100.96 arc(43.6,101.03) 43.56,101.09 arc(43.5,101.13) 43.43,101.14 43.37,101.14 arc(43.24,101.17) 43.13,101.24 43.01,101.36 arc(42.85,101.59) 42.8,101.87 42.8,105.79 arc(42.77,106.1) 42.68,106.39 42.43,106.99 arc(42.27,107.28) 42.06,107.54 41.83,107.78 arc(41.61,108.11) 41.53,108.49 41.53,108.89 arc(41.52,109.02) 41.5,109.14 41.39,109.7 arc(41.27,110.2) 41.1,110.68 40.9,111.15 arc(40.67,111.59) 40.35,111.97 37.48,114.85 arc(37.1,115.16) 36.66,115.39 36.37,115.51 arc(36.1,115.59) 35.82,115.62 35.09,115.62 arc(34.98,115.63) 34.87,115.64 34.6,115.7 arc(34.21,115.81) 33.86,116 33.47,116.26 arc(32.8,116.76) 32.18,117.32 30.88,118.62 arc(30.66,118.95) 30.58,119.34 30.58,123.26 arc(30.54,123.45) 30.43,123.61 28.36,125.68 arc(28.14,126.01) 28.07,126.4 28.07,134.58 arc(28.03,134.78) 27.92,134.94 26.15,136.71 arc(25.99,136.82) 25.79,136.86 10.34,136.86 arc(10.03,136.92) 9.76,137.09 9.7,137.16 arc(9.53,137.41) 9.47,137.72 arc(9.34,138.1) J1.A10
HYPERLINK0_RXP3_C: length 12.6
  TOP w0.102: U24.AW8 53.52,94.66 arc(53.51,94.71) 53.48,94.76 arc(53.43,94.79) 53.38,94.8 53.31,94.8 arc(53.19,94.82) 53.09,94.89 53.01,94.97 arc(52.88,95.16) 52.83,95.39 52.83,95.49 arc(52.77,95.78) 52.61,96.03 47.52,101.12 arc(47.27,101.29) 46.98,101.35 45.14,101.35 arc(44.9,101.3) 44.7,101.16 44.57,101.03 arc(44.53,100.98) 44.52,100.91 C199.2
HYPERLINK0_RXPMCLK: length 71.8
  TOP w0.102: U24.AJ2 v2(64.02,99.92)
  L8 w0.114: v1(36.73,125.06) 35.15,125.06 34.78,124.7 34.78,124.62 34.49,124.33 34.08,124.33 33.2,125.22 32.13,125.22 31.11,124.21 15.1,124.21 J1.C5
  BOTTOM w0.127: v2(64.02,99.92) 63.66,100.28 63.66,101.04 63.63,101.13 63.2,101.56 62.93,101.56 62.48,102.01 62.48,105.66 61.21,106.93 61.21,107.82 60.45,108.59 60.45,112.04 59.77,112.72 47.05,112.72 46.54,113.23 43.44,113.23 42.85,113.82 42.85,114.29 40.01,117.14 40.01,122.07 37.23,124.84 36.96,124.84 v1(36.73,125.06)
HYPERLINK0_RXPMDAT: length 71.3
  TOP w0.102: v2(65.02,98.92) 65.52,99.42 U24.AG3
  L8 w0.114: J1.D5 15.85,124.66 31.11,124.66 31.96,125.51 v1(34.32,125.51)
  BOTTOM w0.127: v1(34.32,125.51) 34.54,125.28 35.89,125.28 36.58,124.59 37.12,124.59 39.75,121.96 39.75,117.03 42.6,114.18 42.6,113.71 43.34,112.98 46.43,112.98 46.94,112.47 59.67,112.47 60.07,112.06 60.07,108.33 60.71,107.7 60.71,106.93 61.98,105.66 61.98,102.19 62.86,101.31 63.13,101.31 63.39,101.04 63.41,101 63.41,99.97 63.92,99.47 64.47,99.47 v2(65.02,98.92)
HYPERLINK0_TXFLCLK: length 78.7
  TOP w0.102: v2(64.02,98.92) U24.AJ3
  L8 w0.114: v1(35.22,124.52) 35.22,123.95 34.14,122.87 29.83,122.87 28.89,121.93 14.88,121.93 J1.C4
  BOTTOM w0.127: v2(64.02,98.92) 64.02,99 61.47,101.55 61.47,105.51 59.72,107.26 59.72,110.46 58.78,111.4 53.04,111.4 48.06,106.43 43.76,106.43 41.39,108.8 41.39,114.85 39.5,116.74 39.5,121.86 37.02,124.33 35.41,124.33 v1(35.22,124.52)
HYPERLINK0_TXFLDAT: length 79.2
  TOP w0.102: v2(64.91,96.9) 65.43,97.42 U24.AG5
  L8 w0.114: v1(32.51,123.3) 32.32,123.11 29.73,123.11 28.92,122.3 15.71,122.3 J1.D4
  BOTTOM w0.127: v2(64.91,96.9) 64.28,97.53 63.85,97.53 63.62,97.76 63.62,99.03 61.09,101.57 61.09,105.28 59.39,106.98 59.39,110.41 58.65,111.15 53.21,111.15 48.11,106.04 43.62,106.04 41.14,108.53 41.14,114.75 39.24,116.64 39.24,121.75 36.91,124.08 33.8,124.08 33.03,123.3 v1(32.51,123.3)
HYPERLINK0_TXN0: length 73.4
  TOP w0.102: U24.AP11 58.52,90.96 58.9,90.58 58.9,89.9 v2(59,89.79)
  L10 w0.089: J1.B3 10.2,120.81 arc(10.1,120.79) 10.02,120.74 9.78,120.5 arc(9.73,120.42) 9.71,120.32 9.71,119.94 arc(9.77,119.63) 9.94,119.37 arc(10.21,119.19) 10.51,119.13 25.57,119.13 arc(25.85,119.08) 26.09,118.92 arc(26.25,118.68) 26.31,118.4 26.31,115.88 arc(26.37,115.58) 26.54,115.32 30.76,111.1 arc(31.03,110.7) 31.13,110.22 31.13,105.52 arc(31.2,105.13) 31.42,104.8 31.63,104.59 arc(31.96,104.37) 32.35,104.29 35.17,104.29 arc(35.36,104.26) 35.53,104.15 arc(35.63,103.99) 35.67,103.79 35.67,103.3 arc(35.74,103.14) 35.91,103.07 36.13,103.07 arc(36.19,103.08) 36.23,103.11 arc(36.26,103.15) 36.27,103.21 36.27,103.85 arc(36.3,104.02) 36.4,104.17 arc(36.54,104.26) 36.71,104.29 36.84,104.29 arc(37.23,104.22) 37.56,104 41.13,100.43 arc(41.16,100.4) 41.19,100.39 41.21,100.38 arc(41.22,100.37) 41.24,100.37 45.76,100.37 arc(46.15,100.3) 46.48,100.08 49.93,96.63 arc(50.1,96.38) 50.15,96.09 arc(50.2,95.84) 50.35,95.63 51.04,94.93 arc(51.26,94.6) 51.34,94.21 51.34,93.38 arc(51.42,92.99) 51.64,92.66 51.85,92.44 arc(51.88,92.41) 51.91,92.38 52.01,92.27 arc(52.14,92.05) 52.18,91.79 52.18,91.45 arc(52.2,91.27) 52.25,91.1 52.26,91.08 arc(52.57,90.7) 53.03,90.56 56.5,90.56 56.57,90.48 58.43,90.48 arc(58.6,90.45) 58.75,90.35 58.75,90.35 arc(58.84,90.21) 58.88,90.04 arc(58.91,89.9) v2(59,89.79)
HYPERLINK0_TXN1: length 73.6
  TOP w0.102: U24.AR10 57.57,92.42 58.04,91.95 v2(58.04,91.95)
  L10 w0.089: v2(58.04,91.95) arc(57.81,91.88) 57.63,92.03 arc(57.6,92.12) 57.59,92.22 arc(57.57,92.39) 57.47,92.54 57.42,92.6 arc(57.29,92.68) 57.14,92.71 56.93,92.71 arc(56.69,92.66) 56.48,92.53 arc(56.42,92.48) 56.34,92.47 55.09,92.47 arc(54.71,92.55) 54.38,92.77 53.54,93.61 arc(53.32,93.94) 53.24,94.32 53.24,94.52 arc(53.16,94.91) 52.94,95.24 52.22,95.97 arc(52.1,96.1) 52.01,96.26 arc(51.94,96.47) 51.92,96.69 51.92,96.76 arc(51.89,96.9) 51.82,97.03 arc(51.81,97.04) 51.8,97.04 47.21,101.63 arc(46.81,101.9) 46.34,102 42.77,102 arc(42.74,102) 42.71,102.02 38.75,105.99 35.66,105.99 arc(35.27,106.06) 34.94,106.28 33.61,107.61 arc(33.39,107.94) 33.31,108.33 33.31,110.35 arc(33.22,110.82) 32.95,111.22 28.07,116.1 arc(27.9,116.36) 27.84,116.66 27.84,120.51 arc(27.76,120.9) 27.54,121.23 27.21,121.56 arc(26.88,121.78) 26.49,121.86 24.58,121.86 arc(24.55,121.87) 24.52,121.88 24.5,121.91 arc(24.46,121.96) 24.45,122.03 24.45,122.35 arc(24.46,122.39) 24.48,122.42 arc(24.51,122.45) 24.56,122.46 26.14,122.46 arc(26.39,122.56) 26.49,122.81 arc(26.43,123.14) 26.24,123.41 25.38,124.28 arc(25.05,124.5) 24.66,124.58 10.07,124.58 arc(9.98,124.6) 9.89,124.65 9.79,124.75 arc(9.73,124.84) 9.72,124.93 9.72,125.29 arc(9.72,125.3) 9.72,125.31 9.72,125.35 arc(9.72,125.38) 9.74,125.41 10.09,125.77 arc(10.14,125.8) J1.B5
HYPERLINK0_TXN2: length 73.6
  TOP w0.102: v2(57.91,93.97) 58.37,94.42 U24.AP8
  L10 w0.089: v2(57.91,93.97) 57.99,93.89 57.99,93.71 arc(57.97,93.63) 57.92,93.56 arc(57.85,93.51) 57.77,93.5 55.07,93.5 arc(54.76,93.56) 54.5,93.73 54.38,93.86 arc(54.21,94.11) 54.15,94.4 54.15,94.81 arc(54.08,95.2) 53.86,95.53 53.62,95.76 arc(53.48,95.86) 53.31,95.89 arc(53.31,95.89) 53.31,95.89 52.83,96.37 arc(52.66,96.63) 52.6,96.93 52.6,97.16 arc(52.54,97.44) 52.38,97.69 47.67,102.4 arc(47.27,102.66) 46.8,102.76 43.09,102.76 arc(43.06,102.76) 43.03,102.78 39.09,106.72 arc(39.06,106.74) 39.02,106.75 36,106.75 arc(35.69,106.81) 35.44,106.98 34.31,108.11 arc(34.14,108.37) 34.07,108.68 34.07,110.75 arc(33.98,111.23) 33.71,111.63 28.84,116.5 arc(28.66,116.76) 28.6,117.07 28.6,121.88 arc(28.52,122.27) 28.3,122.6 26.17,124.73 arc(25.95,125.06) 25.87,125.45 25.87,128.5 arc(25.79,128.89) 25.57,129.22 25.54,129.24 arc(25.21,129.46) 24.82,129.54 10.09,129.54 arc(9.99,129.56) 9.91,129.62 9.76,129.76 arc(9.71,129.84) 9.69,129.94 9.69,130.27 9.69,130.3 9.69,130.33 arc(9.7,130.36) 9.71,130.39 arc(9.95,130.61) J1.B7
HYPERLINK0_TXN3: length 75.8
  TOP w0.102: v2(58.01,94.96) 57.89,94.96 57.52,95.34 U24.AR7
  L10 w0.089: v2(58.01,94.96) 57.97,94.96 arc(57.92,94.97) 57.89,95 57.69,95.2 arc(57.64,95.25) 57.6,95.32 arc(57.6,95.34) 57.59,95.37 57.59,95.85 arc(57.63,96.03) 57.73,96.19 57.79,96.24 arc(57.88,96.31) 58,96.33 58.15,96.33 arc(58.29,96.36) 58.41,96.44 58.44,96.46 arc(58.53,96.61) 58.57,96.78 58.57,97.08 arc(58.51,97.37) 58.35,97.61 58.04,97.91 arc(57.71,98.13) 57.33,98.21 57.02,98.21 arc(56.82,98.25) 56.65,98.36 arc(56.49,98.47) 56.29,98.51 54.23,98.51 arc(53.84,98.59) 53.51,98.81 48.13,104.2 arc(47.8,104.42) 47.41,104.5 43.71,104.5 arc(43.68,104.5) 43.65,104.52 30.18,117.99 arc(30.16,118.02) 30.15,118.06 30.15,122.43 arc(30.06,122.9) 29.79,123.3 27.63,125.46 arc(27.46,125.72) 27.39,126.02 27.39,131.77 arc(27.32,132.16) 27.1,132.49 25.23,134.36 arc(24.9,134.58) 24.51,134.66 10.15,134.66 arc(9.98,134.69) 9.84,134.79 arc(9.74,134.94) 9.7,135.11 9.7,135.21 arc(9.84,135.6) J1.B9
HYPERLINK0_TXP0: length 73.4
  TOP w0.102: U24.AP12 58.52,90.42 58.62,90.32 58.62,89.87 58.56,89.8 58.03,89.8 v2(57.99,89.76)
  L10 w0.089: J1.A3 9.08,120.81 arc(9.16,120.8) 9.22,120.75 9.42,120.55 arc(9.47,120.47) 9.49,120.37 9.49,119.94 arc(9.57,119.55) 9.79,119.21 arc(10.12,118.99) 10.51,118.92 25.57,118.92 arc(25.77,118.88) 25.94,118.76 arc(26.05,118.6) 26.09,118.4 26.09,115.88 arc(26.17,115.5) 26.39,115.17 30.61,110.94 arc(30.83,110.61) 30.91,110.22 30.91,105.52 arc(31,105.04) 31.27,104.64 31.47,104.44 arc(31.87,104.17) 32.35,104.08 35.17,104.08 arc(35.28,104.06) 35.37,104 arc(35.44,103.9) 35.46,103.79 35.46,103.3 arc(35.59,102.98) 35.91,102.85 36.13,102.85 arc(36.27,102.88) 36.38,102.96 arc(36.46,103.07) 36.49,103.21 36.49,103.85 arc(36.5,103.94) 36.55,104.01 arc(36.62,104.06) 36.71,104.08 36.84,104.08 arc(37.15,104.02) 37.41,103.84 40.98,100.28 arc(41.04,100.23) 41.11,100.19 41.12,100.18 arc(41.18,100.16) 41.24,100.16 45.76,100.16 arc(46.07,100.1) 46.33,99.92 49.78,96.47 arc(49.9,96.3) 49.94,96.09 arc(50.01,95.76) 50.19,95.47 50.89,94.78 arc(51.06,94.52) 51.12,94.21 51.12,93.38 arc(51.22,92.91) 51.48,92.51 51.7,92.29 arc(51.72,92.27) 51.75,92.24 51.82,92.16 51.84,92.13 arc(51.93,91.97) 51.97,91.79 51.97,91.45 arc(51.99,91.23) 52.05,91.01 52.06,90.99 arc(52.45,90.52) 53.03,90.34 56.37,90.34 arc(56.4,90.34) 56.43,90.32 56.46,90.29 arc(56.48,90.27) 56.52,90.27 58.43,90.27 arc(58.52,90.25) 58.59,90.2 58.6,90.19 arc(58.66,90.04) 58.6,89.89 arc(58.31,89.74) v2(57.99,89.76)
HYPERLINK0_TXP1: length 73.6
  TOP w0.102: U24.AR11 57.52,91.78 57.32,91.98 v2(57.04,91.98)
  L10 w0.089: v2(57.04,91.98) arc(57.27,92.02) 57.38,92.23 arc(57.36,92.32) 57.32,92.39 57.26,92.44 arc(57.21,92.48) 57.14,92.49 56.93,92.49 arc(56.77,92.46) 56.64,92.37 arc(56.5,92.28) 56.34,92.25 55.09,92.25 arc(54.62,92.35) 54.22,92.61 53.38,93.45 arc(53.12,93.85) 53.02,94.32 53.02,94.52 arc(52.96,94.83) 52.79,95.09 52.06,95.82 arc(51.92,95.98) 51.82,96.17 arc(51.73,96.42) 51.7,96.69 51.7,96.76 arc(51.69,96.83) 51.65,96.89 47.06,101.48 arc(46.73,101.7) 46.34,101.78 42.68,101.78 arc(42.65,101.79) 42.62,101.81 38.68,105.74 arc(38.65,105.76) 38.62,105.77 35.66,105.77 arc(35.19,105.86) 34.79,106.13 33.46,107.46 arc(33.19,107.86) 33.1,108.33 33.1,110.35 arc(33.02,110.74) 32.8,111.07 27.92,115.95 arc(27.7,116.28) 27.62,116.66 27.62,120.51 arc(27.56,120.81) 27.39,121.07 27.05,121.41 arc(26.79,121.58) 26.49,121.64 24.58,121.64 arc(24.47,121.67) 24.37,121.73 24.34,121.76 arc(24.26,121.88) 24.23,122.03 24.23,122.35 arc(24.26,122.47) 24.33,122.58 arc(24.43,122.65) 24.56,122.67 26.14,122.67 arc(26.24,122.71) 26.28,122.81 arc(26.23,123.05) 26.09,123.26 25.23,124.13 arc(24.97,124.3) 24.66,124.36 10.07,124.36 arc(9.89,124.4) 9.74,124.5 9.64,124.6 arc(9.54,124.75) 9.5,124.93 9.5,125.29 arc(9.48,125.39) 9.43,125.47 9.15,125.75 arc(9.08,125.79) J1.A5
HYPERLINK0_TXP2: length 73.6
  TOP w0.102: v2(57.93,92.99) 58.36,93.42 U24.AP9
  L10 w0.089: v2(57.93,92.99) 57.93,93.02 arc(57.92,93.05) 57.91,93.07 57.81,93.17 arc(57.68,93.25) 57.53,93.28 55.07,93.28 arc(54.68,93.36) 54.35,93.58 54.23,93.7 arc(54.01,94.02) 53.94,94.4 53.94,94.81 arc(53.88,95.11) 53.7,95.37 53.47,95.61 arc(53.4,95.66) 53.31,95.67 arc(53.26,95.68) 53.2,95.7 arc(53.18,95.72) 53.16,95.74 52.68,96.22 arc(52.46,96.54) 52.38,96.93 52.38,97.15 arc(52.34,97.36) 52.23,97.53 47.51,102.24 arc(47.18,102.46) 46.8,102.54 42.96,102.54 38.97,106.53 36,106.53 arc(35.61,106.61) 35.28,106.83 34.16,107.96 arc(33.94,108.29) 33.86,108.68 33.86,110.75 arc(33.78,111.14) 33.56,111.47 28.68,116.35 arc(28.46,116.68) 28.38,117.07 28.38,121.88 arc(28.32,122.19) 28.15,122.45 26.01,124.58 arc(25.75,124.98) 25.65,125.45 25.65,128.5 arc(25.59,128.8) 25.42,129.06 25.39,129.09 arc(25.13,129.26) 24.82,129.33 10.09,129.33 arc(9.91,129.36) 9.75,129.46 9.61,129.6 arc(9.51,129.76) 9.47,129.94 9.47,130.35 arc(9.45,130.45) 9.4,130.53 arc(9.21,130.69) J1.A7
HYPERLINK0_TXP3: length 75.8
  TOP w0.102: v2(57.01,95.02) 57.05,95.02 57.52,94.55 U24.AR8
  L10 w0.089: v2(57.01,95.02) 57.05,95.02 arc(57.1,95.03) 57.13,95.05 57.24,95.16 arc(57.34,95.32) 57.38,95.5 57.38,95.85 arc(57.43,96.12) 57.58,96.34 57.63,96.39 arc(57.8,96.51) 58,96.55 58.15,96.55 arc(58.21,96.56) 58.26,96.59 58.28,96.61 arc(58.33,96.69) 58.35,96.78 58.35,97.08 arc(58.31,97.28) 58.2,97.45 57.89,97.76 arc(57.63,97.93) 57.33,97.99 57.02,97.99 arc(56.74,98.05) 56.5,98.21 arc(56.4,98.27) 56.29,98.3 54.23,98.3 arc(53.76,98.39) 53.36,98.66 47.97,104.05 arc(47.71,104.22) 47.41,104.28 43.58,104.28 29.93,117.93 29.93,122.43 arc(29.86,122.82) 29.64,123.14 27.48,125.31 arc(27.26,125.63) 27.18,126.02 27.18,131.77 arc(27.12,132.08) 26.94,132.34 25.07,134.21 arc(24.81,134.38) 24.51,134.44 10.15,134.44 arc(9.9,134.49) 9.68,134.64 arc(9.54,134.86) 9.49,135.11 9.49,135.29 arc(9.47,135.39) 9.41,135.47 9.12,135.76 arc(9.07,135.8) J1.A9
HYPERLINK0_TXPMCLK: length 61.3
  L8 w0.114: J1.C6 14.94,126.87 25.02,126.87 26.8,125.09 30.83,125.09 31.68,125.95 34.5,125.95 34.64,125.81 35.88,125.81 35.89,125.8 36.22,125.8 v1(36.41,125.61)
  BOTTOM w0.127: v1(36.41,125.61) 36.51,125.51 36.92,125.51 37.33,125.09 37.34,125.09 40.26,122.17 40.26,117.24 43.11,114.39 43.11,113.93 43.55,113.49 46.64,113.49 47.15,112.98 60.12,112.98 60.96,112.13 60.96,109.92 R609.2
HYPERLINK0_TXPMCLK_R: length 12
  TOP w0.102: v2(64.02,97.92) U24.AH5
  L5 w0.114: v2(64.02,97.92) 63.5,98.44 63.5,101.55 v2(63.07,101.98)
  BOTTOM w0.127: v2(63.07,101.98) 63.07,105.71 62.23,106.55 62.23,107.75 R609.1
HYPERLINK0_TXPMDAT: length 68.5
  TOP w0.102: v2(63.86,101.96) 63.52,101.62 U24.AJ1
  L8 w0.114: J1.D6 15.69,127.32 25.45,127.32 27.43,125.34 30.73,125.34 31.58,126.19 34.6,126.19 34.74,126.05 35.88,126.05 v1(36.07,126.24)
  BOTTOM w0.127: v2(63.86,101.96) 63.86,105.44 62.61,106.68 62.61,108.99 61.47,110.13 61.47,111.98 60.22,113.23 47.26,113.23 46.75,113.74 46.51,113.98 44.65,113.98 44.29,114.34 44.29,114.94 43.52,115.71 43.08,116.15 43.08,116.94 40.51,119.51 40.51,122.28 37.44,125.35 37.44,125.35 37.02,125.76 36.89,125.76 36.41,126.24 v1(36.07,126.24)
HYPERLINK1_RXFLCLK: length 76.9
  L8 w0.114: v1(36.57,127.48) 36.57,127.25 36.39,127.07 36.01,127.07 35.37,126.43 32.29,126.43 31.46,127.25 30.93,127.25 30.16,126.49 28.57,126.49 25.65,129.41 14.9,129.41 J1.C7
  BOTTOM w0.127: R621.2 65.47,105.47 63.75,107.19 63.75,109.22 64.71,110.17 64.71,110.74 63.18,112.27 63.18,112.45 61.64,113.99 47.57,113.99 46.65,114.92 46.19,115.38 44.93,115.38 43.84,116.47 43.84,117.26 41.27,119.82 41.27,122.59 36.67,127.2 36.67,127.39 v1(36.57,127.48)
HYPERLINK1_RXFLCLK_R: length 1.4
  TOP w0.102: U24.AH4 v2(65.02,97.92)
  BOTTOM w0.102: R621.1 64.57,98.37 v2(65.02,97.92)
HYPERLINK1_RXFLDAT: length 77.7
  TOP w0.102: U24.AG2 65.52,100.42 v2(66.02,100.92)
  L8 w0.114: J1.D7 15.86,129.65 25.75,129.65 28.68,126.73 30.06,126.73 30.83,127.5 31.56,127.5 32.39,126.67 35.1,126.67 35.18,126.75 35.18,128.27 35.63,128.72 36.2,128.72 36.2,128.68 v1(36.14,128.68)
  BOTTOM w0.127: v1(36.14,128.68) 36.2,128.68 36.2,128.72 36.86,128.72 37.11,128.47 37.11,127.12 39.51,124.71 41.34,124.71 41.9,124.16 41.9,123.58 42.32,123.16 42.32,119.14 44.09,117.36 44.09,116.84 45.3,115.63 46.29,115.63 46.83,115.1 47.68,114.25 61.75,114.25 63.44,112.56 63.44,112.37 64.96,110.85 64.96,110.07 64.01,109.11 64.01,107.31 65.85,105.47 65.85,101.09 v2(66.02,100.92)
HYPERLINK1_RXN0: length 50.2
  BOTTOM w0.102: C517.1 44.25,96.74 arc(44.22,96.59) 44.14,96.46 arc(44.01,96.37) 43.85,96.34 41.3,96.34 arc(40.76,96.57) 40.54,97.1 40.54,99.84 arc(40.46,100.23) 40.24,100.56 33.85,106.94 arc(33.74,107.11) 33.71,107.3 33.71,107.35 arc(33.63,107.74) 33.41,108.07 32.99,108.49 arc(32.88,108.66) 32.84,108.85 32.84,109.49 arc(32.78,109.78) 32.62,110.03 31.64,111 arc(31.4,111.17) 31.1,111.23 27.32,111.23 arc(27.02,111.28) 26.78,111.45 26.39,111.84 arc(26.22,112.09) 26.16,112.38 26.16,112.95 arc(26,113.34) 25.6,113.51 24.21,113.51 arc(23.9,113.81) 24.21,114.12 25.6,114.12 arc(26,114.28) 26.16,114.67 26.16,121.15 arc(26.1,121.44) 25.94,121.69 25.77,121.85 arc(25.53,122.02) 25.23,122.07 19.33,122.07 arc(19.1,122.12) 18.9,122.25 arc(18.77,122.45) 18.72,122.69 18.72,123.02 arc(18.74,123.13) 18.81,123.22 arc(18.9,123.29) 19.01,123.31 J1.F4
HYPERLINK1_RXN0_C: length 13
  TOP w0.102: U24.AU7 55.52,95.23 55.85,94.89 v2(56.01,94.89)
  BOTTOM w0.102: C517.2 45.15,96.93 arc(45.16,96.89) 45.17,96.86 45.19,96.8 arc(45.22,96.75) 45.25,96.71 45.3,96.66 arc(45.32,96.65) 45.34,96.65 48.68,96.65 arc(49.07,96.57) 49.4,96.35 51.01,94.74 arc(51.18,94.63) 51.37,94.59 55.7,94.59 arc(55.82,94.61) 55.92,94.68 55.96,94.72 arc(56,94.77) 56.01,94.83 v2(56.01,94.89)
HYPERLINK1_RXN1: length 49.2
  BOTTOM w0.102: C511.1 46.41,99.23 arc(46.38,99.08) 46.3,98.95 arc(46.16,98.9) 46.03,98.95 45.95,99.03 arc(45.8,99.13) 45.63,99.16 43.58,99.16 arc(43.33,99.27) 43.23,99.52 43.23,100.13 arc(43.18,100.38) 43.03,100.6 37.52,106.12 arc(37.2,106.6) 37.08,107.16 37.08,109.68 arc(37.07,109.84) 37.01,109.99 arc(36.95,110.08) 36.88,110.16 35.71,111.33 35.45,111.59 arc(35.07,111.85) 34.62,111.94 33.98,111.94 arc(33.78,111.98) 33.62,112.09 32.64,113.06 arc(32.4,113.23) 32.11,113.28 31.71,113.28 arc(31.42,113.34) 31.17,113.51 29.89,114.79 arc(29.49,114.95) 29.1,114.79 29,114.69 arc(28.86,114.63) 28.72,114.69 28.65,114.77 arc(28.56,114.98) 28.65,115.2 28.67,115.22 arc(28.83,115.62) 28.67,116.01 28.22,116.46 arc(28.06,116.7) 28,117 28,122.84 arc(27.94,123.13) 27.78,123.38 26.13,125.02 arc(25.97,125.27) 25.91,125.56 25.91,126.28 arc(25.85,126.57) 25.68,126.82 25.6,126.91 arc(25.35,127.07) 25.06,127.13 19.07,127.13 arc(18.94,127.16) 18.82,127.23 arc(18.75,127.34) 18.72,127.48 18.72,128.03 arc(18.74,128.13) 18.8,128.23 arc(18.9,128.29) 19,128.31 J1.F6
HYPERLINK1_RXN1_C: length 13.7
  TOP w0.102: v2(54.97,95.92) 54.52,96.37 U24.AV6
  BOTTOM w0.102: C511.2 47.31,99.44 arc(47.34,99.31) 47.42,99.19 arc(47.53,99.11) 47.67,99.09 48.3,99.09 arc(48.37,99.1) 48.43,99.14 arc(48.46,99.19) 48.48,99.26 48.48,99.69 arc(49.04,100.25) 49.59,99.69 49.59,99.27 arc(49.61,99.17) 49.64,99.07 49.71,98.93 arc(49.75,98.87) 49.81,98.82 50.08,98.66 arc(50.21,98.6) 50.35,98.58 50.76,98.58 arc(51.05,98.52) 51.3,98.36 51.54,98.12 arc(51.7,97.87) 51.76,97.58 51.76,97.11 arc(51.78,97.02) 51.82,96.93 arc(51.87,96.88) 51.93,96.83 arc(52,96.81) 52.07,96.8 arc(52.25,96.87) 52.33,97.06 arc(52.37,97.29) 52.51,97.5 52.55,97.53 arc(52.66,97.61) 52.8,97.64 54.05,97.64 arc(54.24,97.6) 54.41,97.49 arc(54.52,97.32) 54.56,97.12 54.56,96.85 arc(54.56,96.82) 54.57,96.78 54.66,96.58 arc(54.7,96.45) 54.71,96.3 54.71,96.07 arc(54.72,96.02) 54.76,95.97 arc(54.81,95.93) 54.86,95.92 v2(54.97,95.92)
HYPERLINK1_RXN2: length 50.3
  BOTTOM w0.102: C505.1 44.25,101.08 arc(44.22,101) 44.14,100.97 arc(44.04,100.99) 43.95,101.05 38.23,106.76 arc(38.06,107.02) 38,107.32 38,109.91 arc(37.93,110.26) 37.72,110.57 35.41,112.88 arc(35.08,113.11) 34.69,113.18 34.05,113.18 arc(33.85,113.22) 33.69,113.33 32.27,114.75 arc(32.01,114.93) 31.7,114.99 31.48,114.99 arc(31.19,115.04) 30.94,115.21 29.18,116.97 arc(29.01,117.22) 28.96,117.51 28.96,123.31 arc(28.9,123.6) 28.73,123.85 27.15,125.43 arc(26.98,125.68) 26.92,125.97 26.92,128.69 arc(26.75,129.11) 26.33,129.29 25.73,129.29 arc(25.66,129.3) 25.6,129.34 arc(25.5,129.38) 25.45,129.49 25.45,129.72 arc(25.5,129.84) 25.62,129.9 25.8,129.9 arc(26.11,130.02) 26.24,130.34 26.24,131.4 arc(26.02,131.93) 25.48,132.16 19.03,132.16 arc(18.91,132.18) 18.81,132.25 18.76,132.3 arc(18.75,132.31) 18.74,132.32 18.73,132.37 arc(18.72,132.38) 18.72,132.4 18.72,132.71 arc(18.77,132.97) 18.92,133.19 arc(19.05,133.28) J1.F8
HYPERLINK1_RXN2_C: length 13.3
  TOP w0.102: U24.AU4 v2(56.02,97.92)
  BOTTOM w0.102: C505.2 45.15,101.64 arc(45.17,101.56) 45.21,101.5 45.32,101.39 arc(45.51,101.26) 45.73,101.22 49.34,101.22 arc(49.73,101.14) 50.06,100.92 52.26,98.73 arc(52.42,98.62) 52.61,98.58 55.17,98.58 arc(55.29,98.56) 55.4,98.52 55.45,98.5 arc(55.62,98.35) 55.68,98.13 55.68,98.03 arc(55.69,98.01) 55.7,98 55.73,97.97 arc(55.78,97.93) 55.84,97.92 v2(56.02,97.92)
HYPERLINK1_RXN3: length 40
  BOTTOM w0.102: C502.1 39.71,113.02 39.5,113.23 39.5,113.53 37.53,115.5 arc(37.2,115.72) 36.82,115.8 34.37,115.8 arc(34.18,115.84) 34.01,115.95 30.96,119 arc(30.79,119.25) 30.73,119.54 30.73,124.14 arc(30.68,124.44) 30.51,124.68 29.05,126.14 arc(28.89,126.39) 28.83,126.68 28.83,130.11 arc(28.77,130.41) 28.61,130.65 arc(28.47,130.86) 28.42,131.09 28.42,133.82 arc(28.35,134.21) 28.13,134.54 25.88,136.79 arc(25.55,137.01) 25.16,137.09 19.2,137.09 arc(19.02,137.12) 18.86,137.23 18.83,137.26 arc(18.75,137.38) 18.72,137.52 18.72,138.07 arc(18.79,138.24) 18.96,138.31 J1.F10
HYPERLINK1_RXN3_C: length 25.4
  TOP w0.102: v2(54.97,99.92) 54.97,99.24 54.81,99.09 54.57,99.09 54.52,99.14 U24.AV3
  BOTTOM w0.102: v2(54.97,99.92) 54.69,99.92 arc(54.64,99.93) 54.6,99.96 54.58,99.97 arc(54.57,100) 54.56,100.04 54.56,100.21 arc(54.53,100.34) 54.46,100.46 54.44,100.47 arc(54.32,100.55) 54.17,100.58 53.44,100.58 arc(53.17,100.7) 53.06,100.97 53.06,101.6 arc(52.99,101.93) 52.81,102.21 50.57,104.44 arc(50.26,104.65) 49.9,104.72 43.14,104.72 arc(42.98,104.76) 42.84,104.85 40.23,107.46 arc(40.06,107.71) 40.01,108 40.01,110.66 arc(39.95,110.95) 39.78,111.2 39.62,111.36 arc(39.51,111.52) 39.47,111.71 39.47,111.76 arc(39.5,111.9) 39.58,112.02 39.68,112.12 C502.2
HYPERLINK1_RXP0: length 50.2
  BOTTOM w0.102: C523.1 44.25,95.86 arc(44.24,95.95) 44.19,96.02 arc(44.11,96.07) 44.03,96.09 41.3,96.09 arc(40.58,96.39) 40.28,97.1 40.28,99.84 arc(40.23,100.13) 40.06,100.38 33.68,106.76 arc(33.51,107.01) 33.45,107.3 33.45,107.35 arc(33.39,107.65) 33.23,107.89 32.81,108.31 arc(32.65,108.56) 32.59,108.85 32.59,109.49 arc(32.55,109.68) 32.44,109.85 31.46,110.82 arc(31.3,110.93) 31.1,110.97 27.32,110.97 arc(26.93,111.05) 26.6,111.27 26.21,111.66 arc(25.99,111.99) 25.91,112.38 25.91,112.95 arc(25.82,113.16) 25.6,113.25 24.21,113.25 arc(23.65,113.81) 24.21,114.37 25.6,114.37 arc(25.82,114.46) 25.91,114.67 25.91,121.15 arc(25.87,121.34) 25.76,121.51 25.59,121.67 arc(25.43,121.78) 25.23,121.82 19.33,121.82 arc(19,121.89) 18.72,122.07 arc(18.53,122.35) 18.47,122.69 18.47,123.08 arc(18.4,123.24) 18.23,123.31 J1.E4
HYPERLINK1_RXP0_C: length 13
  TOP w0.102: v2(56.01,94.03) 55.61,94.42 U24.AU8
  BOTTOM w0.102: v2(56.01,94.03) 56.01,94.12 arc(55.99,94.2) 55.94,94.27 arc(55.87,94.32) 55.79,94.34 51.37,94.34 arc(51.08,94.39) 50.83,94.56 49.22,96.17 arc(48.97,96.33) 48.68,96.39 45.38,96.39 arc(45.23,96.31) 45.16,96.14 arc(45.16,95.95) C523.2
