# Allegro board 19C2830503-01-JOB.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SOC_EMU_23: length 123.2
  TOP w0.102: U24.D33 v2(89.02,68.92)
  TOP w0.127: v1(111.24,140.03) 111.24,140.68 110.24,141.68 110.24,143.33 109.86,143.7 109.86,145.54 105.88,149.52 104.4,149.52 103.86,148.97 R67.2
  L5 w0.114: v1(111.24,140.03) 111.24,138.42 116,133.66 116,126.49 116.69,125.8 116.69,115.8 115.44,114.55 115.44,114.04 115.69,113.79 115.69,112.51 113.45,110.27 113.45,67.86 112.14,66.55 111.12,66.55 110.11,65.53 110.11,62.94 109.39,62.21 105.17,62.21 104.78,62.61 104.78,62.7 v1(104.74,62.74)
  BOTTOM w0.102: 89.9,68.92 v2(89.02,68.92) ; 93.18,65.66 93.16,65.66
  BOTTOM w0.127: 89.9,68.92 90.27,68.55 93.16,65.66 ; 93.18,65.66 94.84,64.01 97,64.01 98.92,62.1 103.75,62.1 104.39,62.74 v1(104.74,62.74)
SOC_EMU_23_R: length 2.7
  TOP w0.127: EMU1.22 101.14,148.18 101.93,148.97 R67.1
SOC_EMU_24: length 111.7
  TOP w0.102: U24.D31 v2(89.02,70.92)
  TOP w0.127: R68.2 105.87,148.97 109.48,145.36 109.48,143.54 109.86,143.17 109.86,142.68 v1(109.42,142.24)
  L5 w0.114: v1(98.42,66.04) 99.5,64.97 100.64,64.97 102.44,66.77 102.44,67.16 102.69,67.42 103.93,67.42 104.02,67.32 104.53,67.32 104.78,67.56 104.78,68.71 106.3,70.23 107.19,70.23 108.09,71.14 108.09,103.91 110.88,106.7 110.88,111.34 111.9,112.36 111.9,113.98 112.51,114.59 112.51,116.39 114.07,117.94 114.07,119.67 114.55,120.15 114.55,133.07 109.51,138.1 109.51,142.14 v1(109.42,142.24)
  BOTTOM w0.102: v2(89.02,70.92) 93.18,70.92
  BOTTOM w0.127: v1(98.42,66.04) 98.02,66.45 97.99,66.45 97.76,66.68 96.52,66.68 95.76,67.44 95.76,69.51 94.34,70.92 93.18,70.92
SOC_EMU_24_R: length 5.6
  TOP w0.127: EMU1.24 101.3,147.68 101.83,148.21 103.63,148.21 104.39,148.97 R68.1
SOC_EMU_25: length 110.6
  TOP w0.102: 93.18,65.29 93.18,65.29 91.55,66.93 91.01,66.93 U24.B35
  TOP w0.127: R72.1 103.63,147.57 104.18,148.12 105.93,148.12 109.1,144.95 109.1,143.29 v1(109.41,142.98) ; 93.18,65.29 93.33,65.14 93.34,65.14 95.11,63.37 v1(96.52,63.37)
  L5 w0.114: v1(109.41,142.98) 109.86,142.54 109.86,138.25 114.94,133.16 114.94,118.33 112.85,116.24 112.85,114.38 112.24,113.77 112.24,112.22 111.22,111.2 111.22,106.55 108.44,103.77 108.44,70.87 107.42,69.85 106.43,69.85 105.16,68.58 105.16,67.44 104.26,66.54 102.88,66.54 102.37,66.03 102.37,65.81 100.64,64.08 98.91,64.08 98.68,64.31 97.46,64.31 v1(96.52,63.37)
SOC_EMU_25_R: length 2.6
  TOP w0.127: EMU1.26 101.36,147.18 101.75,147.57 R72.2
SOC_EMU_26: length 97.6
  TOP w0.102: U24.B33 90.83,69.11 90.9,69.04 91.84,69.04 92.62,68.26 v2(92.99,68.26)
  TOP w0.127: R73.1 105.94,147.57 108.72,144.79 v1(108.72,143)
  L5 w0.102: 93.18,68.06 v2(92.99,68.26)
  L5 w0.114: v1(108.72,143) 106.57,143 106.12,142.55 106.12,140.51 106.3,140.34 106.3,128.57 107.93,126.94 107.93,121.65 109.33,120.26 109.33,116.37 109.1,116.14 109.1,114.43 108,113.33 108,111.57 108.39,111.18 108.39,107.66 102.11,101.38 102.11,75.15 101.96,75 101.96,72.76 100.51,71.3 99.77,71.3 98.53,70.07 98.53,69.82 96.61,67.89 93.36,67.89 93.18,68.06
SOC_EMU_26_R: length 5.4
  TOP w0.127: R73.2 104.27,147.57 103.63,146.94 101.73,146.94 101.47,146.68 EMU1.28
SOC_EMU_27: length 108.7
  TOP w0.102: v2(88.04,70.97) 87.97,70.97 U24.E31
  TOP w0.127: v1(108.39,140.97) 108.27,141.09 108.27,144.54 106.09,146.72 104.31,146.72 103.76,146.18 R79.1
  L5 w0.114: v1(100.46,66.88) 102.65,69.08 103.73,69.08 105.11,70.45 105.11,101.89 110.19,106.98 110.19,111.62 111.21,112.65 111.21,114.26 111.79,114.84 111.79,117.18 112.13,117.52 112.13,119.81 110.08,121.87 110.08,128.57 110.76,129.25 110.76,135.85 108.39,138.22 v1(108.39,140.97)
  BOTTOM w0.102: v2(88.04,70.97) 88.46,70.54 93.18,70.54
  BOTTOM w0.127: 93.18,70.54 93.29,70.54 94.61,69.22 94.61,67.49 96.51,65.6 99.3,65.6 99.69,65.99 99.69,66.12 v1(100.46,66.88)
SOC_EMU_27_R: length 2.4
  TOP w0.127: EMU1.30 102.03,146.18 R79.2
SOC_EMU_28: length 96.8
  TOP w0.102: 93.18,67.47 92.58,67.47 91.63,68.42 U24.A34
  TOP w0.127: v1(107.43,140.97) 107.89,141.43 107.89,144.38 106.1,146.18 R80.1 ; 93.18,67.47 93.37,67.47 95.24,65.6 97.22,65.6 v1(97.66,66.04)
  L5 w0.114: v1(97.66,66.04) 98.81,67.18 99.43,67.18 101.61,69.36 101.61,70.13 102.63,71.16 103.46,71.16 104.41,72.11 104.41,102.17 109.51,107.27 109.51,112.07 109.99,112.56 109.99,114.13 110.36,114.5 110.36,117.04 110.83,117.51 110.83,119.73 109.33,121.23 109.33,136.17 107.43,138.07 v1(107.43,140.97)
SOC_EMU_28_R: length 5.5
  TOP w0.127: R80.2 103.94,145.41 102.08,145.41 101.82,145.68 EMU1.32
SOC_EMU_29: length 107.5
  TOP w0.102: U24.D32 v2(89.02,69.92)
  TOP w0.127: R89.1 103.89,144.78 104.43,145.33 106.36,145.33 107.45,144.24 v1(107.45,142.37)
  L5 w0.114: v1(100.46,65.41) 101.98,66.93 101.98,67.29 102.55,67.86 103.28,67.86 106.35,70.94 106.35,102.66 110.53,106.84 110.53,111.48 111.56,112.5 111.56,114.12 112.13,114.7 112.13,116.61 113.54,118.01 113.54,120.13 114.2,120.8 114.2,132.93 109.17,137.96 109.17,140.81 107.61,142.37 v1(107.45,142.37)
  BOTTOM w0.102: 90.58,69.47 89.93,69.47 89.48,69.92 v2(89.02,69.92)
  BOTTOM w0.127: v1(100.46,65.41) 99.89,64.83 95.22,64.83 90.58,69.47
SOC_EMU_29_R: length 2.6
  TOP w0.127: EMU1.34 101.64,145.18 R89.2
SOC_EMU_30: length 96.2
  TOP w0.102: U24.C33 90.11,68.83 91.64,68.83 92.63,67.85 93.18,67.85
  TOP w0.127: v1(106.79,140.97) 107,141.18 107,144.15 106.37,144.78 R90.1 ; v1(97.02,66.04) 95.4,66.04 93.59,67.85 93.18,67.85
  L5 w0.114: v1(97.02,66.04) 97.04,66.04 101.26,70.26 101.26,70.28 102.49,71.5 103.32,71.5 103.82,72 103.82,76.27 103.5,76.58 103.5,101.75 109.16,107.41 109.16,112.22 109.65,112.7 109.65,114.27 110.02,114.64 110.02,118.09 109.92,118.18 109.92,120.15 108.45,121.62 108.45,126.9 106.79,128.56 v1(106.79,140.97)
SOC_EMU_30_R: length 5.7
  TOP w0.127: EMU1.36 101.39,144.68 102.06,144.02 103.94,144.02 R90.2
SOC_EMU_31: length 104.2
  TOP w0.102: 93.18,66.29 91.66,67.82 90.12,67.82 U24.C34
  TOP w0.127: R96.1 103.89,143.38 104.43,143.93 106.23,143.93 106.62,143.54 106.62,142.43 v1(106.56,142.37) ; v1(99.12,66.04) 99.12,63.54 98.72,63.14 97.92,63.14 96.83,64.24 95.35,64.24 93.29,66.29 93.18,66.29
  L5 w0.114: v1(106.56,142.37) 106.65,142.37 107.95,141.07 107.95,138.07 109.67,136.35 109.67,121.72 111.79,119.6 111.79,117.96 110.87,117.04 110.87,112.79 109.85,111.77 109.85,107.12 104.76,102.04 104.76,70.59 103.59,69.42 102.38,69.42 99.12,66.16 v1(99.12,66.04)
SOC_EMU_31_R: length 2.7
  TOP w0.127: R96.2 101.24,144.18 EMU1.38
SOC_EMU_32: length 124.6
  TOP w0.102: 93.18,64.04 93.18,64.35 91.69,65.84 91.1,65.84 90.52,66.42 U24.B36
  TOP w0.127: v1(106.18,143.36) 106.15,143.38 R97.1 ; v1(103.38,60.33) 103.37,60.33 96.9,60.33 93.18,64.04
  L5 w0.114: v1(103.38,60.33) 103.45,60.33 105.67,58.11 109.08,58.11 114.41,63.44 114.41,109.84 114.94,110.37 118.12,110.37 119.76,112.01 119.76,112.84 117.62,114.98 117.62,119.79 118.22,120.39 118.22,122 117.14,123.08 117.14,133.24 111.84,138.54 111.84,143.14 110.49,144.49 107.31,144.49 v1(106.18,143.36)
SOC_EMU_32_R: length 5.8
  TOP w0.127: EMU1.40 100.9,143.68 101.96,142.62 103,142.62 103.38,143 104.04,143 104.42,143.38 R97.2
SOC_EMU_33: length 110.5
  TOP w0.102: 93.18,66.93 92.84,66.93 91.72,68.04 90.9,68.04 U24.B34
  TOP w0.127: 93.18,66.93 93.37,66.93 95.15,65.15 97.21,65.15 v1(98.49,63.87) ; R104.1 105.77,141.99 106.12,141.63 106.12,141.01 106.61,140.53 109.85,140.53 v1(110.3,140.97)
  L5 w0.114: v1(110.3,140.97) 110.3,138.39 115.32,133.38 115.32,126.16 116.01,125.47 116.01,116.1 114.45,114.54 114.45,112.67 112.48,110.71 112.48,104.8 110.49,102.8 110.49,84.45 110.93,84.02 110.93,82.75 111.89,81.79 111.89,70.2 110.65,68.96 109.28,68.96 105.06,64.74 101.79,64.74 100.78,63.73 98.63,63.73 v1(98.49,63.87)
SOC_EMU_33_R: length 2.9
  TOP w0.127: EMU1.42 100.84,143.18 R104.2
SOC_GPIO_00: length 224.6
  TOP w0.127: v1(28.57,150.37) 28.57,147.83 31.04,145.36 31.04,142.93 30.24,142.13 30.24,141.41 31.45,140.2 CN3.54 ; R374.1 105.23,74.48 v1(105.79,73.91)
  L3 w0.114: v1(105.79,73.91) 105.73,73.97 99.5,73.97 98.23,72.7 95.68,72.7 94.59,73.79 89.61,73.79 88.63,74.76 88.63,74.83 87.91,75.55 87.87,75.55 87.64,75.78 87.64,76.02 87.09,76.58 87.01,76.58 86.61,76.97 86.61,77.87 86.1,78.38 84.91,78.38 84.41,78.88 84.41,80.07 83.95,80.54 82.86,80.54 82.4,80.99 82.4,81.08 81.95,81.54 81.02,81.54 79.9,82.66 79.9,83.93 78.61,85.22 78.61,90.44 79.38,91.22 79.38,92.93 78.8,93.52 78.8,95.68 78.4,96.07 78.4,98.08 78.06,98.43 78,98.43 77.4,99.02 77.4,99.08 77.18,99.31 77.05,99.31 76.48,99.88 76.48,100.01 75.95,100.54 75.86,100.54 74.45,101.94 74.45,102.01 74.15,102.31 74.02,102.31 70.24,106.09 70.24,107.07 70.61,107.43 70.61,113.44 66.35,117.69 66.35,119.83 65.67,120.52 65.67,122.4 64.14,123.93 64.14,125.35 59.44,130.05 59.44,131.91 57.98,133.37 56.03,133.37 55.65,132.99 48.73,132.99 48.7,133.03 46.88,133.03 46.59,132.73 45.49,132.73 45.21,132.46 44.83,132.46 43.74,133.55 43.74,134.58 43.12,135.2 42.58,135.2 41.85,135.93 41.64,135.93 40.17,137.4 40.17,137.43 40.15,137.44 40.15,138.28 40.16,138.28 40.16,139.37 40.15,139.37 40.15,140.89 39.12,141.93 39.12,143.82 37.28,145.65 37.28,146.59 36.83,147.04 v1(36.07,147.04)
  L5 w0.114: v1(36.07,147.04) 35.38,147.73 35.38,149.71 36,150.33 36,153.97 37.61,155.58 37.61,159.22 38.21,159.82 38.21,161.64 42.96,166.38 85.47,166.38 85.77,166.68 91.59,166.68 v1(92,166.27)
  L8 w0.114: v1(28.57,150.37) 30.48,148.46 31.39,148.46 32.82,147.04 v1(36.07,147.04)
  BOTTOM w0.127: v1(92,166.27) 92.3,165.96 92.3,164.31 92.72,163.9 U48.21
SOC_GPIO_01: length 207.4
  TOP w0.127: v1(96.78,71.06) 98.56,71.06 R388.1 ; v1(36.84,146.41) 36.84,145.9 34.75,143.8 34.75,141.52 33.94,140.7 CN3.56
  L3 w0.114: v1(36.84,146.41) 36.84,145.6 38.1,144.35 38.1,143.38 38.76,142.72 38.76,138.15 41.75,135.16 42.1,135.16 42.7,134.56 42.7,132.54 43.37,131.86 43.37,131.41 43.67,131.11 43.75,131.11 43.75,131.12 44.12,131.12 45.66,129.58 45.66,129.26 45.9,129.02 46.04,128.88 51.2,128.88 51.29,128.79 51.67,128.79 51.76,128.88 52.2,128.88 52.29,128.79 52.67,128.79 52.76,128.88 53.2,128.88 53.29,128.79 53.67,128.79 53.76,128.88 54.2,128.88 54.29,128.79 54.67,128.79 54.94,129.07 56.13,130.26 56.13,131.68 57.48,133.03 57.84,133.03 58.67,132.19 58.67,130.3 63.79,125.18 63.79,123.79 65.32,122.26 65.32,120.37 66.01,119.69 66.01,117.54 67.06,116.5 67.06,114.89 68.4,113.54 69.21,113.54 70.26,112.48 70.26,108.47 69.54,107.75 69.54,105.95 73.4,102.08 73.4,101.96 74.05,101.32 74.2,101.32 75.56,99.96 75.56,99.83 75.95,99.44 76.05,99.44 76.63,98.86 76.63,98.76 76.86,98.54 76.95,98.54 77.62,97.87 77.62,96.55 78.44,95.73 78.44,91.07 78.39,91.01 78.39,83.59 79.67,82.3 79.67,81.78 79.92,81.53 80.62,81.53 80.95,81.2 81.19,81.2 81.86,80.54 82.55,80.54 82.77,80.32 83.17,80.32 83.63,79.86 83.63,79.76 84.2,79.19 84.2,78.79 84.35,78.64 84.35,78.04 84.94,77.45 86.16,77.45 86.39,77.22 86.39,76.89 87.05,76.23 87.13,76.23 87.43,75.94 87.43,75.69 87.62,75.49 87.62,74.74 88.83,73.53 90.6,73.53 91.52,72.62 95.22,72.62 v1(96.78,71.06)
  L5 w0.114: v1(36.84,146.41) 36.84,146.88 36.25,147.48 36.11,147.48 35.73,147.87 35.73,148.53 36.28,149.09 37.61,149.09 38.64,150.12 38.64,158.8 39.24,159.4 39.24,161.21 41.17,163.13 41.21,163.13 42.79,164.71 91.31,164.71 v1(91.82,165.23)
  BOTTOM w0.127: U48.22 92.76,163.25 91.82,164.19 v1(91.82,165.23)
SOC_GPIO_02: length 203.2
  TOP w0.127: CN3.66 33.57,148.2 33.86,147.91 v1(34.63,147.91)
  L3 w0.114: v1(34.63,147.91) 34.82,148.11 34.87,148.11 35.94,149.17 36.5,149.17 37.62,148.05 37.62,147.78 38.52,146.87 38.52,145.53 40.98,143.07 40.98,139.84 41.76,139.06 43.43,139.06 46.19,136.31 46.54,136.31 46.78,136.07 46.78,135.72 47.33,135.17 49.51,135.17 51,133.68 55.36,133.68 56.02,134.34 60.05,134.34 61.76,132.63 61.76,131.58 64.31,129.03 67.58,129.03 67.69,128.92 67.69,126.79 67.71,126.77 67.71,123.45 68.06,123.11 68.07,123.11 68.52,122.67 68.52,117.21 68.52,116.5 71.35,113.67 71.35,107.2 70.93,106.78 70.93,106.38 74.5,102.81 75.27,102.81 75.51,102.57 76.92,102.57 77.57,101.92 77.57,100.82 77.86,100.54 78.05,100.54 78.63,99.96 78.63,98.8 78.9,98.54 78.95,98.54 79.43,98.06 79.43,93.78 80.14,93.07 80.14,91.14 79.6,90.6 79.6,88.29 79.67,88.22 79.67,86.24 80.54,85.37 80.54,82.85 80.86,82.54 82.26,82.54 82.63,82.16 82.63,81.76 82.86,81.54 83.55,81.54 83.77,81.32 84.17,81.32 85.66,79.82 85.66,79.74 85.9,79.51 86.03,79.51 86.61,78.93 86.61,78.83 86.9,78.54 87.92,78.54 88.41,78.04 88.41,76.74 89.81,75.34 95.43,75.34 v1(96.29,74.47)
  L5 w0.114: v1(91.44,167.89) 90.66,167.11 85.72,167.11 85.33,166.72 42.81,166.72 37.87,161.78 37.87,159.97 37.27,159.37 37.27,155.72 35.66,154.11 35.66,150.84 34.62,149.8 34.62,147.92 v1(34.63,147.91)
  BOTTOM w0.127: U48.23 92.47,162.6 91.38,163.69 91.38,167.83 v1(91.44,167.89) ; v1(96.29,74.47) 96.69,74.87 98.17,74.87 R703.1
SOC_GPIO_03: length 220.6
  TOP w0.127: R396.1 102.69,64.26 v1(102.74,64.2) ; v1(30.87,148.97) 31.14,148.7 CN3.68
  L3 w0.102: 62.53,100.79 59.31,104.01 59.18,104.01
  L3 w0.114: 59.18,104.01 57.69,105.51 54.24,105.51 46.21,113.54 45.1,113.54 44.34,114.3 44.34,114.88 44.03,115.19 43.67,115.19 43.53,115.06 42.27,115.06 41.67,115.66 41.67,116.46 v1(41.6,116.53) ; 62.53,100.79 63.79,99.54 63.95,99.54 64.63,98.86 64.63,97.76 65.01,97.38 66.11,97.38 66.54,96.95 66.54,93.85 68.08,92.31 68.18,92.31 68.48,92.01 68.48,90.92 68.63,90.77 68.63,84.25 69.55,83.34 69.55,82.85 70.87,81.53 71.41,81.53 71.45,81.48 72.26,80.67 72.55,80.38 73.12,80.38 74.45,79.05 74.45,76.11 75.25,75.31 78.39,75.31 79.63,74.07 79.63,66.76 80.08,66.31 80.18,66.31 80.64,65.85 80.64,65.73 81.05,65.31 81.18,65.31 81.63,64.86 81.63,64.76 82.07,64.32 100.02,64.32 100.26,64.08 102.62,64.08 v1(102.74,64.2)
  L5 w0.114: v1(90.63,167.87) 90.21,167.46 85.58,167.46 85.19,167.06 42.67,167.06 37.53,161.92 37.53,160.11 36.93,159.51 36.93,155.86 35.32,154.25 35.32,150.98 33.31,148.97 v1(30.87,148.97)
  L10 w0.114: v1(30.87,148.97) 32,147.84 32,136.65 32,136.37 33.16,135.21 33.16,127.18 33.81,126.53 34.83,126.53 35.38,125.97 35.38,125.54 36.01,124.91 36.01,124.21 39.03,121.19 42.02,121.19 42.27,120.93 42.27,118.47 41.53,117.73 41.53,116.6 v1(41.6,116.53)
  BOTTOM w0.127: U48.24 92.02,161.95 90.83,163.14 90.83,167.67 v1(90.63,167.87)
SOC_GPIO_04: length 197.3
  TOP w0.127: v1(36.65,147.76) 36.64,147.76 36.07,147.76 35.47,148.36 34.5,148.36 33.66,149.2 CN3.70 ; R383.1 99.13,72.97 98.87,72.71 96.71,72.71 96.28,73.14 v1(96.27,73.14)
  L3 w0.114: v1(96.27,73.14) 94.89,74.52 89.86,74.52 89.6,74.77 89.6,74.99 87.6,77 87.6,77.89 87.18,78.31 86.52,78.31 86.22,78.61 85.79,78.61 84.63,79.76 84.63,80.16 83.69,81.1 83.68,81.1 83.46,81.32 82.77,81.32 82.4,81.68 82.4,82.08 82.17,82.32 80.77,82.32 80.32,82.76 80.32,84.01 79.39,84.95 79.39,90.72 79.6,90.93 79.6,93.17 79.12,93.65 79.12,96.49 78.62,97 78.62,98.26 78.56,98.32 78.41,98.47 78.41,99.11 77.99,99.54 77.92,99.54 76.92,100.54 76.86,100.54 76.4,100.99 76.4,101.08 75.4,102.08 75.4,102.36 75.18,102.59 74.23,102.59 70.59,106.23 70.59,106.92 70.95,107.28 70.95,113.58 67.44,117.09 67.44,120.34 66.79,121 66.79,126.69 64.79,128.69 61.55,128.69 59.82,130.42 59.82,132.95 58.92,133.85 56.02,133.85 55.5,133.34 48.87,133.34 48.65,133.56 45.66,133.56 45.47,133.36 45.12,133.36 44.3,134.19 44.3,134.8 43.37,135.72 43.37,135.96 43.12,136.22 43.11,136.22 43.05,136.27 41.78,136.27 40.51,137.54 40.51,143.05 37.62,145.94 37.62,146.78 v1(36.65,147.76)
  L5 w0.114: v1(90.35,164.08) 89.83,163.56 87.97,163.56 87.5,164.03 45.11,164.03 42.59,161.52 42.4,161.52 41.46,160.58 41.46,160.09 41.2,159.84 40.77,159.84 40.52,159.58 40.52,158.03 39.72,157.24 39.72,154.55 40.44,153.83 40.44,152.6 40.16,152.32 39.68,152.32 38.99,151.63 38.99,149.98 36.76,147.76 v1(36.65,147.76)
  BOTTOM w0.127: v1(90.35,164.08) 90.35,163.02 92.06,161.3 U48.25
SOC_GPIO_05: length 197.8
  TOP w0.127: v1(36.5,149.67) 36.5,149.52 35.72,148.74 34.78,148.74 33.81,149.7 CN3.72
  L3 w0.114: v1(95.5,75.77) 89.68,75.77 88.63,76.83 88.63,78.86 87.95,79.54 86.87,79.54 86.46,79.94 86.46,80.04 86.18,80.32 85.77,80.32 84.55,81.54 83.86,81.54 83.4,81.99 83.4,82.08 83.18,82.31 83.07,82.31 82.4,82.98 82.4,83.08 82.18,83.31 81.19,83.31 80.76,83.74 80.76,85.69 80.52,85.93 80.52,97.2 80.38,97.33 80.38,98.01 79.55,98.84 79.55,100.09 79.11,100.54 78.86,100.54 78.63,100.76 78.63,101.16 76.95,102.84 75.54,102.84 72.06,106.33 72.06,106.7 71.69,107.06 71.69,113.95 68.86,116.78 68.86,128.23 67.52,129.57 65.69,129.57 64.44,130.82 64.13,130.82 63.47,131.48 62.39,131.48 62.11,131.76 62.11,132.77 60.19,134.68 55.8,134.68 55.2,134.07 51.09,134.07 49.66,135.51 47.48,135.51 47.12,135.86 47.12,136.21 46.68,136.66 46.33,136.66 43.58,139.41 41.9,139.41 41.33,139.98 41.33,143.21 38.87,145.67 38.87,147.29 36.48,149.67 v1(36.5,149.67)
  L5 w0.114: v1(89.79,166.24) 89.24,165.69 43.24,165.69 38.9,161.35 38.9,159.54 38.3,158.94 38.3,150.31 37.66,149.67 v1(36.5,149.67)
  BOTTOM w0.127: v1(89.79,166.24) 89.79,162.99 92.13,160.65 U48.26 ; R697.1 96.06,76.33 v1(95.5,75.77)
SOC_GPIO_06: length 216.7
  TOP w0.127: v1(34.07,150.47) 33.81,150.2 CN3.74
  L3 w0.114: v1(34.07,150.47) 32.48,148.88 32.48,146.71 34.53,144.65 34.53,142.86 35.52,141.88 35.52,137.95 38.29,135.18 38.29,128.24 42.59,123.95 42.92,123.95 43.93,122.94 44.47,122.94 44.65,122.75 45.52,122.75 46.41,121.87 46.41,115.79 53.84,108.35 60.52,108.35 60.98,107.89 60.98,107.6 67.63,100.95 67.63,100.79 69.1,99.32 69.17,99.32 69.63,98.86 69.63,98.81 69.91,98.54 69.93,98.54 70.63,97.84 70.63,97.76 70.86,97.54 70.95,97.54 71.55,96.94 71.55,96.84 71.9,96.49 71.99,96.49 72.63,95.86 72.63,95.76 73.56,94.83 73.56,84.93 74.63,83.86 74.63,83.46 75.41,82.67 75.41,81.67 75.63,81.46 75.63,80.76 76.86,79.54 76.95,79.54 77.41,79.08 77.41,78.68 78.03,78.05 79.08,78.05 79.76,77.37 80.71,77.37 81.55,76.54 81.95,76.54 82.63,75.86 82.63,69.82 82.92,69.53 83.47,69.53 84.51,68.5 90.1,68.5 91.07,67.53 95.87,67.53 96.7,68.36 100.87,68.36 101.69,69.18 103.35,69.18 105.82,71.64 v1(105.82,72.33)
  L5 w0.114: v1(89.46,167.89) 89.02,168.33 85.97,168.33 85.04,167.41 42.81,167.41 42.81,167.41 42.53,167.41 36.21,161.08 36.21,155.63 34.98,154.4 34.98,151.31 34.14,150.47 v1(34.07,150.47)
  BOTTOM w0.127: U48.27 91.94,160 89.34,162.6 89.34,167.78 v1(89.46,167.89) ; R712.1 105.54,72.33 v1(105.82,72.33)
SOC_GPIO_07: length 210
  TOP w0.127: v1(99.95,70.87) 100.55,71.46 101.5,71.46 R387.1 ; v1(36.58,152.96) 35.72,153.82 34.93,153.82 34.8,153.7 34.8,151.84 33.67,150.7 CN3.76
  L3 w0.114: v1(36.58,152.96) 35.54,151.92 35.54,149.75 34.58,148.79 34.41,148.79 33.85,148.24 33.85,147.27 35.9,145.22 35.9,143.64 36.19,143.36 36.67,143.36 37.73,142.3 37.73,137.68 40.59,134.82 40.59,130.92 43.31,128.2 43.35,128.2 43.61,127.94 43.61,126.97 44.54,126.03 44.98,126.03 45.92,126.97 48.06,126.97 49.07,125.96 49.76,125.96 50.02,125.71 50.33,125.71 50.62,125.42 51.92,125.42 52.83,124.51 57.43,124.51 58.65,123.29 59.26,123.29 60.59,121.96 60.59,110.96 69.05,102.5 70.59,102.5 72.78,100.31 73.18,100.31 73.4,100.08 73.4,99.72 73.83,99.29 74.18,99.29 74.41,99.06 74.41,98.19 74.45,98.15 74.45,98 75.07,97.38 75.1,97.38 76.41,96.07 76.41,84.38 76.62,84.17 76.62,83.65 77.59,82.68 77.59,81.81 78.09,81.31 78.18,81.31 78.63,80.86 78.63,80.76 78.86,80.54 78.95,80.54 79.62,79.87 79.62,79.77 79.85,79.55 80.85,79.55 81.86,78.54 82.6,78.54 82.83,78.31 83.18,78.31 83.4,78.08 83.4,78.07 85.17,76.31 85.18,76.31 85.43,76.06 85.43,74.04 85.91,73.55 87.09,73.55 87.51,73.13 87.51,72.88 88.05,72.34 89.36,72.34 89.89,71.81 94.77,71.81 96.3,70.28 98.72,70.28 99.31,70.87 v1(99.95,70.87)
  L5 w0.114: v1(88.85,166.19) 85.77,166.19 85.61,166.03 43.1,166.03 38.56,161.49 38.56,159.68 37.96,159.08 37.96,154.34 v1(36.58,152.96)
  BOTTOM w0.127: U48.28 91.88,159.35 88.95,162.28 88.95,166.09 v1(88.85,166.19)
SOC_GPIO_08: length 269.7
  TOP w0.127: v1(81.05,115.49) 81.05,115.57 80.67,115.96 U21.6 ; R384.1 101.5,72.86 100.62,72.86 v1(100.58,72.9) ; v1(34.62,157.02) 34.78,156.87 34.78,154.21 34.42,153.85 34.42,153.5 34.42,153.5 34.42,152.46 34.42,152.46 34.42,151.99 33.63,151.2 CN3.78
  L3 w0.114: v1(34.62,157.02) 34.75,157.02 35.43,156.34 36.76,156.34 37.47,155.63 37.47,153.16 35.88,151.57 35.88,149.6 34.73,148.45 34.55,148.45 34.19,148.09 34.19,147.63 35.96,145.87 36.1,145.87 37.76,144.21 37.76,143.24 38.42,142.58 38.42,137.96 41.27,135.1 41.27,131.72 42.88,130.12 44.12,130.12 44.37,129.86 44.37,129.5 44.3,129.43 44.3,127.4 44.42,127.27 45.18,127.27 45.67,127.76 55.14,127.76 56.11,126.8 58.93,123.98 59.55,123.98 61.34,122.18 61.34,114.3 64.77,110.87 64.77,107.75 69.47,103.05 71.34,103.05 72.86,101.54 72.95,101.54 73.48,101.01 73.48,100.77 73.9,100.36 74.17,100.36 74.63,99.89 74.63,99.8 74.89,99.54 74.95,99.54 75.63,98.86 75.63,98.76 75.86,98.54 75.95,98.54 76.63,97.86 76.63,97.76 76.86,97.54 76.95,97.54 77.4,97.08 77.4,85.66 78,85.07 78,83.67 79.46,82.21 79.46,81.69 79.84,81.31 80.47,81.31 80.78,80.99 81.06,80.99 81.76,80.29 82.1,80.29 82.6,79.79 82.6,79.79 82.87,79.52 83.23,79.52 83.98,78.77 83.98,78.11 85.34,76.74 85.36,76.74 85.42,76.68 85.96,76.68 86.58,76.06 86.58,75.68 86.83,75.44 87.01,75.44 87.41,75.04 87.41,74.65 88.75,73.31 90.34,73.31 91.49,72.16 94.92,72.16 96.46,70.62 97.5,70.62 99.78,72.9 v1(100.58,72.9)
  L5 w0.114: v1(81.05,115.49) 81.05,116.18 82.25,117.37 82.25,120.66 83.92,122.33 83.92,123.52 85.08,124.69 87.06,124.69 87.93,125.57 87.93,126.47 91.1,129.64 91.1,132.46 92.17,133.53 92.17,138.93 93.11,139.87 93.11,155.68 v1(92.2,156.59) ; v1(34.62,157.02) 34.36,156.76 33.83,156.76 33.57,157.02 33.57,160.39 42.86,169.67 v1(81.66,169.67)
  BOTTOM w0.127: v1(92.2,156.59) 92.2,157.43 90.28,159.35 U48.1 85.2,159.35 81.66,162.89 v1(81.66,169.67)
SOC_GPIO_09: length 274.4
  TOP w0.127: v1(33.98,152.27) 33.98,152.09 33.59,151.7 CN3.80 ; v1(82.17,167.84) 85.04,164.97 85.04,151.54 86.64,149.94 89.43,149.94 v1(89.47,149.99) ; U17.6 82.07,122.05 83.06,123.04 v1(83.06,124.05)
  L3 w0.114: v1(33.98,152.27) 32.14,150.43 32.14,146.56 34.19,144.51 34.19,142.72 35.17,141.73 35.17,137.81 37.95,135.03 37.95,128.1 41.89,124.15 41.89,123.73 42.69,122.94 42.69,122 43.45,121.25 45.6,121.25 46.06,120.78 46.06,115.65 53.7,108.01 60.38,108.01 60.64,107.75 60.64,107 66.47,101.17 66.47,100.97 66.97,100.47 67.19,100.47 67.42,100.25 67.42,99.8 67.9,99.31 68.18,99.31 68.4,99.08 68.4,98.99 69.04,98.36 69.15,98.36 69.37,98.13 69.37,98 69.77,97.61 69.88,97.61 70.4,97.08 70.4,96.99 70.97,96.42 71.07,96.42 71.63,95.86 71.63,95.76 71.86,95.54 71.95,95.54 72.53,94.96 72.53,84.96 73.4,84.08 73.4,83.99 73.86,83.54 73.95,83.54 74.63,82.86 74.63,81.76 74.99,81.41 75.08,81.41 75.41,81.08 75.41,80.62 76.63,79.4 76.63,78.76 77.08,78.31 77.47,78.31 77.96,77.83 78.65,77.83 79.93,76.54 80.94,76.54 81.56,75.93 81.56,75.83 81.88,75.51 81.97,75.51 82.41,75.07 82.41,69.13 83.16,68.38 83.19,68.38 83.42,68.16 83.42,68.08 83.96,67.53 90.25,67.53 90.6,67.19 96.02,67.19 96.84,68.01 101.16,68.01 101.98,68.83 104.25,68.83 106.55,71.14 106.55,72.77 v1(107.06,73.28)
  L5 w0.114: v1(82.17,167.84) 42.48,167.84 35.86,161.23 35.86,155.77 34.63,154.54 34.63,152.93 v1(33.98,152.27) ; v1(83.06,124.05) 83.06,124.37 84.97,126.28 86.72,126.28 90.42,129.98 90.42,132.77 91.29,133.64 91.29,138.54 92.77,140.01 92.77,147.16 89.94,149.99 v1(89.47,149.99)
  BOTTOM w0.127: U48.2 85.21,160 82.04,163.17 82.04,167.72 v1(82.17,167.84) ; v1(107.06,73.28) 106.61,72.83 105.61,72.83 105.23,73.22 R708.1
SOC_GPIO_10: length 224.5
  TOP w0.127: U30.6 104.72,58.67 104.08,59.32 104.08,61.66 104.52,62.1 104.52,62.12 v1(104.51,62.12) ; CN3.82 30.92,152.2 v1(30.86,152.15) ; R724.1 102.83,66.93 v1(102.88,66.98)
  L3 w0.114: v1(104.51,62.12) 104.51,62.12 104.26,62.36 104.26,63.58 104.27,63.58 104.27,65.59 v1(102.88,66.98) 102.54,67.32 99.15,67.32 98.33,66.5 91.64,66.5 90.67,65.53 82.95,65.53 82.4,66.07 82.4,66.15 81.99,66.57 81.83,66.57 81.41,66.98 81.41,67.11 81.19,67.34 81.08,67.34 80.63,67.79 80.63,75.16 80.27,75.53 79.57,75.53 78.65,76.45 76.94,76.45 76.4,76.99 76.4,77.08 76.02,77.47 75.92,77.47 75.63,77.76 75.63,79.16 75.26,79.54 74.86,79.54 73.64,80.75 73.64,81.75 72.4,82.99 72.4,83.08 72.18,83.31 72.08,83.31 71.4,83.99 71.4,84.08 71.18,84.31 71.08,84.31 70.48,84.91 70.48,88.71 70.43,88.76 70.43,94.96 69.52,95.87 69.52,95.97 69.15,96.34 68.97,96.34 68.4,96.91 68.4,97.04 67.9,97.54 67.86,97.54 67.4,97.99 67.4,98.08 67.01,98.48 66.92,98.48 66.63,98.76 66.63,98.86 65.95,99.54 65.86,99.54 65.4,99.99 65.4,100.08 64.95,100.54 64.73,100.54 63.47,101.8 63.47,102.64 59.02,107.09 53.63,107.09 43.81,116.9 43.81,119.64 v1(41.83,121.63)
  L5 w0.114: v1(30.86,152.15) 32.61,153.9 32.61,160.4 42.67,170.45 82.15,170.45 v1(82.93,169.67)
  L10 w0.114: v1(41.83,121.63) 39.28,121.63 37.21,123.7 37.21,125.48 36.51,126.18 36.51,126.42 36.25,126.68 35.63,126.68 35.2,127.11 35.2,128.76 34.54,129.41 33.91,129.41 33.5,129.82 33.5,135.35 32.35,136.51 32.35,150.66 v1(30.86,152.15)
  BOTTOM w0.127: U48.3 85.68,160.65 82.79,163.54 82.79,169.53 v1(82.93,169.67)
SOC_GPIO_11: length 213.5
  TOP w0.127: v1(33.98,152.91) 33.77,152.7 CN3.84 ; v1(103,68.39) 102.73,68.65 102.73,69.47 102.05,70.15 R718.1 ; U26.1 106.06,65.12 v1(106.09,65.15)
  L3 w0.102: 63.71,103 62.89,103.82 62.89,104.01
  L3 w0.114: v1(106.09,65.15) 105.92,65.15 103,68.07 v1(103,68.39) 102.3,68.39 101.58,67.67 96.99,67.67 96.16,66.84 91.19,66.84 90.88,66.54 83.89,66.54 83.61,66.82 83.61,66.88 83.18,67.31 83.17,67.31 82.38,68.1 82.38,68.11 82.15,68.33 82.12,68.33 81.48,68.97 81.48,75 80.97,75.51 80.88,75.51 80.59,75.8 80.59,75.89 80.16,76.33 79.34,76.33 78.17,77.5 76.9,77.5 76.41,77.98 76.41,79.07 75.17,80.32 75.07,80.32 74.41,80.98 74.41,81.85 73.63,82.63 73.63,82.86 72.95,83.54 72.86,83.54 72.63,83.76 72.63,83.86 71.51,84.98 71.51,94.98 70.95,95.54 70.86,95.54 70.63,95.76 70.63,95.86 69.95,96.54 69.86,96.54 69.58,96.82 69.58,96.83 69.12,97.29 69.12,97.29 68.45,97.95 68.45,98.03 68.18,98.31 68.08,98.31 67.63,98.76 67.63,98.86 65.95,100.54 65.86,100.54 65.63,100.76 65.63,101.08 63.71,103 ; v1(33.98,152.91) 31.79,150.72 31.79,146.42 33.85,144.37 33.85,142.54 34.83,141.56 34.83,137.66 37.11,135.39 37.11,127.2 39.68,124.63 39.68,124.3 41.07,122.92 41.58,122.92 41.6,122.94 41.96,122.94 42.22,122.69 42.22,121.85 42.27,121.81 42.27,121.69 42.67,121.28 42.8,121.28 43.18,120.9 45.02,120.9 45.72,120.2 45.72,115.5 53.7,107.52 59.39,107.52 62.89,104.01
  L5 w0.114: v1(33.98,152.91) 34.29,153.22 34.29,154.79 35.52,156.02 35.52,161.37 42.43,168.28 82.8,168.28 v1(83.24,167.84)
  BOTTOM w0.127: U48.4 85.68,161.3 83.17,163.81 83.17,167.77 v1(83.24,167.84)
SOC_GPIO_12: length 334.3
  TOP w0.127: v1(30.89,153.2) CN3.86 ; v1(99.31,69.59) 99.31,69.16 100.09,68.39 101.48,68.39 102.05,68.96 R722.1
  L3 w0.114: v1(84.81,169.65) 85.67,168.79 94.8,168.79 100.14,174.14 116.82,174.14 117.7,175.01 138.69,175.01 138.85,174.85 146.3,174.85 146.58,174.57 156.94,174.57 158.38,173.14 168.24,173.14 171.89,169.48 171.89,159.25 176.19,154.95 176.19,150.13 v1(175.74,149.68) ; v1(30.89,153.2) 32.44,154.75 32.44,155.04 33.77,156.37 34.13,156.37 34.85,155.65 34.85,150.15 34.18,149.48 34.12,149.48 33.16,148.52 33.16,146.99 35.22,144.94 35.22,143.36 35.91,142.67 36.26,142.67 37.05,141.88 37.05,137.39 38.98,135.46 38.98,131.02 41.36,128.63 41.36,127.82 42.78,126.4 42.82,126.4 43.28,125.94 43.28,125.54 43.67,125.15 45.81,125.15 45.82,125.14 48.16,125.14 48.46,124.83 50.23,124.83 50.33,124.73 51.63,124.73 52.54,123.82 57.14,123.82 58.36,122.61 58.82,122.61 59.91,121.52 59.91,110.67 68.68,101.9 69.59,101.9 71.63,99.86 71.63,99.76 71.86,99.54 71.95,99.54 72.63,98.86 72.63,98.76 72.86,98.54 72.9,98.54 73.4,98.03 73.4,96.99 74.08,96.31 74.18,96.31 75.4,95.08 75.4,87.68 75.42,87.66 75.42,85.96 75.41,85.96 75.41,84.67 75.63,84.46 75.63,83.76 76.08,83.31 76.18,83.31 76.57,82.91 76.57,81.81 76.63,81.75 76.63,80.76 76.86,80.54 77.26,80.54 78.4,79.39 78.4,78.99 78.86,78.54 80.95,78.54 81.63,77.86 81.63,77.76 81.86,77.54 82.26,77.54 82.48,77.31 83.18,77.31 83.63,76.86 83.63,73.76 83.72,73.67 83.72,72.89 84.27,72.34 86.06,72.34 86.4,72 86.4,71.92 87,71.33 87.18,71.33 87.41,71.1 87.41,71.05 87.92,70.54 94.77,70.54 95.71,69.59 99.29,69.59 99.3,69.59 v1(99.31,69.59)
  L5 w0.114: v1(84.81,169.65) 83.66,170.8 42.52,170.8 32.27,160.54 32.27,154.58 32.26,154.58 v1(30.89,153.2)
  BOTTOM w0.127: U48.5 85.68,161.95 84.33,163.3 84.33,169.16 v1(84.81,169.65) ; v1(175.74,149.68) 177.3,149.68 177.67,149.31 R522.1
SOC_GPIO_13: length 318.1
  TOP w0.127: CN3.88 33.73,153.7 34.39,154.37 34.39,156.56 34.01,156.95 v1(34.01,157.2)
  L3 w0.114: v1(102.72,70.62) 100.6,70.62 100.3,70.33 99.29,70.33 98.89,69.93 96.08,69.93 94.64,71.37 88.02,71.37 87.38,72.01 87.38,72.11 86.18,73.31 85.07,73.31 84.58,73.8 84.58,76.21 83.26,77.54 82.86,77.54 82.63,77.76 82.63,77.86 82.17,78.32 81.77,78.32 80.78,79.31 79.08,79.31 77.6,80.8 77.6,80.89 77.35,81.14 77.35,82.55 76.4,83.5 76.4,84.08 76.08,84.4 75.99,84.4 75.63,84.76 75.63,85.87 75.63,85.87 75.63,87.75 75.63,87.76 75.63,95.39 74.45,96.56 74.45,97.06 73.63,97.88 73.63,98.86 72.95,99.54 72.86,99.54 72.63,99.76 72.63,99.98 70.49,102.11 68.95,102.11 60.25,110.81 60.25,121.66 58.96,122.95 58.5,122.95 58.36,123.09 57.28,124.17 52.68,124.17 51.78,125.08 50.48,125.08 50.37,125.18 48.62,125.18 48.09,125.7 46.49,125.7 46.18,126.02 45.82,126.02 45.43,125.63 44.42,125.63 44,126.05 43.72,126.05 42.48,127.3 42.48,127.94 42.47,127.95 42.47,128.05 40.25,130.27 40.25,134.68 37.39,137.53 37.39,142.02 36.4,143.01 36.05,143.01 35.56,143.5 35.56,145.08 33.51,147.13 33.51,148.38 34.26,149.14 34.33,149.14 35.2,150 35.2,155.81 34.01,157 v1(34.01,157.2) ; v1(84.89,167.87) 85.37,168.35 96.37,168.35 101.81,173.79 116.96,173.79 117.38,174.21 118.07,174.21 118.15,174.14 125.2,174.14 125.3,174.24 140.2,174.24 140.78,173.65 146.08,173.65 146.46,174.03 157,174.03 158.24,172.8 168.1,172.8 171.55,169.34 171.55,158.85 175.08,155.32 v1(175.08,154.31)
  L5 w0.114: v1(84.89,167.87) 84.13,168.62 42.29,168.62 35.18,161.51 35.18,159.08 34.01,157.91 v1(34.01,157.2)
  BOTTOM w0.127: U48.6 85.79,162.6 84.89,163.5 v1(84.89,167.87) ; v1(102.72,70.62) 103.12,71.03 104.74,71.03 105.23,70.54 R391.1 ; v1(175.08,154.31) R510.1
SOC_GPIO_14: length 334.1
  TOP w0.127: v1(102.93,65.18) 102.4,65.18 R732.1 ; v1(30.86,153.85) 31.22,154.2 CN3.90
  L3 w0.114: v1(102.93,65.18) 102.72,64.97 92.53,64.97 92.09,64.54 82.9,64.54 82.41,65.03 82.41,65.08 82.18,65.31 82.15,65.31 81.58,65.87 81.58,65.88 80.99,66.47 80.96,66.47 80.41,67.02 80.41,75.08 80.18,75.31 79.02,75.31 78.8,75.53 75.87,75.53 75.62,75.78 75.62,76.78 74.75,77.64 74.75,78.09 75.4,78.74 75.4,79.08 75.18,79.31 74.78,79.31 73.42,80.66 73.42,80.92 72.91,81.43 72.09,81.43 71.21,82.31 71.08,82.31 70.56,82.83 70.56,82.93 70.18,83.31 69.48,84.01 69.48,93.01 67.95,94.54 67.86,94.54 67.49,94.9 67.49,96.9 66.45,97.94 66.45,98.03 65.95,98.54 65.86,98.54 65.63,98.76 65.63,98.86 64.95,99.54 64.86,99.54 64.4,99.99 64.4,100.08 60.19,104.3 59.53,104.3 57.98,105.85 54.39,105.85 45.17,115.06 44.71,115.06 44.24,115.54 43.52,115.54 43.43,115.44 42.8,115.44 v1(42.16,116.08) ; v1(86.23,169.55) 86.65,169.13 94.65,169.13 100.68,175.16 100.97,175.45 138.74,175.45 138.99,175.2 146.45,175.2 146.66,174.98 157.02,174.98 158.52,173.48 168.38,173.48 172.24,169.63 172.24,159.39 176.54,155.09 176.54,149.46 v1(175.79,148.72)
  L5 w0.114: v1(86.23,169.55) 84.64,171.14 42.38,171.14 36.14,164.9 35.21,164.9 33.59,163.28 33.59,162.35 31.92,160.67 31.92,154.9 v1(30.86,153.85)
  L10 w0.114: v1(42.16,116.08) 42.63,116.55 42.63,120.69 42.62,120.71 42.62,121.08 42.27,121.43 42.27,121.81 42.01,122.07 39.33,122.07 37.55,123.84 37.55,125.62 36.85,126.32 36.85,126.56 36.4,127.02 35.77,127.02 35.54,127.25 35.54,128.9 35.23,129.21 35.23,135.62 32.69,138.16 32.69,152.02 30.86,153.85 v1(30.86,153.85)
  BOTTOM w0.127: v1(175.79,148.72) 175.79,148.97 176.05,149.22 R525.1 ; U48.7 85.9,163.25 85.39,163.75 85.39,168.71 v1(86.23,169.55)
SOC_GPIO_15: length 326.9
  TOP w0.127: R76.1 176.66,146.13 v1(176.4,145.87) ; CN3.92 33.69,154.7 33.95,154.96 v1(33.95,155.93)
  L3 w0.114: v1(87.02,169.57) 86.51,170.08 84.63,170.08 84.37,169.83 84.37,167.41 93.38,158.41 v1(94.59,158.41) ; v1(33.95,155.93) 33.95,154.92 34.51,154.36 34.51,150.29 34.04,149.82 33.98,149.82 32.82,148.66 32.82,146.85 34.87,144.8 34.87,143 35.86,142.02 35.86,138.09 38.63,135.32 38.63,130.04 39.82,128.86 39.85,128.86 40.11,128.6 40.11,128.58 42.64,126.05 42.68,126.05 42.93,125.8 42.93,125.43 42.93,125.39 43.52,124.8 45.67,124.8 45.68,124.8 47.9,124.8 48.31,124.39 51.49,124.39 52.44,123.44 57.04,123.44 58.22,122.26 58.68,122.26 59.56,121.38 59.56,110.49 70.63,99.42 70.63,98.76 70.86,98.54 70.95,98.54 71.63,97.86 71.63,97.76 71.86,97.54 71.95,97.54 72.54,96.95 72.54,96.85 72.86,96.54 72.95,96.54 73.4,96.08 73.4,95.99 73.86,95.54 73.95,95.54 74.6,94.89 74.6,84.89 75.4,84.08 75.4,83.49 75.63,83.26 75.63,81.76 75.86,81.54 75.95,81.54 76.4,81.08 76.4,80.68 76.77,80.32 77.17,80.32 77.62,79.87 77.62,78.77 78.11,78.28 79.16,78.28 79.85,77.59 80.8,77.59 81.07,77.32 82.17,77.32 82.63,76.86 82.63,76.76 82.86,76.54 82.95,76.54 83.4,76.08 83.4,73.1 83.45,73.06 83.45,70 84.07,69.37 90.42,69.37 91.92,67.87 94.86,67.87 96.1,69.11 100.11,69.11 100.52,69.52 103.07,69.52 v1(103.5,69.95)
  L5 w0.114: v1(87.02,169.57) 86.56,169.11 82.85,169.11 81.84,170.11 42.81,170.11 33.23,160.53 33.23,156.65 v1(33.95,155.93)
  L10 w0.114: v1(94.59,158.41) 94.59,158.56 94.87,158.85 104.03,158.85 105.3,157.58 105.3,154.24 107.31,152.22 109.14,152.22 109.46,152.54 125.67,152.54 127.91,150.3 137.89,150.3 142.34,145.85 142.85,145.85 143.54,145.16 143.54,144.73 144.37,143.89 145.92,143.89 146.81,144.78 157.64,144.78 157.99,145.13 161.25,145.13 161.77,144.6 175.13,144.6 v1(176.4,145.87)
  BOTTOM w0.127: U48.8 86.11,163.9 85.83,164.18 85.83,168.38 v1(87.02,169.57) ; R393.1 105.23,69.4 104.69,69.94 103.52,69.94 v1(103.5,69.95)
SOC_GPIO_16: length 244.4
  TOP w0.127: v1(30.89,154.53) 30.89,154.62 31.48,155.2 CN3.94 ; R398.1 102.15,62.88 v1(102.79,62.88)
  L3 w0.114: v1(98.15,148.46) 96.72,149.89 95.07,149.89 80.77,164.19 44.97,164.19 44.09,163.3 39.33,163.3 38.24,162.22 36.08,162.22 31.99,158.13 31.99,157.36 30.89,156.27 v1(30.89,154.53) ; v1(102.79,62.88) 102.12,62.88 101.47,62.23 96.9,62.23 95.69,63.44 81.95,63.44 80.6,64.79 80.6,64.89 79.95,65.54 79.86,65.54 79.41,65.99 79.41,73.99 79.05,74.35 75.05,74.35 73.46,75.94 73.46,78.74 72.63,79.57 72.63,79.86 71.18,81.31 70.35,81.31 69.19,82.47 68.92,82.47 68.41,82.98 68.41,90.07 68.18,90.31 68.08,90.31 67.63,90.76 67.63,91.86 66.18,93.31 65.08,93.31 64.52,93.87 64.52,96.91 63.9,97.54 63.86,97.54 63.43,97.96 63.43,99.17 57.44,105.16 50.67,105.16 49.02,106.81 49.02,110.24 46.48,112.79 43.81,112.79 40.89,115.7 40.89,118.24 41.15,118.49 41.15,122.17 41.4,122.43 41.71,122.43 v1(41.78,122.5)
  L10 w0.114: v1(30.89,154.53) 30.89,154.43 33.03,152.3 33.03,138.42 33.67,137.78 34.62,137.78 34.91,137.49 34.91,136.54 35.57,135.88 35.57,129.86 37.34,128.1 37.34,126.32 37.9,125.76 37.9,123.98 39.38,122.5 v1(41.78,122.5)
  BOTTOM w0.127: U50.25 110.61,150.89 110.77,150.73 110.77,148.34 110.42,147.99 98.62,147.99 v1(98.15,148.46)
SOC_GPIO_R00: length 20
  TOP w0.102: v2(87.12,72.97) 86.97,72.97 U24.F29
  TOP w0.127: v1(103.38,74.68) R374.2
  BOTTOM w0.102: v2(87.12,72.97) 87.56,72.54 92.46,72.54 93.07,73.15 93.18,73.15
  BOTTOM w0.127: R374.2 v1(103.38,74.68) 102.74,74.04 97.41,74.04 97.28,73.91 95.53,73.91 94.77,73.15 93.18,73.15
SOC_GPIO_R01: length 9.6
  TOP w0.102: U24.B30 90.9,72.42 91.28,72.04 93.14,72.04 93.18,72.09
  TOP w0.127: R388.2 96.84,71.63 v1(96.77,71.69) 96.65,71.69 96.25,72.09 93.18,72.09
  BOTTOM w0.127: R388.2 96.84,71.63 v1(96.77,71.69)
SOC_GPIO_R02: length 14.4
  TOP w0.102: U24.D29 v2(89.02,72.92)
  BOTTOM w0.102: 93.18,73.53 90.09,73.53 89.48,72.92 v2(89.02,72.92)
  BOTTOM w0.127: R702.2 100.9,74.42 99.51,74.42 R703.2 98.53,75.4 96.48,75.4 94.61,73.53 93.18,73.53
SOC_GPIO_R03: length 13.6
  TOP w0.102: U24.A35 93.18,65.76
  TOP w0.127: R396.2 100.26,63.37 v1(100.26,63.3) 99.73,62.76 97.76,62.76 96.67,63.86 95.19,63.86 93.29,65.76 93.18,65.76
  BOTTOM w0.127: R396.2 100.26,63.37 v1(100.26,63.3)
SOC_GPIO_R04: length 9.9
  TOP w0.102: 93.18,73.08 92.88,72.77 92.15,72.77 92.12,72.8 91.15,72.8 90.53,73.42 U24.B29
  TOP w0.127: R383.2 97.05,73.28 v1(96.93,73.15) 96.49,73.58 93.69,73.58 93.18,73.08
  BOTTOM w0.127: v1(96.93,73.15) 97.05,73.28 R383.2
SOC_GPIO_R05: length 15.5
  TOP w0.102: U24.E29 v2(88.02,72.92)
  BOTTOM w0.102: 93.18,73.91 90.18,73.91 89.65,73.39 88.94,73.39 88.48,72.92 v2(88.02,72.92)
  BOTTOM w0.127: R696.2 100.9,75.95 99.51,75.95 R697.2 98.58,75.78 96.23,75.78 94.36,73.91 93.18,73.91
SOC_GPIO_R06: length 18.4
  TOP w0.102: U24.D30 v2(89.02,71.92)
  TOP w0.127: v1(103.33,72.14) 103.46,72.01 R389.2
  BOTTOM w0.102: v2(89.02,71.92) 89.21,72.12 93.18,72.12
  BOTTOM w0.127: R389.2 103.46,72.01 v1(103.33,72.14) 102.51,71.31 99.76,71.31 99.07,70.61 96.55,70.61 95.04,72.12 93.18,72.12
SOC_GPIO_R07: length 13.6
  TOP w0.102: U24.C30 89.88,72.42 90.5,71.8 93.08,71.8 93.18,71.7
  TOP w0.127: v1(100.58,72) 100.59,72 ; 100.59,72 100.6,72.01 R387.2 ; 100.59,72 100.6,72 100.6,71.98 100.43,71.98 99.06,70.61 96.39,70.61 95.3,71.7 93.18,71.7
  BOTTOM w0.127: v1(100.58,72) 100.62,72 100.63,72.01 R387.2
SOC_GPIO_R08: length 10.9
  TOP w0.102: 93.18,72.47 93.14,72.42 U24.A30
  TOP w0.127: 93.18,72.47 96.41,72.47 96.55,72.33 99.34,72.33 v1(100.55,73.53) 100.67,73.41 R384.2
  BOTTOM w0.127: v1(100.55,73.53) 100.67,73.41 R384.2
SOC_GPIO_R09: length 20.7
  TOP w0.102: U24.G30 v2(86.02,72.92)
  TOP w0.127: R385.2 v1(103.38,73.41)
  BOTTOM w0.102: 93.18,72.5 93.03,72.34 87.22,72.34 86.64,72.92 86.37,72.92 86.37,72.92 v2(86.02,72.92)
  BOTTOM w0.127: R385.2 v1(103.38,73.41) 102.83,72.86 101.3,72.86 100.89,72.45 100.27,72.45 100.21,72.52 93.21,72.52 93.18,72.5
SOC_GPIO_R10: length 19.2
  TOP w0.102: U24.F31 87,70.94 v2(87.02,70.94)
  TOP w0.127: v1(100.46,66.17) 100.86,66.17 101.15,66.45 R724.2
  BOTTOM w0.102: v2(87.02,70.94) 87.52,70.94 88.13,70.34 90.25,70.34 90.68,69.91
  BOTTOM w0.127: R724.2 101.15,66.86 v1(100.46,66.17) 99.5,65.21 95.37,65.21 90.68,69.91
SOC_GPIO_R11: length 16.9
  TOP w0.102: U24.E30 v2(88.02,71.92)
  TOP w0.127: v1(99.96,69.58) 100.25,69.58 R718.2
  BOTTOM w0.102: v2(88.02,71.92) 88.27,71.92 88.65,71.54 92.99,71.54 93.18,71.73
  BOTTOM w0.127: R718.2 100.25,69.58 v1(99.96,69.58) 99.94,69.58 99.76,69.76 99.76,69.78 99.31,70.23 96.39,70.23 94.88,71.73 93.18,71.73
SOC_GPIO_R12: length 17.1
  TOP w0.102: v2(87,71.88) 87,71.94 U24.F30
  TOP w0.127: R722.2 100.71,69.09 v1(100.46,68.83)
  BOTTOM w0.102: v2(87,71.88) 87.5,71.88 87.88,71.5 88.36,71.5 88.55,71.31 93.18,71.31
  BOTTOM w0.127: 93.18,71.31 94.77,71.31 96.23,69.85 98.3,69.85 99.01,69.14 99.78,69.14 99.78,69.14 100.15,69.14 100.15,69.14 v1(100.46,68.83) 100.71,69.09 R722.2
SOC_GPIO_R13: length 15
  TOP w0.102: 93.18,71.32 93.09,71.42 U24.A31
  TOP w0.127: v1(103.5,70.59) 103.5,70.6 ; 103.5,70.6 102.73,71.37 101.95,71.37 101.66,71.08 100.93,71.08 100.08,70.23 96.14,70.23 95.05,71.32 93.18,71.32 ; 103.5,70.6 103.62,70.48 R390.2
  BOTTOM w0.127: R390.2 104.22,70.59 v1(103.5,70.59)
SOC_GPIO_R14: length 18.1
  TOP w0.102: v2(88.11,69.95) 87.64,70.42 U24.E32
  TOP w0.127: v1(100.46,64.52) 101.15,65.21 R732.2
  BOTTOM w0.102: 90.17,69.22 89.53,69.22 89.41,69.34 88.73,69.34 v2(88.11,69.95)
  BOTTOM w0.127: R732.2 101.15,65.21 v1(100.46,64.52) 100.33,64.39 95,64.39 90.17,69.22
SOC_GPIO_R15: length 18
  TOP w0.102: U24.B31 90.9,71.04 92.54,71.04 92.64,70.94 93.18,70.94
  TOP w0.127: R394.2 104.32,67.88 v1(104.2,67.76) 104.12,67.84 97.89,67.84 94.79,70.94 93.18,70.94
  BOTTOM w0.127: v1(104.2,67.76) 104.32,67.88 R394.2
SOC_GPIO_R16: length 12.8
  TOP w0.102: U24.A36 93.18,64.76
  TOP w0.127: 93.18,64.76 96.03,61.91 99.67,61.91 100.46,62.69 ; 100.46,62.69 100.54,62.69 100.84,62.99 R398.2 ; 100.46,62.69 v1(100.46,62.67)
  BOTTOM w0.127: R398.2 100.78,62.99 v1(100.46,62.67)
SOC_HOUT: length 131
  TOP w0.102: v2(68.02,97.92) 67.52,97.42 U24.AE5
  L5 w0.114: v2(68.02,97.92) 68.4,98.31 68.4,99.91 67.66,100.65 67.66,101.95 69.5,103.79 69.5,104.18 69,104.69 67.78,104.69 64.9,107.57 64.9,110.62 64.14,111.38 64.14,114.43 61.98,116.59 61.98,120.86 64.02,122.91 64.02,132.23 62,134.25 60.86,134.25 57.3,137.81 55.75,137.81 55.46,138.1 55.1,138.46 55.1,138.87 54.78,139.19 54.47,139.5 54.33,139.64 54.33,139.81 54.01,140.13 54.01,140.18 51.78,142.41 50.39,142.41 49.29,143.51 49.29,145.61 46.49,148.4 46.49,150.21 48.66,152.37 52.5,152.37 60.05,159.92 60.3,159.92 60.3,159.92 60.5,159.92 60.7,159.92 60.7,159.92 91.87,159.92 93.26,161.31 99.37,161.31 100.16,162.1 v1(101.39,162.1)
  BOTTOM w0.127: v1(101.39,162.1) 101.89,162.6 U47.23
SOC_I2C_EN: length 56.5
  TOP w0.127: U7.6 v1(147.07,150.69)
  L5 w0.114: v1(147.07,150.69) 148.44,149.32 148.44,141.89 146.81,140.26 146.81,137.08 146.11,136.37 146.11,133.84 146.06,133.8 146.06,129.24 146.11,129.19 146.11,128.47 148.44,126.14 148.44,121.73 145.15,118.43 145.15,115.2 143.96,114.01 138.61,114.01 135.86,111.26 135.86,111 v1(135.87,110.99)
  BOTTOM w0.127: U58.5 132.59,108.2 135.37,110.99 v1(135.87,110.99)
SOC_LRESETNMIENZ: length 91.2
  TOP w0.102: U24.AD4 68.53,98.42 v2(68.99,97.97)
  L5 w0.114: v2(68.99,97.97) 69.41,98.39 69.41,99.29 69.85,99.73 69.85,102.49 71.37,104.01 71.37,105.54 70.83,106.08 70.83,117.34 70.85,117.36 70.85,122.57 70.35,123.07 70.35,148.26 73.07,150.98 73.62,150.98 74.16,151.52 74.16,152.01 79.38,157.24 91.05,157.24 93.79,159.98 101.84,159.98 v1(102.51,160.65)
  BOTTOM w0.127: U47.26 v1(102.51,160.65)
SOC_LRESETZ: length 137.6
  TOP w0.102: U24.AE4 67.52,98.42 v2(68.02,98.92)
  L5 w0.114: v2(68.02,98.92) 67.56,99.38 65.72,99.38 65.41,99.69 65.41,101.73 64.39,102.74 62.48,102.74 61,104.23 61,109.26 60.73,109.52 60.73,109.82 60.73,109.82 60.73,110.6 60.73,119.96 63.78,123.01 63.78,129.56 62.96,130.38 62.96,131.03 63.5,131.57 63.5,132.41 61.9,134.01 60.76,134.01 57.2,137.57 55.65,137.57 55.29,137.93 54.86,138.36 54.86,138.77 54.29,139.33 54.01,139.33 52.68,140.67 52.68,141.17 51.75,142.09 50.36,142.09 49.05,143.41 49.05,145.51 46.25,148.3 46.25,150.31 46.94,151 46.94,152.33 46.3,152.98 45.32,152.98 44.96,153.34 44.96,154.01 48.55,157.61 51.69,157.61 54.97,160.88 60.7,160.88 60.9,160.88 61.1,160.88 91.45,160.88 92.84,162.27 98.61,162.27 v1(99.34,163.01)
  BOTTOM w0.127: U47.25 102.9,161.3 102.72,161.12 101.74,161.12 99.86,163.01 v1(99.34,163.01)
SOC_MDC: length 122.7
  TOP w0.102: v2(58.02,71.92) U24.AP31
  TOP w0.127: v1(140,55.75) 139.85,55.75 138.87,56.73 138.87,57.38 R405.2 138.88,57.93 139.59,58.64 U31.3
  L10 w0.114: v1(140,55.75) 139.84,55.59 139.84,50.93 135.46,46.55 135.18,46.55 109.55,46.55 105.89,50.22 97.33,50.22 95.28,52.27 95.28,55.88 v1(95.17,55.98)
  BOTTOM w0.102: v2(58.02,71.92) 57.43,71.34 57.43,69.76 55.75,68.08 55.75,67.77 56.39,67.13 56.39,62.09 55.89,61.59
  BOTTOM w0.127: v1(95.17,55.98) 95.25,55.91 95.25,54.1 94.39,53.25 81.27,53.25 79.78,54.74 59.51,54.74 55.18,59.06 55.18,60.88 55.89,61.59
SOC_MDC_3V3: length 273.5
  TOP w0.127: v1(138.63,63.94) R400.1 139.59,63.79 U31.6
  L3 w0.127: v1(113.16,168.49) 113.41,168.49 113.44,168.52 124.09,168.52 125.6,167 127.13,167 127.64,167.51 132.09,167.51 136.87,162.73 136.87,150.91 140.27,147.51 140.27,137.68 134.2,131.61 134.2,127.85 134.48,127.57 134.48,122.55 138.68,118.35 138.68,115.27 143.01,110.95 144.44,110.95 146.69,108.7 146.69,102.95 v2(148.64,100.99)
  L5 w0.127: J2.B9 11.16,161.77 25.21,161.77 27.74,164.3 27.74,164.66 35.23,172.16 50.37,172.16 51.84,173.63 83.82,173.63 84.97,172.48 99.81,172.48 101.6,170.69 105.38,170.69 105.79,171.09 110.98,171.09 112.08,169.99 112.08,169.48 112.34,169.22 112.43,169.22 v1(113.16,168.49)
  L8 w0.127: v1(138.63,63.94) 138.63,65.9 142.45,69.72 148.51,69.72 150.13,71.34 150.13,73.77 150.1,73.8 150.1,76.67 149.74,77.03 149.07,77.03 v2(148.64,76.6) 143.59,81.66 143.59,83.64 141.36,85.87 141.36,90.82 144.15,93.6 148.08,93.6 151.31,96.82 151.31,100.41 150.11,101.6 149.22,101.6 148.64,101.02 v2(148.64,100.99)
  BOTTOM w0.127: PHY2.L3 v2(148.64,100.99) ; PHY1.L3 v2(148.64,76.6)
SOC_MDIO: length 118.4
  TOP w0.102: U24.AR32 v2(58.02,70.92)
  TOP w0.127: U31.4 140.09,58.15 R404.2 139.26,57.31 139.26,56.88 139.73,56.41 v1(140.03,56.41)
  L10 w0.114: v1(140.03,56.41) 139.5,55.88 139.5,51.07 135.32,46.89 109.7,46.89 105.97,50.62 97.71,50.62 95.63,52.7 95.63,56.39 95.4,56.62 v1(95.4,56.72)
  BOTTOM w0.102: 56.43,61.59 56.64,61.8 56.64,68.58 57.64,69.58 57.64,70.54 v2(58.02,70.92)
  BOTTOM w0.127: 56.43,61.59 55.56,60.72 55.56,59.22 59.67,55.12 79.94,55.12 81.43,53.63 92.1,53.63 95.19,56.72 v1(95.4,56.72)
SOC_MDIO_3V3: length 273.4
  TOP w0.127: v1(140.1,64.32) 140.46,64.32 140.84,63.94 R399.1 140.09,63.19 U31.5
  L3 w0.127: v1(149.86,105.11) 149.86,106.5 142.02,114.34 142.02,120.27 143.18,121.42 143.18,127.28 141.02,129.44 141.02,130.14 141.58,130.7 141.58,136.97 141.03,137.52 141.03,137.99 141.58,138.54 141.58,147.45 137.48,151.55 137.48,162.62 132.08,168.02 132.08,169.29 131.27,170.1 128.45,170.1 127.51,169.16 113.03,169.16 112.53,169.67 v1(112.52,169.67)
  L5 w0.127: v1(112.52,169.67) 112.52,169.67 112.52,170.06 111.12,171.45 102.82,171.45 100.99,173.28 85.29,173.28 84.12,174.45 51.51,174.45 49.83,172.77 34.98,172.77 27.13,164.92 27.13,164.55 24.96,162.38 10.78,162.38 9.21,160.81 J2.A9
  L8 w0.127: v1(140.1,64.32) 140.52,64.32 141.55,65.35 141.55,66.32 144.2,68.96 148.97,68.96 151.14,71.13 151.14,77.4 149.61,78.94 v3(149.61,80.77) 145.92,84.45 144.53,84.45 142.88,86.11 142.88,90.68 144.91,92.71 148.34,92.71 152.04,96.42 152.04,100.71 149.86,102.9 v1(149.86,105.11)
  BOTTOM w0.127: v3(149.61,80.77) 149.73,80.65 149.73,79.88 149.14,79.29 PHY1.M1 ; PHY2.M1 149.14,104.19 149.86,104.9 v1(149.86,105.11)
SOC_NMIZ: length 94
  TOP w0.102: v2(68.96,96.9) 68.96,96.98 U24.AD5
  L5 w0.114: v2(68.96,96.9) 69.54,97.48 69.54,98.15 69.62,98.24 69.62,99.2 70.14,99.72 70.14,102.44 71.74,104.04 71.74,104.25 72.63,105.14 72.63,113.6 72.95,113.91 72.95,122.97 72.95,122.97 72.95,123.33 72.95,123.33 72.95,126.89 71.83,128 71.83,132.62 70.61,133.84 70.61,145.9 75.67,150.95 75.67,152.03 80.61,156.97 91.16,156.97 93.93,159.74 102.22,159.74 102.95,160.47 102.95,161.16 v1(102.54,161.57)
  BOTTOM w0.127: v1(102.54,161.57) 102.92,161.95 U47.24
SOC_PACLKSEL: length 293
  TOP w0.102: v2(59,71.89) 59,71.91 U24.AN30
  L3 w0.114: v1(105.63,162.81) 105.63,161.27 106.73,160.17 106.8,160.17 109.17,157.8 109.17,148.39 114.01,143.55 114.01,136.18 119.91,130.28 119.91,129.51 120.88,128.55 120.88,128.17 122.51,126.54 122.51,122.66 122.22,122.36 122.22,117.94 128.35,111.8 128.35,53.35 122.73,47.73 114.03,47.73 109.25,42.94 109.25,36.93 105.67,33.35 31.04,33.35 30.48,33.91 30.48,36.58 31.11,37.21 31.11,39.37 31.78,40.03 31.78,41.09 31.46,41.4 31.46,48.19 28.21,51.44 28.21,52.72 30.2,54.71 35.06,54.71 37.19,56.84 37.19,57.64 46.35,66.8 53.5,66.8 55.27,68.57 55.28,68.57 55.55,68.84 55.55,69.16 55.8,69.41 57.75,69.41 57.76,69.42 58.17,69.42 58.54,69.79 58.54,71.11 59,71.58 v2(59,71.89)
  BOTTOM w0.127: v1(105.63,162.81) 105.19,163.25 U47.22
SOC_PLLLOCK: length 154.7
  TOP w0.102: v2(62.05,97.83) 62.46,97.42 U24.AK5
  L5 w0.114: v2(62.05,97.83) 62.38,98.16 62.38,100.18 58.21,104.35 58.21,107.98 60.25,110.02 60.25,120.16 63.26,123.17 63.26,129.4 62.42,130.24 62.42,131.08 56.41,137.08 53.51,137.08 53.04,137.55 51.41,139.18 51.41,139.39 50.69,140.11 50.51,140.11 49.9,140.72 49.9,141.83 48.74,142.99 48.74,142.99 48.56,143.17 48.56,145.31 45.77,148.1 45.77,150.26 44.91,151.12 44.91,152.53 44.48,152.96 44.48,154.21 45.12,154.86 45.12,157.89 46.33,159.11 47.29,159.11 48.95,160.77 53.22,160.77 54.2,161.75 90.3,161.75 91.31,162.76 97.41,162.76 98.09,163.45 v1(105.66,163.45)
  BOTTOM w0.127: U50.27 107.64,149.59 105.44,151.79 105.44,161.95 106.07,162.59 106.07,163.04 v1(105.66,163.45)
SOC_PORZ: length 137.5
  TOP w0.114: U24.AK4 62.13,98.81 v2(62,98.81)
  TOP w0.127: v1(55.75,106.43) 55.28,106.9 C804.2 C803.1 54.57,109.1 C802.1 53.97,109.1 v1(53.47,109.6)
  L5 w0.102: v2(62,98.81) 61.75,98.81 61.26,99.29 58.32,99.29 57.35,100.25 57.35,102.79 56.13,104.01
  L5 w0.114: 56.13,104.01 55.75,104.39 v1(55.75,106.43) ; v1(95.28,163.9) 91.16,163.9 89.92,162.66 53.47,162.66 53.26,162.46 48.77,162.46 48.06,161.75 46.82,161.75 44.21,159.13 44.21,157.19 42.82,155.8 42.82,152.96 42.32,152.45 42.32,151.67 44.86,149.13 44.86,147.37 47.65,144.58 47.65,142.79 47.83,142.62 47.83,142.61 48.99,141.45 48.99,140.34 49.81,139.52 49.81,139.1 50.55,138.36 50.55,137.05 53.24,134.35 56.85,134.35 59.69,131.52 59.69,129.92 60.61,129 60.61,121.82 59.33,120.54 59.33,115.85 56.51,113.03 55.41,113.03 53.23,110.85 53.23,109.84 v1(53.47,109.6)
  BOTTOM w0.102: R629.2 61.56,99.24 v2(62,98.81)
  BOTTOM w0.127: v1(95.28,163.9) U47.8
SOC_POWER_GOOD: length 24
  TOP w0.127: U7.13 147.35,147.19 147.31,147.23 143.75,147.23 143.38,146.86 v1(142.62,146.86) ; R165.1 136.49,133.11 136.3,132.92 v1(136.3,132.54)
  L5 w0.114: v1(142.62,146.86) 142.18,146.42 142.18,140.01 139.93,137.75 139.93,135.76 136.72,132.54 v1(136.3,132.54)
SOC_POWER_GOOD_R: length 6.2
  TOP w0.127: R165.2 136.31,131.57 135.74,131.57 133.02,128.85 U13.25
SOC_POWER_START: length 25.1
  TOP w0.127: v1(143.28,147.5) 143.48,147.69 U7.12 ; v1(137.27,130.45) R192.2
  L5 w0.114: v1(137.27,130.45) 137.27,131.3 140.41,134.44 140.41,137.55 143.3,140.44 143.3,147.48 v1(143.28,147.5)
SOC_POWER_START_R: length 26.1
  TOP w0.127: U13.23 133.47,127.6 134.32,128.46 134.32,129.44 135.34,130.45 R192.1 136.33,131.01 138,131.01 139.17,132.18 139.17,133.32 140.65,134.8 142.06,134.8 142.19,134.68 142.56,134.68 142.7,134.82 148.59,134.82 148.89,134.52 148.89,133.6 149.35,133.15 152.53,133.15 CN7.6
SOC_RESETFULLZ: length 100.3
  TOP w0.102: v2(69.01,98.93) 68.52,99.42 U24.AD3
  TOP w0.127: v1(69.62,111.38) 69.82,111.38 70.36,111.91 C813.2 C812.1 C811.1 67.56,112.38 66.67,113.27 66.67,114.05 67.44,114.81 v1(67.75,114.81)
  L5 w0.114: v1(67.75,114.81) 67.75,115.15 70.61,118.01 70.61,122.47 70.1,122.97 70.1,148.65 72.67,151.22 72.67,152.03 78.4,157.75 91.17,157.75 93.64,160.22 101.1,160.22 v1(101.3,160.42) ; v1(69.62,111.38) 70,111 70.01,111 70.59,110.42 70.59,105.84 70.99,105.44 70.99,104.01 69.42,102.44 69.42,99.77 69.01,99.36 v2(69.01,98.93)
  BOTTOM w0.102: R625.2 68.5,98.43 v2(69.01,98.93)
  BOTTOM w0.127: v1(101.3,160.42) 101.26,160.46 99.53,160.46 97.39,162.6 U47.6
