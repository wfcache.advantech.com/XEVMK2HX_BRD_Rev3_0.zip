# Allegro board 19C2830503-01-JOB.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
AMCC_P8_SRIO1_RXP_C: length 9.5
  TOP w0.102: C265.2 46.42,79.29 arc(46.44,79.39) 46.5,79.47 46.52,79.49 arc(46.6,79.55) 46.7,79.57 47.07,79.57 47.07,79.56 arc(47.2,79.52) 47.33,79.45 47.46,79.37 arc(47.66,79.22) 47.84,79.06 48.02,78.88 48.94,77.95 arc(49.11,77.84) 49.3,77.8 53.01,77.8 53.04,77.83 54.16,77.83 arc(54.43,77.71) U24.AV25
AMCC_P8_SRIO1_TXN: length 73.6
  TOP w0.102: v2(57,77.83) 57,77.94 U24.AT24
  L10 w0.089: v1(12.29,78.64) arc(12.45,78.92) 12.76,79.01 arc(13,78.91) 13.14,78.68 13.18,78.56 arc(13.3,78.31) 13.52,78.14 arc(13.94,77.99) 14.38,77.94 arc(14.67,77.9) 14.93,77.76 arc(15.64,77.36) 16.45,77.23 22.67,77.23 arc(22.95,77.17) 23.19,77.02 arc(23.81,76.6) 24.54,76.45 33.73,76.45 arc(33.88,76.47) 34.03,76.51 arc(34.3,76.65) 34.54,76.84 34.75,77.02 arc(34.94,77.15) 35.16,77.24 arc(35.23,77.26) 35.31,77.28 37.64,77.28 arc(37.93,77.33) 38.18,77.5 38.4,77.72 arc(38.64,77.88) 38.94,77.94 41.29,77.94 arc(41.45,77.91) 41.59,77.82 arc(41.86,77.64) 42.18,77.57 54.08,77.57 arc(54.29,77.53) 54.46,77.41 54.48,77.4 arc(54.79,77.19) 55.17,77.11 56.33,77.11 arc(56.48,77.14) 56.6,77.23 56.65,77.27 arc(56.85,77.53) v2(57,77.83)
  BOTTOM w0.102: AMC1.90 4.64,94.46 arc(4.8,94.43) 4.95,94.35 arc(4.98,94.33) 5.01,94.31 arc(5.18,94.19) 5.38,94.15 6.55,94.15 arc(6.84,94.09) 7.08,93.93 arc(7.33,93.77) 7.61,93.71 10.24,93.71 arc(10.48,93.68) 10.69,93.56 10.71,93.56 11.1,93.17 14.74,89.53 arc(14.96,89.2) 15.04,88.81 15.04,83.78 arc(15.06,83.68) 15.11,83.59 15.45,83.26 arc(15.73,82.84) 15.82,82.35 arc(15.72,81.83) 15.43,81.39 13.21,79.18 arc(13.08,79.09) 12.93,79.06 12.73,79.06 arc(12.56,79.03) 12.42,78.93 12.35,78.86 arc(12.31,78.8) 12.29,78.72 v1(12.29,78.64)
AMCC_P8_SRIO1_TXP: length 73.6
  TOP w0.102: U24.AT25 56.52,77.29 56.41,77.18 56.2,77.18 56.11,77.27 56.11,77.77 v2(56.01,77.88)
  L10 w0.089: v2(56.01,77.88) arc(56.12,78.05) 56.34,78.05 arc(56.47,77.96) 56.58,77.83 arc(56.6,77.79) 56.62,77.75 arc(56.63,77.63) 56.58,77.52 arc(56.54,77.47) 56.49,77.42 56.45,77.38 arc(56.39,77.34) 56.33,77.33 55.17,77.33 arc(54.88,77.39) 54.63,77.55 54.62,77.56 arc(54.37,77.73) 54.08,77.79 42.18,77.79 arc(41.94,77.84) 41.74,77.97 arc(41.53,78.11) 41.29,78.16 38.94,78.16 arc(38.56,78.08) 38.24,77.87 38.03,77.65 arc(37.85,77.53) 37.64,77.49 35.29,77.49 arc(35.29,77.49) 35.28,77.49 arc(35.28,77.49) 35.27,77.49 arc(35.18,77.47) 35.09,77.45 arc(34.83,77.34) 34.61,77.18 34.4,77 arc(34.19,76.84) 33.95,76.71 arc(33.84,76.68) 33.73,76.67 24.54,76.67 arc(23.89,76.8) 23.34,77.17 arc(23.03,77.37) 22.67,77.44 16.45,77.44 arc(15.71,77.57) 15.06,77.93 arc(14.74,78.1) 14.38,78.16 arc(13.99,78.2) 13.61,78.33 arc(13.47,78.45) 13.39,78.61 13.35,78.74 arc(13.14,79.07) 12.78,79.22 arc(12.46,79.36) v1(12.29,79.65)
  BOTTOM w0.102: v1(12.29,79.65) 12.29,79.62 arc(12.3,79.58) 12.32,79.55 12.43,79.45 arc(12.57,79.35) 12.75,79.31 12.93,79.31 arc(12.99,79.32) 13.03,79.36 15.25,81.57 arc(15.49,81.93) 15.57,82.35 arc(15.49,82.74) 15.27,83.08 14.93,83.41 arc(14.82,83.58) 14.78,83.78 14.78,88.81 arc(14.72,89.1) 14.56,89.35 10.6,93.31 10.6,93.31 arc(10.57,93.34) 10.54,93.36 arc(10.4,93.43) 10.24,93.46 7.61,93.46 arc(7.23,93.54) 6.9,93.75 arc(6.74,93.86) 6.55,93.9 5.23,93.9 arc(5.11,93.87) 5.01,93.8 arc(4.98,93.78) 4.95,93.76 arc(4.87,93.72) 4.78,93.71 AMC1.91
AMCC_P9_SRIO2_RXN: length 51.8
  TOP w0.102: C253.1 43.11,82.19 arc(43.09,82.08) 43.03,81.99 arc(42.94,81.93) 42.83,81.91 41.64,81.91 arc(41.39,81.86) 41.18,81.73 41.16,81.7 arc(41.04,81.52) 41,81.31 arc(40.88,81.06) v1(40.61,81)
  L10 w0.089: v1(40.61,81) 40.81,81 arc(40.89,80.98) 40.96,80.94 arc(41,80.87) 41.02,80.79 41.02,80.68 arc(41,80.55) 40.93,80.45 arc(40.82,80.38) 40.7,80.35 35.27,80.35 arc(34.54,80.5) 33.92,80.91 arc(33.5,81.19) 33.01,81.29 arc(31.95,81.08) 31.06,80.49 30.16,79.59 arc(29.4,79.08) 28.51,78.91 25.62,78.91 arc(25.12,79) 24.71,79.28 arc(24.15,79.65) 23.49,79.78 19.35,79.78 arc(18.39,79.98) 17.58,80.52 arc(16.77,81.06) 15.81,81.25 14.51,81.25 arc(14.32,81.29) 14.16,81.39 14.09,81.46 arc(14.04,81.55) 14.02,81.65 arc(14.02,81.68) 14.02,81.71 arc(14.02,81.75) 14.02,81.78 arc(14.03,81.81) 14.05,81.84 arc(14.22,82.01) v1(14.43,82.14)
  BOTTOM w0.102: v1(14.43,82.14) 14.19,82.38 arc(14.03,82.62) 13.97,82.92 13.97,83.51 arc(13.98,83.63) 14.03,83.75 14.1,83.91 arc(14.15,84.07) 14.17,84.24 14.17,87.34 arc(14.1,87.73) 13.88,88.06 11.19,90.74 arc(11.13,90.8) 11.07,90.84 arc(11,90.89) 10.92,90.94 arc(10.7,91.01) 10.47,91.04 7.91,91.04 arc(7.62,91.1) 7.37,91.26 6.94,91.69 arc(6.83,91.78) 6.69,91.86 6.56,91.91 arc(6.47,91.94) 6.38,91.95 5.34,91.95 arc(5.17,91.98) 5.03,92.08 arc(4.99,92.11) 4.95,92.14 arc(4.84,92.19) 4.71,92.21 AMC1.93
AMCC_P9_SRIO2_RXN_C: length 14
  TOP w0.102: C253.2 44.01,82.2 arc(44.03,82.08) 44.1,81.99 arc(44.19,81.92) 44.3,81.9 48.87,81.9 arc(49.16,81.84) 49.41,81.68 51.64,79.45 arc(51.73,79.38) 51.82,79.32 arc(51.86,79.29) 51.91,79.27 arc(52.04,79.24) 52.18,79.22 52.81,79.22 52.83,79.2 52.96,79.2 arc(53.07,79.18) 53.16,79.13 arc(53.33,79.05) 53.52,79.02 54.58,79.02 arc(54.75,79.06) 54.87,79.18 arc(54.9,79.25) 54.91,79.32 54.91,79.63 arc(55.03,79.91) 55.31,80.02 55.42,80.02 arc(55.49,80.05) 55.52,80.13 U24.AU22
AMCC_P9_SRIO2_RXP: length 51.8
  TOP w0.102: v1(41.63,81) 41.53,81 arc(41.44,81.02) 41.36,81.07 41.34,81.09 arc(41.25,81.31) 41.34,81.52 41.36,81.55 arc(41.49,81.63) 41.64,81.66 42.7,81.66 arc(42.91,81.62) 43.09,81.5 arc(43.17,81.38) 43.2,81.24 arc(43.18,81.12) C257.1
  L10 w0.089: v1(13.41,82.14) arc(13.69,82.05) 13.81,81.78 arc(13.81,81.76) 13.8,81.74 arc(13.8,81.69) 13.8,81.64 arc(13.84,81.46) 13.94,81.31 14.01,81.24 arc(14.24,81.09) 14.51,81.03 15.81,81.03 arc(16.68,80.86) 17.42,80.36 arc(18.31,79.78) 19.35,79.57 23.49,79.57 arc(24.07,79.45) 24.55,79.13 arc(25.04,78.8) 25.62,78.69 28.51,78.69 arc(29.49,78.88) 30.31,79.43 31.21,80.33 arc(32.03,80.88) 33.01,81.08 arc(33.42,80.99) 33.77,80.76 arc(34.46,80.3) 35.27,80.14 40.7,80.14 arc(40.9,80.18) 41.08,80.3 arc(41.2,80.47) 41.24,80.68 arc(41.24,80.74) 41.25,80.8 arc(41.39,80.99) v1(41.63,81)
  BOTTOM w0.102: v1(13.41,82.14) 13.52,82.25 arc(13.67,82.46) 13.74,82.71 arc(13.72,82.81) 13.72,82.92 13.72,83.51 arc(13.74,83.69) 13.8,83.86 13.87,84.02 13.87,84.02 arc(13.91,84.13) 13.92,84.24 13.92,87.34 13.92,87.34 arc(13.86,87.63) 13.7,87.88 11.01,90.56 arc(10.97,90.6) 10.92,90.64 arc(10.71,90.75) 10.47,90.78 7.91,90.78 arc(7.52,90.86) 7.19,91.08 6.76,91.51 arc(6.69,91.57) 6.6,91.62 6.46,91.68 arc(6.42,91.69) 6.38,91.69 5.27,91.69 arc(5.12,91.66) 4.99,91.58 arc(4.97,91.56) 4.95,91.55 arc(4.84,91.48) 4.71,91.46 AMC1.94
AMCC_P9_SRIO2_RXP_C: length 14
  TOP w0.102: U24.AU23 55.52,79.58 arc(55.5,79.68) 55.44,79.76 55.43,79.77 arc(55.38,79.81) 55.31,79.82 arc(55.18,79.76) 55.12,79.63 55.12,79.32 arc(55.1,79.2) 55.05,79.08 arc(54.85,78.89) 54.58,78.82 53.52,78.82 arc(53.27,78.85) 53.04,78.97 arc(53,78.99) 52.96,78.99 52.83,78.99 52.81,78.97 52.18,78.97 arc(52,78.99) 51.82,79.04 arc(51.75,79.06) 51.69,79.09 arc(51.57,79.17) 51.46,79.27 49.23,81.5 arc(49.07,81.61) 48.87,81.65 44.44,81.65 arc(44.27,81.62) 44.14,81.52 arc(44.04,81.39) 44.01,81.22 C257.2
AMCC_P9_SRIO2_TXN: length 63.6
  TOP w0.102: v2(57.02,79.98) 57.02,79.97 57.52,79.47 U24.AR23
  L10 w0.089: v2(57.02,79.98) 57.02,79.88 arc(57,79.78) 56.94,79.7 56.93,79.69 arc(56.84,79.63) 56.73,79.61 56.3,79.61 arc(55.84,79.7) 55.45,79.96 53.99,81.41 arc(53.17,81.97) 52.2,82.16 48.51,82.16 arc(47.54,82.35) 46.71,82.9 42.22,87.4 arc(41.4,87.95) 40.42,88.14 39.57,88.14 arc(39.25,88.08) 38.97,87.89 arc(38.7,87.71) 38.38,87.65 37.62,87.65 arc(36.65,87.45) 35.82,86.9 35.73,86.81 arc(34.91,86.26) 33.94,86.07 18.36,86.07 arc(18.31,86.08) 18.26,86.11 arc(18.23,86.16) 18.21,86.22 18.21,86.3 arc(18.19,86.42) 18.12,86.53 18.1,86.55 arc(17.97,86.63) 17.82,86.66 17.57,86.66 arc(17.43,86.64) 17.3,86.55 arc(17.21,86.42) 17.18,86.28 17.18,86.23 arc(17.18,86.2) 17.16,86.18 17.12,86.13 arc(17.05,86.08) 16.96,86.07 15.36,86.07 arc(15.26,86.09) 15.18,86.14 arc(15.12,86.23) 15.1,86.32 15.1,86.57 arc(14.59,87.08) 14.08,86.57 14.08,86.27 arc(14.06,86.19) 14.02,86.13 arc(13.95,86.08) 13.87,86.07 13.62,86.07 arc(13.39,86.11) 13.2,86.25 arc(13,86.38) 12.77,86.42 10.93,86.42 arc(10.65,86.48) 10.42,86.63 arc(10.34,86.75) v1(10.31,86.89)
  BOTTOM w0.102: AMC1.96 4.63,89.96 arc(4.79,89.93) 4.93,89.84 arc(4.94,89.83) 4.95,89.82 arc(5.08,89.74) 5.23,89.71 6.07,89.71 arc(6.24,89.68) 6.38,89.58 arc(6.52,89.49) 6.69,89.45 8.78,89.45 arc(9.03,89.4) 9.24,89.27 arc(9.37,89.06) 9.42,88.81 9.42,86.72 arc(9.49,86.55) 9.65,86.49 9.83,86.49 arc(9.99,86.52) 10.13,86.61 10.24,86.72 arc(10.29,86.8) v1(10.31,86.89)
AMCC_P9_SRIO2_TXP: length 63.6
  TOP w0.102: v2(57.02,78.94) 57.18,78.94 57.52,78.6 U24.AR24
  L10 w0.089: v2(57.02,78.94) 57.02,79.2 arc(57,79.27) 56.96,79.34 arc(56.9,79.38) 56.83,79.39 56.3,79.39 arc(55.76,79.5) 55.29,79.81 53.84,81.26 arc(53.09,81.77) 52.2,81.94 48.51,81.94 arc(47.45,82.15) 46.56,82.75 42.07,87.24 arc(41.31,87.75) 40.42,87.92 39.57,87.92 arc(39.33,87.88) 39.13,87.74 arc(38.78,87.51) 38.38,87.43 37.62,87.43 arc(36.73,87.25) 35.98,86.75 35.89,86.66 arc(34.99,86.06) 33.94,85.85 18.36,85.85 arc(18.22,85.88) 18.1,85.96 arc(18.03,86.08) 18,86.22 18,86.3 arc(17.99,86.34) 17.96,86.38 17.95,86.4 arc(17.89,86.44) 17.82,86.45 17.57,86.45 arc(17.51,86.44) 17.45,86.4 arc(17.41,86.34) 17.4,86.28 17.4,86.23 arc(17.38,86.12) 17.32,86.02 17.27,85.98 arc(17.13,85.89) 16.96,85.85 15.36,85.85 arc(15.18,85.89) 15.03,85.99 arc(14.92,86.14) 14.89,86.32 14.89,86.57 arc(14.59,86.87) 14.29,86.57 14.29,86.27 arc(14.26,86.11) 14.17,85.97 arc(14.03,85.88) 13.87,85.85 13.62,85.85 arc(13.31,85.91) 13.04,86.09 arc(12.92,86.18) 12.77,86.21 10.76,86.21 arc(10.56,86.17) 10.38,86.05 arc(10.33,85.97) v1(10.31,85.88)
  BOTTOM w0.102: AMC1.97 4.61,89.21 arc(4.77,89.24) 4.9,89.33 4.93,89.36 arc(4.94,89.37) 4.95,89.38 arc(5.05,89.44) 5.16,89.46 6.07,89.46 arc(6.14,89.44) 6.2,89.4 arc(6.42,89.25) 6.69,89.2 8.78,89.2 arc(8.93,89.17) 9.06,89.09 arc(9.14,88.96) 9.17,88.81 9.17,86.72 arc(9.31,86.37) 9.65,86.23 9.83,86.23 arc(9.99,86.2) 10.13,86.11 10.28,85.96 arc(10.3,85.92) v1(10.31,85.88)
AMCC_P10_SRIO3_RXN: length 54.7
  TOP w0.102: C245.1 arc(45.51,83.99) 45.46,83.91 45.46,83.91 arc(45.21,83.75) 44.92,83.69 41.71,83.69 arc(41.39,83.63) 41.13,83.45 41.01,83.33 arc(40.92,83.19) 40.88,83.02 arc(40.78,82.72) v1(40.51,82.55)
  L10 w0.089: v1(11.07,80.26) 11.07,80.31 arc(11.08,80.36) 11.11,80.4 11.21,80.5 arc(11.36,80.6) 11.53,80.63 11.65,80.63 arc(11.81,80.66) 11.95,80.76 arc(12.04,80.89) 12.07,81.05 12.07,81.55 arc(12.16,82.01) 12.42,82.4 arc(12.81,82.66) 13.26,82.75 23.87,82.75 arc(24.39,82.85) 24.83,83.14 arc(25.12,83.34) 25.48,83.41 31.46,83.41 arc(32.13,83.28) 32.69,82.91 arc(33.32,82.48) 34.07,82.33 arc(34.09,82.33) 34.1,82.33 38.55,82.33 arc(38.92,82.41) 39.24,82.62 39.72,83.1 arc(39.9,83.22) 40.1,83.26 40.66,83.26 arc(40.76,83.24) 40.84,83.18 arc(40.9,83.1) 40.92,83 40.92,82.98 arc(40.9,82.89) 40.85,82.81 40.64,82.6 arc(40.58,82.56) v1(40.51,82.55)
  BOTTOM w0.102: AMC1.99 4.6,87.71 arc(4.76,87.68) 4.89,87.59 arc(4.92,87.56) 4.95,87.54 arc(5.07,87.48) 5.19,87.46 6.38,87.46 arc(6.77,87.39) 7.1,87.17 7.54,86.73 arc(7.67,86.64) 7.83,86.6 7.95,86.6 arc(8.15,86.56) 8.32,86.45 9.42,85.35 arc(9.58,85.24) 9.78,85.2 10.99,85.2 arc(11.12,85.23) 11.24,85.31 arc(11.51,85.49) 11.84,85.56 11.96,85.56 arc(12.17,85.51) 12.35,85.4 12.44,85.3 arc(12.63,85.02) 12.7,84.68 12.7,83.2 arc(12.62,82.81) 12.4,82.48 12.3,82.38 arc(12.15,82.14) 12.09,81.86 12.09,81.25 arc(12.05,81.06) 11.94,80.9 11.81,80.77 arc(11.67,80.68) 11.51,80.65 11.29,80.65 arc(11.21,80.63) 11.14,80.58 arc(11.09,80.51) 11.07,80.43 v1(11.07,80.26)
AMCC_P10_SRIO3_RXN_C: length 9.2
  TOP w0.102: C245.2 46.42,83.67 arc(46.43,83.61) 46.47,83.56 arc(46.51,83.53) 46.57,83.52 48.55,83.52 arc(48.84,83.46) 49.09,83.3 52.11,80.27 arc(52.36,80.11) 52.65,80.05 53.28,80.05 arc(53.37,80.07) 53.45,80.12 arc(53.5,80.19) 53.52,80.28 U24.AW22
AMCC_P10_SRIO3_RXP: length 54.7
  TOP w0.102: C248.1 45.55,82.68 arc(45.61,82.69) 45.66,82.72 arc(45.7,82.77) 45.71,82.83 45.71,83.2 arc(45.69,83.29) 45.64,83.37 arc(45.57,83.42) 45.48,83.43 41.71,83.43 arc(41.49,83.39) 41.31,83.27 41.19,83.15 arc(41.15,83.09) 41.14,83.02 41.14,82.85 arc(41.26,82.61) v1(41.53,82.55)
  L10 w0.089: v1(41.53,82.55) 41.49,82.55 arc(41.46,82.56) 41.43,82.58 41.23,82.77 arc(41.16,82.88) 41.14,83 arc(41.1,83.18) 41,83.34 arc(40.84,83.44) 40.66,83.48 40.1,83.48 arc(39.81,83.42) 39.57,83.25 39.09,82.77 arc(38.84,82.61) 38.55,82.55 34.07,82.55 arc(33.41,82.68) 32.84,83.06 arc(32.21,83.48) 31.46,83.63 25.48,83.63 arc(25.04,83.54) 24.67,83.3 24.67,83.3 arc(24.3,83.05) 23.87,82.96 13.26,82.96 arc(12.72,82.86) 12.27,82.55 arc(11.96,82.09) 11.86,81.55 11.86,81.05 arc(11.84,80.98) 11.79,80.91 arc(11.73,80.86) 11.65,80.85 11.53,80.85 arc(11.41,80.87) 11.32,80.93 11.15,81.11 arc(11.09,81.19) v1(11.07,81.28)
  BOTTOM w0.102: AMC1.100 4.45,86.96 arc(4.71,87.01) 4.92,87.15 arc(4.94,87.17) 4.95,87.18 arc(5,87.2) 5.06,87.21 6.38,87.21 arc(6.67,87.15) 6.92,86.99 7.36,86.55 arc(7.57,86.4) 7.83,86.35 7.95,86.35 arc(8.05,86.33) 8.14,86.27 9.24,85.17 arc(9.49,85.01) 9.78,84.95 10.99,84.95 arc(11.22,85) 11.42,85.13 arc(11.61,85.26) 11.84,85.3 11.96,85.3 arc(12.07,85.28) 12.17,85.22 12.26,85.12 arc(12.4,84.92) 12.45,84.68 12.45,83.2 arc(12.39,82.9) 12.22,82.66 12.12,82.56 arc(11.91,82.24) 11.84,81.86 11.84,81.25 arc(11.82,81.16) 11.76,81.08 11.63,80.95 arc(11.58,80.91) 11.51,80.9 11.46,80.9 arc(11.32,80.93) 11.19,81.01 11.13,81.07 arc(11.09,81.13) 11.07,81.2 v1(11.07,81.28)
AMCC_P10_SRIO3_RXP_C: length 9.2
  TOP w0.102: U24.AW23 53.52,79.56 arc(53.5,79.65) 53.45,79.73 arc(53.37,79.78) 53.28,79.8 52.65,79.8 arc(52.26,79.87) 51.93,80.09 48.91,83.12 arc(48.74,83.23) 48.55,83.27 46.65,83.27 arc(46.57,83.25) 46.49,83.2 arc(46.44,83.13) 46.42,83.04 C248.2
AMCC_P10_SRIO3_TXN: length 63.8
  TOP w0.102: v2(58.02,80.01) 58.12,80.01 58.52,80.41 U24.AP22
  L10 w0.089: v1(9.55,83.08) 9.95,82.68 10.23,82.68 arc(10.26,82.69) 10.29,82.71 10.41,82.83 arc(10.43,82.86) 10.44,82.89 10.44,83.82 arc(10.57,84.48) 10.94,85.03 11.08,85.17 arc(11.48,85.44) 11.96,85.53 12.39,85.53 arc(12.57,85.5) 12.73,85.39 arc(12.88,85.29) 13.06,85.26 18.8,85.26 arc(19.07,85.2) 19.29,85.05 arc(19.52,84.9) 19.78,84.85 21.86,84.85 arc(22.04,84.89) 22.2,84.99 arc(22.49,85.19) 22.84,85.26 32.31,85.26 arc(32.98,85.12) 33.54,84.75 arc(34.1,84.37) 34.77,84.24 35.9,84.24 arc(36.11,84.28) 36.29,84.4 36.99,85.1 arc(37.31,85.31) 37.68,85.38 39.08,85.38 arc(39.29,85.43) 39.47,85.54 39.72,85.79 arc(40.04,86.01) 40.41,86.08 41.87,86.08 arc(42.17,86.02) 42.41,85.86 43.06,85.21 arc(43.16,85.06) 43.2,84.89 arc(43.23,84.73) 43.32,84.6 47.7,80.21 arc(47.95,80.05) 48.24,79.99 51.37,79.99 arc(51.59,79.98) 51.82,79.95 arc(51.84,79.94) 51.86,79.94 arc(52.54,79.7) 53.12,79.26 arc(53.93,78.73) 54.88,78.54 57.14,78.54 arc(57.24,78.56) 57.33,78.61 arc(57.38,78.7) 57.4,78.8 57.4,79.01 arc(57.44,79.21) 57.56,79.38 57.6,79.42 arc(57.72,79.5) 57.86,79.53 arc(57.93,79.55) 57.96,79.6 arc(58.01,79.8) v2(58.02,80.01)
  BOTTOM w0.102: v1(9.55,83.08) 9.55,83.01 arc(9.54,82.94) 9.5,82.88 9.46,82.84 arc(9.36,82.78) 9.25,82.75 8.67,82.75 arc(8.62,82.76) 8.56,82.77 arc(8.54,82.77) 8.51,82.78 arc(8.4,82.83) 8.31,82.9 6.3,84.91 arc(5.97,85.13) 5.58,85.21 5.29,85.21 arc(5.13,85.24) 4.99,85.33 arc(4.97,85.35) 4.95,85.37 arc(4.83,85.44) 4.69,85.46 AMC1.102
AMCC_P10_SRIO3_TXP: length 63.9
  TOP w0.102: v2(58.02,78.92) 58.52,79.42 U24.AP23
  L10 w0.089: v1(9.55,82.07) 9.95,82.47 10.36,82.47 10.66,82.77 10.66,83.82 arc(10.77,84.4) 11.09,84.88 11.23,85.02 arc(11.56,85.24) 11.96,85.32 12.39,85.32 arc(12.49,85.3) 12.57,85.24 arc(12.8,85.09) 13.06,85.04 18.8,85.04 arc(18.98,85) 19.14,84.9 arc(19.43,84.7) 19.78,84.63 21.86,84.63 arc(22.13,84.69) 22.35,84.84 arc(22.58,84.99) 22.84,85.04 32.31,85.04 arc(32.9,84.92) 33.39,84.59 arc(34.02,84.17) 34.77,84.02 35.9,84.02 arc(36.2,84.08) 36.44,84.25 37.14,84.95 arc(37.39,85.11) 37.68,85.17 39.08,85.17 arc(39.37,85.23) 39.62,85.39 39.87,85.64 arc(40.12,85.81) 40.41,85.86 41.87,85.86 arc(42.08,85.82) 42.26,85.7 42.91,85.05 arc(42.96,84.98) 42.98,84.89 arc(43.03,84.65) 43.16,84.45 47.55,80.06 arc(47.87,79.85) 48.24,79.77 51.37,79.77 arc(51.57,79.76) 51.78,79.74 arc(51.8,79.73) 51.82,79.73 arc(52.44,79.5) 52.97,79.11 arc(53.84,78.53) 54.88,78.32 57.14,78.32 arc(57.33,78.36) 57.48,78.46 arc(57.58,78.62) 57.62,78.8 57.62,79.01 arc(57.64,79.12) 57.71,79.22 57.76,79.27 arc(57.81,79.3) 57.86,79.32 57.87,79.32 arc(57.92,79.3) 57.97,79.27 arc(58.01,79.22) 58.02,79.16 v2(58.02,78.92)
  BOTTOM w0.102: v1(9.55,82.07) 9.55,82.11 arc(9.52,82.26) 9.44,82.38 arc(9.31,82.47) 9.16,82.5 8.67,82.5 arc(8.55,82.51) 8.43,82.54 arc(8.27,82.61) 8.13,82.72 6.12,84.73 arc(5.88,84.9) 5.58,84.96 5.3,84.96 arc(5.14,84.92) 5,84.83 arc(4.98,84.81) 4.95,84.79 arc(4.84,84.73) 4.7,84.71 AMC1.103
AMCC_P11_SRIO4_RXN: length 46.3
  TOP w0.102: C240.1 43.11,85.94 arc(43.09,85.84) 43.04,85.76 43.02,85.74 arc(42.96,85.7) 42.88,85.68 42.8,85.68 arc(42.55,85.73) 42.35,85.87 arc(42.14,86.01) 41.9,86.06 41.48,86.06 arc(41.26,86.01) 41.08,85.89 41.07,85.88 arc(40.96,85.71) 40.92,85.52 arc(40.81,85.21) v1(40.54,85.04)
  L10 w0.089: v1(40.54,85.04) 40.66,85.04 arc(40.76,85.02) 40.84,84.96 arc(40.9,84.88) 40.92,84.78 40.92,84.56 arc(40.9,84.46) 40.84,84.38 arc(40.76,84.32) 40.66,84.3 38.83,84.3 arc(38.46,84.23) 38.14,84.02 37.65,83.52 arc(37.47,83.4) 37.26,83.36 34.38,83.36 arc(33.76,83.49) 33.23,83.84 arc(32.56,84.29) 31.77,84.44 23.64,84.44 arc(23.38,84.39) 23.15,84.24 arc(22.93,84.09) 22.66,84.04 14.43,84.04 arc(14.18,83.99) 13.97,83.84 arc(13.89,83.79) 13.8,83.78 12.91,83.78 arc(12.79,83.85) 12.66,83.87 12.03,83.87 arc(11.78,83.92) 11.57,84.06 arc(11.5,84.16) v1(11.48,84.28)
  BOTTOM w0.102: AMC1.105 4.46,83.21 arc(4.66,83.17) 4.83,83.06 arc(4.89,83.01) 4.95,82.98 arc(5,82.97) 5.06,82.96 5.33,82.96 arc(5.59,82.91) 5.8,82.77 6.96,81.6 arc(7.67,81.1) 8.51,80.86 arc(8.69,80.85) 8.87,80.85 arc(9.26,80.87) 9.64,80.94 arc(10.02,81.17) 10.22,81.56 arc(10.23,81.62) 10.24,81.69 10.24,83.22 arc(10.41,83.65) 10.83,83.82 10.98,83.82 arc(11.11,83.85) 11.23,83.92 11.41,84.1 arc(11.46,84.18) v1(11.48,84.28)
AMCC_P11_SRIO4_RXN_C: length 13.1
  TOP w0.102: C240.2 44.01,85.95 arc(44.03,85.84) 44.09,85.75 arc(44.18,85.69) 44.29,85.67 47.67,85.67 arc(47.96,85.61) 48.21,85.45 52.41,81.25 arc(52.57,81.12) 52.76,81.05 arc(52.85,81.03) 52.95,81.02 54.42,81.02 arc(54.49,81.05) 54.52,81.13 U24.AV21
AMCC_P11_SRIO4_RXP: length 46.3
  TOP w0.102: C243.1 43.11,85.18 arc(43.09,85.28) 43.04,85.36 43.03,85.37 arc(42.96,85.41) 42.88,85.43 42.8,85.43 arc(42.46,85.5) 42.17,85.69 arc(42.05,85.77) 41.9,85.8 41.48,85.8 arc(41.36,85.78) 41.26,85.71 41.25,85.7 arc(41.17,85.52) 41.25,85.35 v1(41.55,85.04)
  L10 w0.089: v1(41.55,85.04) 41.37,85.04 arc(41.28,85.02) 41.21,84.97 arc(41.15,84.89) 41.14,84.8 41.14,84.56 arc(41.1,84.38) 41,84.23 arc(40.84,84.12) 40.66,84.09 38.83,84.09 arc(38.54,84.03) 38.3,83.86 37.8,83.37 arc(37.56,83.2) 37.26,83.15 34.38,83.15 arc(33.67,83.29) 33.08,83.69 arc(32.48,84.09) 31.77,84.23 23.64,84.23 arc(23.46,84.19) 23.31,84.09 arc(23.01,83.89) 22.66,83.82 14.43,83.82 arc(14.26,83.79) 14.12,83.69 arc(13.98,83.59) 13.81,83.56 12.89,83.56 arc(12.83,83.57) 12.77,83.61 arc(12.72,83.64) 12.66,83.65 11.91,83.65 arc(11.75,83.62) 11.61,83.53 11.53,83.45 arc(11.49,83.4) 11.48,83.33 v1(11.48,83.26)
  BOTTOM w0.102: AMC1.106 4.46,82.46 arc(4.62,82.49) 4.76,82.58 arc(4.85,82.65) 4.95,82.69 arc(5,82.7) 5.06,82.71 5.33,82.71 arc(5.49,82.68) 5.62,82.59 6.79,81.43 arc(7.56,80.87) 8.48,80.61 arc(8.68,80.6) 8.87,80.59 arc(9.29,80.62) 9.7,80.7 9.7,80.7 arc(10.21,80.99) 10.47,81.51 10.47,81.51 arc(10.48,81.59) 10.49,81.67 arc(10.49,81.73) 10.49,81.79 10.49,83.22 arc(10.59,83.47) 10.83,83.57 11.09,83.57 arc(11.26,83.53) 11.41,83.43 arc(11.46,83.36) v1(11.48,83.26)
AMCC_P11_SRIO4_RXP_C: length 13.1
  TOP w0.102: U24.AV22 54.52,80.72 arc(54.49,80.79) 54.42,80.82 53.06,80.82 arc(53,80.81) 52.95,80.77 arc(52.82,80.78) 52.7,80.8 arc(52.45,80.9) 52.23,81.07 48.03,85.27 arc(47.86,85.38) 47.67,85.42 44.42,85.42 arc(44.24,85.36) 44.12,85.22 arc(44.05,85.02) C243.2
AMCC_P11_SRIO4_TXN: length 71.7
  TOP w0.102: U24.AT21 56.52,81.42 v2(56.02,80.92)
  L10 w0.089: v2(56.02,80.92) 56.02,80.81 arc(56,80.71) 55.94,80.63 55.87,80.56 arc(55.84,80.54) 55.8,80.53 arc(55.76,80.54) 55.73,80.56 54.02,82.27 arc(53.94,82.35) 53.85,82.44 arc(53.02,82.97) 52.04,83.15 51.7,83.15 arc(50.81,83.33) 50.06,83.83 47.67,86.22 arc(46.78,86.82) 45.72,87.03 44.93,87.03 arc(44.04,87.2) 43.29,87.71 42.76,88.23 arc(41.87,88.83) 40.81,89.04 39.51,89.04 arc(39.45,89.03) 39.38,89.02 39.2,88.99 arc(39.14,88.97) 39.09,88.95 38.43,88.7 arc(38.11,88.59) 37.78,88.51 arc(37.42,88.46) 37.05,88.44 arc(36.06,88.24) 35.23,87.68 35.2,87.66 arc(34.47,87.17) 33.62,87 31.25,87 arc(30.89,87.07) 30.59,87.27 30.56,87.3 arc(30.23,87.52) 29.84,87.6 26.26,87.6 arc(25.97,87.54) 25.72,87.38 arc(25.62,87.31) 25.49,87.28 18.97,87.28 arc(18.72,87.31) 18.49,87.4 18.33,87.48 arc(18.16,87.55) 17.98,87.57 17.75,87.57 arc(17.61,87.59) 17.49,87.65 17.09,87.94 arc(16.75,88.12) 16.36,88.18 11.19,88.18 arc(10.93,88.15) 10.68,88.06 10.51,87.97 10.18,87.81 arc(10.18,87.81) 10.18,87.81 10.17,87.81 arc(10.17,87.8) 10.16,87.8 9.88,87.63 arc(9.69,87.47) 9.54,87.26 9.51,87.19 arc(9.45,87.04) 9.44,86.88 9.44,85.29 arc(9.34,84.82) 9.07,84.41 8.83,84.18 arc(8.26,83.32) 8.06,82.32 8.06,80.52 arc(8.14,79.94) 8.37,79.4 arc(8.42,79.34) 8.48,79.28 arc(8.68,79.11) 8.92,78.99 arc(8.99,78.97) 9.06,78.96 arc(9.34,78.83) v1(9.45,78.54)
  BOTTOM w0.102: AMC1.108 4.52,80.96 arc(4.67,80.93) 4.81,80.84 arc(4.88,80.79) 4.95,80.75 arc(5.02,80.73) 5.1,80.72 arc(5.41,80.66) 5.67,80.48 8.1,78.05 arc(8.3,77.88) 8.51,77.73 arc(8.9,77.54) 9.32,77.44 9.61,77.44 arc(10.11,77.65) 10.31,78.14 10.31,78.76 arc(10.3,78.83) 10.26,78.89 arc(10.2,78.93) 10.13,78.94 9.96,78.94 arc(9.79,78.91) 9.65,78.82 9.5,78.67 arc(9.46,78.61) v1(9.45,78.54)
AMCC_P11_SRIO4_TXP: length 71.7
  TOP w0.102: U24.AT22 56.43,80.42 56.02,80.01 v2(56.02,80.04)
  L10 w0.089: v1(9.45,79.55) arc(9.34,79.28) 9.07,79.17 arc(9.03,79.18) 9,79.19 arc(8.8,79.29) 8.63,79.43 arc(8.59,79.47) 8.56,79.51 arc(8.35,80) 8.28,80.52 8.28,82.32 arc(8.46,83.24) 8.99,84.03 9.22,84.26 arc(9.54,84.73) 9.65,85.29 9.65,86.88 arc(9.66,86.99) 9.7,87.09 9.74,87.17 arc(9.84,87.32) 9.99,87.44 10.26,87.61 10.27,87.61 10.77,87.86 arc(10.98,87.94) 11.19,87.96 16.36,87.96 arc(16.68,87.91) 16.97,87.76 17.36,87.48 arc(17.55,87.38) 17.75,87.35 17.98,87.35 arc(18.11,87.34) 18.23,87.29 18.39,87.21 arc(18.67,87.1) 18.97,87.06 25.49,87.06 arc(25.7,87.11) 25.88,87.22 arc(26.05,87.34) 26.26,87.38 29.84,87.38 arc(30.15,87.32) 30.41,87.15 30.44,87.12 arc(30.81,86.87) 31.25,86.79 33.62,86.79 arc(34.56,86.97) 35.35,87.5 35.38,87.53 arc(36.15,88.04) 37.05,88.22 arc(37.44,88.24) 37.82,88.3 arc(38.17,88.38) 38.51,88.5 38.75,88.59 39.17,88.75 arc(39.21,88.76) 39.25,88.77 39.43,88.81 arc(39.47,88.82) 39.51,88.82 40.82,88.82 arc(41.79,88.63) 42.61,88.08 43.13,87.55 arc(43.96,87) 44.93,86.81 45.72,86.81 arc(46.69,86.62) 47.52,86.07 49.91,83.68 arc(50.73,83.13) 51.7,82.93 52.04,82.93 arc(52.94,82.77) 53.7,82.28 55.58,80.41 arc(55.67,80.34) 55.79,80.32 arc(55.97,80.23) v2(56.02,80.04)
  BOTTOM w0.102: v1(9.45,79.55) 9.45,79.48 arc(9.46,79.41) 9.5,79.35 9.55,79.3 arc(9.66,79.22) 9.8,79.2 10.13,79.2 arc(10.3,79.16) 10.44,79.07 arc(10.53,78.93) 10.57,78.76 10.57,78.14 arc(10.29,77.47) 9.61,77.19 9.29,77.19 9.29,77.19 arc(8.82,77.31) 8.38,77.52 arc(8.14,77.68) 7.92,77.87 5.5,80.3 arc(5.31,80.42) 5.1,80.47 4.98,80.47 arc(4.97,80.47) 4.95,80.47 arc(4.8,80.43) 4.67,80.34 arc(4.53,80.24) 4.36,80.21 AMC1.109
AMCC_P17_AIF4_RXN: length 83.5
  L10 w0.089: v1(45.06,89.41) 44.84,89.41 arc(44.78,89.42) 44.74,89.45 arc(44.7,89.5) 44.69,89.56 44.69,89.67 arc(44.65,89.89) 44.53,90.07 arc(44.34,90.19) 44.13,90.23 43.85,90.23 arc(43.55,90.29) 43.29,90.47 42.34,91.42 arc(41.94,91.69) 41.46,91.78 39.21,91.78 arc(38.74,91.69) 38.34,91.42 38,91.09 arc(37.74,90.92) 37.44,90.86 34.8,90.86 arc(34.33,90.76) 33.93,90.5 33.57,90.14 arc(33.31,89.96) 33.01,89.9 9.17,89.9 arc(8.78,89.83) 8.45,89.61 6.74,87.89 arc(6.52,87.56) 6.44,87.17 6.44,61.05 arc(6.53,60.58) 6.8,60.18 9,57.98 arc(9.17,57.72) 9.23,57.42 9.23,56.36 arc(9.21,56.26) 9.16,56.17 9.12,56.13 arc(9.08,56.11) 9.03,56.1 8.92,56.1 arc(8.81,56.12) 8.72,56.18 arc(8.66,56.27) 8.64,56.38 v1(8.64,56.57)
  BOTTOM w0.102: AMC1.141 4.47,56.21 arc(4.56,56.19) 4.64,56.14 4.67,56.11 arc(4.79,56.03) 4.92,56.01 7.11,56.01 arc(7.18,56.02) 7.24,56.06 arc(7.46,56.21) 7.72,56.26 8.25,56.26 arc(8.4,56.29) 8.52,56.38 8.61,56.46 arc(8.63,56.49) 8.64,56.53 v1(8.64,56.57) ; v1(45.06,89.41) 44.72,89.07 arc(44.65,88.97) 44.63,88.85 arc(44.64,88.78) 44.68,88.72 arc(44.74,88.68) 44.81,88.67 45.53,88.67 arc(45.73,88.71) 45.89,88.82 45.91,88.83 arc(46.07,88.94) 46.27,88.98 46.49,88.98 arc(46.6,89.01) 46.7,89.07 arc(46.77,89.17) 46.79,89.29 C568.2
AMCC_P17_AIF4_RXP: length 83.5
  L10 w0.089: v1(8.64,55.55) 8.64,55.6 arc(8.65,55.65) 8.67,55.69 8.75,55.77 arc(8.88,55.85) 9.03,55.88 9.03,55.88 arc(9.16,55.91) 9.27,55.98 9.31,56.02 arc(9.41,56.17) 9.45,56.36 9.45,57.42 arc(9.37,57.8) 9.15,58.13 6.95,60.33 arc(6.73,60.66) 6.65,61.05 6.65,87.17 arc(6.72,87.48) 6.89,87.74 8.61,89.45 arc(8.87,89.63) 9.17,89.69 33.01,89.69 arc(33.39,89.76) 33.72,89.99 34.08,90.34 arc(34.41,90.56) 34.8,90.64 37.44,90.64 arc(37.83,90.72) 38.16,90.94 38.49,91.27 arc(38.82,91.49) 39.21,91.57 41.46,91.57 arc(41.85,91.49) 42.18,91.27 43.14,90.32 arc(43.47,90.1) 43.85,90.02 44.13,90.02 arc(44.26,89.99) 44.37,89.92 arc(44.45,89.8) 44.48,89.67 44.48,89.58 arc(44.46,89.52) 44.42,89.46 arc(44.37,89.42) 44.3,89.41 v1(44.04,89.41)
  BOTTOM w0.102: AMC1.142 4.38,55.46 arc(4.57,55.5) 4.73,55.61 arc(4.89,55.71) 5.08,55.75 7.11,55.75 arc(7.28,55.79) 7.42,55.88 arc(7.56,55.97) 7.72,56.01 8.1,56.01 arc(8.29,55.97) 8.45,55.86 8.59,55.72 arc(8.62,55.67) 8.64,55.61 v1(8.64,55.55) ; C579.2 46.79,88.49 arc(46.78,88.58) 46.72,88.66 arc(46.65,88.71) 46.56,88.73 46.27,88.73 arc(46.17,88.71) 46.09,88.65 46.07,88.64 arc(45.82,88.47) 45.53,88.41 44.81,88.41 arc(44.64,88.45) 44.5,88.54 arc(44.41,88.68) 44.37,88.85 arc(44.37,88.91) 44.37,88.98 arc(44.3,89.26) v1(44.04,89.41)
AMCC_P17_AIF4_TXN: length 97.1
  TOP w0.102: U24.AR13 57.19,89.42 57.02,89.59 v2(57.02,89.79)
  L10 w0.089: v1(10.05,57.51) 10.24,57.51 arc(10.42,57.59) 10.5,57.76 10.5,58.03 arc(10.58,58.47) 10.83,58.84 10.9,58.91 arc(11.01,59.06) 11.04,59.24 11.04,59.52 arc(10.98,59.82) 10.81,60.08 9.82,61.07 arc(9.68,61.17) 9.51,61.2 9.23,61.2 arc(8.76,61.29) 8.36,61.56 7.61,62.31 arc(7.35,62.71) 7.25,63.18 7.25,85.08 arc(7.46,86.13) 8.06,87.03 9.31,88.28 arc(10.21,88.88) 11.26,89.09 17.45,89.09 arc(17.84,89.01) 18.17,88.79 18.77,88.19 arc(18.85,88.13) 18.95,88.11 24.89,88.11 arc(25.27,88.18) 25.6,88.39 arc(25.95,88.6) 26.34,88.67 34.73,88.67 arc(35.12,88.75) 35.45,88.97 36.1,89.62 arc(36.43,89.84) 36.82,89.91 41.87,89.91 arc(42.26,89.84) 42.59,89.62 43.86,88.35 arc(44.19,88.13) 44.58,88.05 47.19,88.05 arc(47.58,87.97) 47.91,87.75 48.84,86.82 arc(49.17,86.6) 49.56,86.53 50.53,86.53 arc(50.84,86.59) 51.1,86.76 52.5,88.16 arc(52.9,88.43) 53.37,88.52 56.3,88.52 arc(56.31,88.52) 56.32,88.53 56.39,88.6 arc(56.4,88.61) 56.4,88.62 56.4,89.13 arc(56.5,89.37) 56.74,89.47 arc(56.95,89.57) v2(57.02,89.79)
  BOTTOM w0.102: AMC1.144 4.47,53.96 arc(4.63,53.93) 4.76,53.84 arc(4.89,53.75) 5.05,53.72 6.32,53.72 arc(6.59,53.67) 6.81,53.52 arc(6.87,53.48) 6.94,53.46 9.08,53.46 arc(9.25,53.5) 9.39,53.59 arc(9.49,53.74) 9.53,53.91 9.53,54.33 arc(9.52,54.35) 9.51,54.37 arc(9.39,54.55) 9.35,54.76 9.35,55.62 arc(9.4,55.91) 9.57,56.16 10.35,56.94 arc(10.4,57.03) 10.41,57.13 arc(10.3,57.38) v1(10.05,57.51)
AMCC_P17_AIF4_TXP: length 97.1
  TOP w0.102: v2(57.02,88.92) 57.15,88.92 57.52,88.56 U24.AR14
  L10 w0.089: v1(11.06,57.51) 11.04,57.51 10.78,57.78 arc(10.73,57.85) 10.71,57.94 10.71,58.03 10.71,58.03 arc(10.78,58.38) 10.98,58.68 11.06,58.76 arc(11.2,58.98) 11.26,59.24 11.26,59.52 arc(11.18,59.91) 10.96,60.24 9.97,61.22 arc(9.76,61.37) 9.51,61.42 9.23,61.42 arc(8.85,61.49) 8.52,61.71 7.77,62.47 arc(7.55,62.8) 7.47,63.18 7.47,85.08 arc(7.66,86.05) 8.21,86.88 9.47,88.13 arc(10.29,88.68) 11.26,88.87 17.45,88.87 arc(17.75,88.81) 18.01,88.64 18.62,88.03 arc(18.77,87.93) 18.95,87.9 24.89,87.9 arc(25.35,87.98) 25.75,88.23 arc(26.02,88.4) 26.34,88.46 arc(26.43,88.45) 26.52,88.46 34.73,88.46 arc(35.2,88.55) 35.6,88.82 36.25,89.46 arc(36.51,89.64) 36.82,89.7 41.87,89.7 arc(42.18,89.64) 42.44,89.46 43.71,88.19 arc(44.11,87.93) 44.58,87.83 47.19,87.83 arc(47.5,87.77) 47.76,87.6 48.68,86.67 arc(49.08,86.4) 49.56,86.31 50.53,86.31 arc(50.92,86.39) 51.25,86.61 52.65,88.01 arc(52.98,88.23) 53.37,88.3 56.3,88.3 arc(56.39,88.32) 56.48,88.38 56.54,88.44 arc(56.6,88.53) 56.62,88.62 56.62,89.13 arc(56.65,89.22) 56.74,89.26 arc(56.96,89.15) v2(57.02,88.92)
  BOTTOM w0.102: AMC1.145 4.42,53.21 arc(4.58,53.24) 4.72,53.34 arc(4.86,53.43) 5.03,53.46 6.32,53.46 arc(6.49,53.43) 6.63,53.34 arc(6.77,53.24) 6.94,53.21 9.08,53.21 arc(9.35,53.26) 9.57,53.41 arc(9.73,53.64) 9.78,53.91 9.78,54.33 arc(9.76,54.45) 9.69,54.55 arc(9.62,54.65) 9.6,54.76 9.6,55.62 arc(9.64,55.82) 9.75,55.98 10.53,56.76 arc(10.64,56.94) 10.67,57.15 arc(10.78,57.43) v1(11.06,57.51)
AMCC_P18_AIF5_RXN: length 96.7
  L10 w0.089: v1(40.41,94.23) 40.12,94.23 arc(40.06,94.22) 40.01,94.19 39.99,94.17 arc(39.97,94.14) 39.97,94.11 39.97,94.08 39.97,94.06 arc(39.97,94.04) 39.97,94.02 39.97,93.61 arc(39.95,93.52) 39.89,93.44 39.75,93.29 arc(39.67,93.24) 39.57,93.22 39.02,93.22 arc(38.71,93.16) 38.45,92.98 37.41,91.94 arc(37.01,91.67) 36.54,91.58 34.2,91.58 arc(33.9,91.52) 33.64,91.35 33.15,90.86 arc(32.75,90.59) 32.28,90.5 15.36,90.5 arc(15.1,90.55) 14.87,90.7 arc(14.79,90.76) 14.7,90.77 8.16,90.77 arc(7.77,90.7) 7.44,90.48 6.14,89.17 arc(5.92,88.84) 5.84,88.45 5.84,55.45 arc(5.86,55.35) 5.92,55.27 7.65,53.54 arc(7.73,53.49) 7.83,53.47 9.9,53.47 arc(10,53.49) 10.08,53.54 10.59,54.05 arc(10.65,54.14) 10.67,54.23 10.67,54.38 arc(10.65,54.48) 10.59,54.56 10.27,54.88 arc(10.25,54.9) v1(10.22,54.9)
  BOTTOM w0.102: AMC1.147 4.39,51.71 arc(4.59,51.67) 4.75,51.56 4.81,51.5 arc(4.98,51.39) 5.17,51.35 6.15,51.35 arc(6.35,51.39) 6.51,51.5 6.63,51.62 arc(6.96,51.84) 7.35,51.92 8.93,51.92 arc(8.95,51.92) 8.97,51.92 8.97,51.92 arc(9.13,51.96) 9.27,52.05 arc(9.28,52.06) 9.29,52.06 10.47,53.25 arc(10.64,53.5) 10.69,53.79 10.69,54.43 arc(10.55,54.76) v1(10.22,54.9) ; C219.2 46.98,92.33 arc(47.11,92.27) 47.17,92.14 47.17,91.95 arc(47.06,91.68) 46.79,91.57 46.49,91.57 arc(46.46,91.57) 46.43,91.57 arc(46.22,91.63) 46.04,91.76 arc(45.83,91.9) 45.58,91.95 43.98,91.95 arc(43.69,92.01) 43.44,92.17 42.23,93.38 arc(41.99,93.54) 41.7,93.6 40.39,93.6 arc(40.23,93.63) 40.1,93.72 39.98,93.84 39.98,94.13 40.08,94.23 v1(40.41,94.23)
AMCC_P18_AIF5_RXP: length 96.8
  L10 w0.089: v1(11.23,54.9) 11.2,54.9 arc(11.13,54.89) 11.07,54.84 10.94,54.67 arc(10.9,54.59) 10.88,54.51 10.88,54.23 arc(10.85,54.05) 10.75,53.9 10.23,53.39 arc(10.08,53.29) 9.9,53.25 7.83,53.25 arc(7.65,53.29) 7.49,53.39 5.76,55.12 arc(5.66,55.27) 5.63,55.45 5.63,88.45 arc(5.72,88.93) 5.99,89.33 7.29,90.63 arc(7.69,90.9) 8.16,90.99 14.7,90.99 arc(14.87,90.95) 15.03,90.85 arc(15.18,90.75) 15.36,90.72 32.28,90.72 arc(32.67,90.79) 33,91.01 33.48,91.5 arc(33.81,91.72) 34.2,91.8 36.54,91.8 arc(36.93,91.87) 37.25,92.09 38.3,93.14 arc(38.63,93.36) 39.02,93.43 39.57,93.43 arc(39.58,93.44) 39.6,93.45 39.74,93.59 arc(39.75,93.6) 39.75,93.62 39.75,94.02 arc(39.73,94.1) 39.69,94.17 arc(39.62,94.22) 39.53,94.23 v1(39.4,94.23)
  BOTTOM w0.102: v1(39.4,94.23) 39.61,94.23 39.73,94.12 39.73,93.77 arc(39.73,93.74) 39.76,93.7 39.92,93.54 arc(40.13,93.4) 40.39,93.34 41.7,93.34 arc(41.89,93.31) 42.06,93.2 43.26,91.99 arc(43.59,91.77) 43.98,91.69 45.58,91.69 arc(45.73,91.66) 45.86,91.58 arc(46.11,91.4) 46.4,91.32 arc(46.67,91.2) C224.2 ; AMC1.148 4.53,50.96 arc(4.62,50.98) 4.69,51.03 arc(4.77,51.08) 4.85,51.1 6.15,51.1 arc(6.44,51.15) 6.69,51.32 6.81,51.44 arc(7.06,51.6) 7.35,51.66 8.93,51.66 arc(8.96,51.66) 8.99,51.66 arc(9.23,51.73) 9.44,51.86 arc(9.46,51.87) 9.47,51.88 10.72,53.14 arc(10.89,53.39) 10.95,53.68 10.95,54.62 arc(11.03,54.82) v1(11.23,54.9)
AMCC_P18_AIF5_TXN: length 107.2
  TOP w0.102: v2(56.01,89.81) 56.52,90.32 U24.AT12
  L10 w0.089: v2(56.01,89.81) 56.01,89.71 arc(55.99,89.64) 55.96,89.59 arc(55.9,89.55) 55.83,89.53 52.68,89.53 arc(52.3,89.61) 51.99,89.82 arc(51.98,89.83) 51.96,89.84 arc(51.89,89.9) 51.82,89.96 arc(51.57,90.07) 51.3,90.11 48.24,90.11 arc(47.85,90.18) 47.52,90.4 46.2,91.73 arc(45.87,91.95) 45.48,92.02 44.53,92.02 arc(44.22,92.09) 43.96,92.26 41.44,94.78 arc(41.04,95.05) 40.57,95.14 39.19,95.14 arc(38.72,95.05) 38.32,94.78 36.62,93.08 arc(36.36,92.91) 36.05,92.85 33.97,92.85 arc(33.5,92.76) 33.1,92.49 32.38,91.76 arc(32.12,91.59) 31.81,91.53 26.31,91.53 26.31,91.53 26.16,91.53 arc(26.03,91.56) 25.92,91.63 24.96,92.59 arc(24.63,92.81) 24.24,92.89 22.45,92.89 arc(22.01,92.8) 21.63,92.55 arc(21.4,92.4) 21.13,92.34 14.76,92.34 arc(14.37,92.42) 14.04,92.64 14.01,92.67 arc(13.68,92.89) 13.3,92.96 8.54,92.96 arc(8.06,92.87) 7.66,92.6 5.17,90.11 arc(4.91,89.71) 4.81,89.24 4.81,55.16 arc(4.91,54.69) 5.17,54.29 7.39,52.07 arc(7.79,51.81) 8.26,51.71 8.75,51.71 arc(9.14,51.64) 9.47,51.42 9.58,51.3 arc(9.8,50.97) 9.88,50.58 9.88,50.37 arc(9.75,49.97) 9.39,49.72 8.98,49.72 arc(8.88,49.74) 8.8,49.8 8.6,50 arc(8.58,50.03) 8.57,50.07 arc(8.57,50.08) 8.57,50.09 v1(8.53,50.16)
  BOTTOM w0.102: v1(8.53,50.16) 8.53,50.09 arc(8.52,50.02) 8.48,49.96 8.39,49.87 arc(8.23,49.76) 8.04,49.72 7.95,49.72 arc(7.81,49.71) 7.67,49.67 arc(7.48,49.59) 7.32,49.46 7.18,49.32 arc(7.02,49.21) 6.82,49.17 4.98,49.17 arc(4.79,49.21) 4.63,49.32 arc(4.47,49.42) 4.29,49.46 AMC1.150
AMCC_P18_AIF5_TXP: length 107.1
  TOP w0.102: U24.AT13 56.3,89.42 56.03,89.15 v2(56.03,88.92)
  L10 w0.089: v2(56.03,88.92) 56.03,89 arc(56,89.12) 55.93,89.23 arc(55.83,89.3) 55.71,89.32 52.68,89.32 arc(52.22,89.41) 51.83,89.67 arc(51.83,89.68) 51.82,89.69 arc(51.76,89.73) 51.7,89.77 arc(51.51,89.86) 51.3,89.89 48.24,89.89 arc(47.76,89.98) 47.36,90.25 46.04,91.57 arc(45.78,91.75) 45.48,91.81 44.53,91.81 arc(44.14,91.89) 43.81,92.11 41.29,94.63 arc(40.96,94.85) 40.57,94.93 39.19,94.93 arc(38.8,94.85) 38.47,94.63 36.77,92.93 arc(36.44,92.71) 36.05,92.63 33.97,92.63 arc(33.59,92.56) 33.26,92.34 32.53,91.61 arc(32.2,91.39) 31.81,91.31 26.22,91.31 26.16,91.31 arc(25.95,91.36) 25.77,91.48 24.81,92.44 arc(24.55,92.61) 24.24,92.67 22.45,92.67 arc(22.09,92.6) 21.79,92.4 arc(21.48,92.2) 21.13,92.13 14.76,92.13 arc(14.29,92.22) 13.89,92.49 13.86,92.51 arc(13.6,92.69) 13.3,92.75 8.54,92.75 arc(8.15,92.67) 7.82,92.45 5.33,89.96 arc(5.11,89.63) 5.03,89.24 5.03,55.16 arc(5.11,54.77) 5.33,54.44 7.54,52.23 arc(7.87,52.01) 8.26,51.93 8.75,51.93 arc(9.22,51.84) 9.62,51.57 9.74,51.45 arc(10,51.05) 10.1,50.58 10.1,50.37 arc(9.91,49.82) 9.42,49.51 8.92,49.51 arc(8.82,49.49) 8.74,49.43 8.59,49.28 arc(8.55,49.22) v1(8.53,49.15)
  BOTTOM w0.102: AMC1.151 4.37,48.71 arc(4.5,48.74) 4.62,48.82 arc(4.74,48.89) 4.87,48.92 6.82,48.92 arc(7.11,48.98) 7.36,49.14 7.5,49.28 arc(7.61,49.37) 7.75,49.43 arc(7.85,49.46) 7.95,49.47 8.19,49.47 arc(8.32,49.44) 8.43,49.36 8.49,49.3 arc(8.52,49.26) 8.53,49.21 v1(8.53,49.15)
ARM0_VCL_R: length 56.6
  TOP w0.102: 51.82,65.24 52.07,65.49 52.07,65.56 53.31,66.8 55.68,66.8 56.08,66.4 56.08,65.86 U24.AT37
  TOP w0.127: CN19.3 27.67,34.16 v1(28.05,34.54) ; 51.82,65.24 48.75,62.17 47.7,62.17 v1(47.24,62.62)
  L8 w0.114: v1(47.24,62.62) 46.95,62.33 41.21,62.33 40.68,61.79 36.67,61.79 33.5,58.62 33.5,52.89 27.39,46.78 27.39,35.21 v1(28.05,34.54)
ARM0_VD_R: length 54.2
  TOP w0.102: 51.82,65.6 53.25,67.03 56.12,67.03 U24.AT35
  TOP w0.127: v1(28.07,35.43) 28.42,35.08 CN19.4 ; v1(47.88,62.62) 47.88,62.61 48.07,62.42 48.64,62.42 51.82,65.6
  L8 w0.114: v1(28.07,35.43) 27.63,35.87 27.63,46.68 34.75,53.8 34.75,59.52 35.05,59.82 36.77,61.55 40.78,61.55 41.31,62.08 47.34,62.08 v1(47.88,62.62)
ARM_CLKN: length 108.2
  TOP w0.102: v1(87.34,123.56) 87.41,123.56 87.71,123.27 87.71,122.78 87.62,122.7 U19.21
  L10 w0.089: v1(87.34,123.56) 87.46,123.56 87.62,123.41 87.62,123.38 87.69,123.31 87.69,122.95 87.48,122.73 84.35,122.73 82.52,120.9 82.52,119.37 82.17,119.02 82.17,117.2 81.57,116.6 80.94,116.6 80.4,116.07 80.4,114.88 79.26,113.74 77.66,113.74 75.74,111.82 75.12,111.82 74.55,112.4 71.83,112.4 70.68,111.25 70.68,104.24 70.41,103.96 70.41,95.66 70.75,95.31 80.35,95.31 81.39,94.27 81.39,84.8 81.39,84.8 81.39,84.77 81.14,84.51 80.77,84.51 80.44,84.18 80.44,82.32 80.53,82.23 80.53,81.66 80.43,81.56 80.43,79.69 80.25,79.51 79.72,79.51 79.39,79.19 79.39,77.15 79.44,77.09 79.44,76.71 79.39,76.66 79.39,73.71 79.79,73.31 82.16,73.31 82.42,73.05 82.42,62.53 83.19,61.77 88.53,61.77 91.15,59.16 91.15,58.24 91.07,58.17 v1(90.81,58.17)
  BOTTOM w0.102: v1(90.81,58.17) 91.26,57.71 91.26,56.04 90.62,55.39 88.86,55.39 88.77,55.48 88.77,55.88 88.83,55.94 C725.1
ARM_CLKP: length 108.2
  TOP w0.102: U19.20 88.12,122.67 87.96,122.83 87.96,123.48 v1(88.04,123.56)
  L10 w0.089: v1(88.04,123.56) 87.91,123.43 87.91,122.86 87.57,122.52 84.44,122.52 82.73,120.81 82.73,119.28 82.38,118.93 82.38,117.11 81.66,116.38 81.03,116.38 80.62,115.98 80.62,114.79 79.35,113.53 77.75,113.53 75.83,111.61 75.03,111.61 74.46,112.18 71.92,112.18 70.9,111.16 70.9,104.15 70.62,103.87 70.62,95.75 70.84,95.53 80.44,95.53 81.61,94.36 81.61,84.68 81.23,84.3 80.86,84.3 80.66,84.09 80.66,82.41 80.75,82.32 80.75,81.57 80.64,81.47 80.64,79.6 80.34,79.3 79.81,79.3 79.61,79.1 79.61,77.24 79.66,77.18 79.66,76.62 79.61,76.57 79.61,73.8 79.88,73.53 82.25,73.53 82.64,73.14 82.64,62.62 83.27,61.99 88.62,61.99 91.36,59.25 91.36,58.37 v1(91.57,58.17)
  BOTTOM w0.102: v1(91.57,58.17) 91.52,58.12 91.52,55.93 90.72,55.14 88.75,55.14 88.52,55.37 88.52,55.83 88.41,55.94 C726.1
ARM_UCD9244_VID2A: length 227.5
  TOP w0.127: v1(110.36,118.36) 110.36,118.47 109.89,118.95 U16.20 ; R446.1 27.87,42.93 v1(28.07,42.93) 28.19,42.93 28.45,42.67 29.08,42.67 29.77,43.36 U35.4
  L8 w0.114: v1(110.36,118.36) 110.8,117.93 111.54,117.93 111.73,118.12 114.69,118.12 115.25,118.68 116.92,118.68 117.17,118.42 120.96,118.42 122.71,116.67 124.87,116.67 131.29,110.26 131.29,84.18 133.92,81.55 133.92,51.52 136.8,48.65 136.8,46.12 133.22,42.55 130.56,42.55 129.16,41.15 123.75,41.15 123.5,40.9 117.99,40.9 115.41,43.48 112.24,43.48 110.84,42.08 110.84,35.34 107.79,32.29 107.79,32.29 31.97,32.29 29.84,34.42 29.84,36 31.01,37.16 31.01,40.11 28.73,42.39 28.6,42.39 v1(28.07,42.93)
ARM_UCD9244_VID2B: length 228.7
  TOP w0.127: v1(29.84,39.8) 29.11,40.54 29.11,41.4 28.45,42.06 R447.1 29.14,42.11 30.09,43.05 30.1,43.05 30.42,43.38 U35.5 ; v1(111.35,118.36) 110.89,118.83 U16.22
  L8 w0.114: v1(111.35,118.36) 114.49,118.36 115.04,118.92 117.1,118.92 117.34,118.68 121.05,118.68 122.81,116.92 128.89,116.92 131.53,114.27 131.53,84.28 134.16,81.65 134.16,51.85 137.04,48.97 137.04,45.98 133.35,42.29 130.68,42.29 129.34,40.95 129.34,40.2 129.09,39.95 123.96,39.95 123.25,40.66 117.89,40.66 115.31,43.24 112.34,43.24 111.16,42.07 111.16,35.33 107.96,32.12 107.89,32.05 31.83,32.05 29.59,34.29 29.59,36.09 30.77,37.26 30.77,38.89 30.05,39.6 30.04,39.6 v1(29.84,39.8)
ARM_UCD9244_VID2C: length 225.6
  TOP w0.127: v1(114.5,119) 114.39,119.11 U16.29 ; U35.6 31.07,43.49 29.84,42.27 R448.1 30.26,42.11 30.45,41.91 30.45,39.75 v1(29.87,39.17)
  L8 w0.114: v1(29.87,39.17) 30.52,38.51 30.52,37.36 29.31,36.15 29.31,34.19 31.69,31.81 107.99,31.81 108.13,31.95 111.4,35.22 111.4,41.97 112.44,43 115.2,43 117.78,40.42 123.01,40.42 123.72,39.71 129.19,39.71 129.58,40.1 129.58,40.81 130.82,42.05 133.45,42.05 137.28,45.88 137.28,49.07 134.4,51.95 134.4,81.75 131.78,84.38 131.78,114.37 128.9,117.25 122.82,117.25 120.32,119.75 115.25,119.75 v1(114.5,119)
ARM_UCD9244_VID2S: length 227.2
  TOP w0.127: v1(31.9,41.58) 31.38,42.11 R449.1 31.24,42.88 31.72,43.36 U35.7 ; v1(106.37,121.54) 106.54,121.71 U16.14
  L8 w0.114: v1(31.9,41.58) 31.97,41.51 31.97,40.28 31.49,39.8 31.49,36.96 30.33,35.8 30.33,34.62 32.17,32.77 107.59,32.77 110.29,35.48 110.29,43.44 110.97,44.13 115.45,44.13 118.19,41.38 123.09,41.38 123.44,41.73 128.98,41.73 131.06,43.81 133.73,43.81 135.31,45.4 135.31,48.86 133.4,50.77 133.4,68.91 131.11,71.2 131.11,82.63 130.71,83.03 130.71,110.16 125.14,115.73 124.75,116.12 122.48,116.12 121.13,117.47 111.76,117.47 111.74,117.44 110.17,117.44 109.43,118.18 108.71,118.18 108.13,118.76 108.13,120.85 107.44,121.54 v1(106.37,121.54)
ARM_VIDA: length 38.3
  TOP w0.102: U24.AU37 v2(55.02,65.92)
  TOP w0.127: R411.1 27.94,51.62 v1(28.65,51.62) 28.65,51.62 29.16,51.62 29.77,51 U35.13
  L3 w0.114: v2(55.02,65.92) 54.8,65.71 54.8,65 54.22,64.41 53.04,64.41 49.14,60.52 44.13,60.52 40.3,56.68 38.83,56.68 38.11,55.96 38.11,54.34 36.1,52.32 29.36,52.32 v1(28.65,51.62)
ARM_VIDB: length 37.6
  TOP w0.102: U24.AV36 54.49,66.42 v2(53.99,65.92)
  TOP w0.127: U35.12 30.42,50.99 30.27,51.14 30.26,51.14 29.34,52.07 28.89,52.07 R412.1 28.45,52.7 28.7,52.96 v1(29.08,52.96)
  L3 w0.114: v2(53.99,65.92) 54.36,65.55 54.36,64.86 54.14,64.64 52.92,64.64 49.04,60.76 44.03,60.76 40.2,56.92 38.73,56.92 37.87,56.06 37.87,54.44 36.01,52.58 29.46,52.58 v1(29.08,52.96)
ARM_VIDC: length 38.6
  TOP w0.102: U24.AU35 55.74,67.42 56.13,67.82 v2(56.13,67.92)
  TOP w0.127: U35.11 31.07,51.22 30.61,51.69 v1(30.35,51.69) 29.84,52.2 R413.1
  L3 w0.114: v1(30.35,51.69) 30.75,52.08 36.28,52.08 38.35,54.16 38.35,55.86 38.93,56.44 40.44,56.44 44.27,60.27 49.28,60.27 52.53,63.53 54.17,63.53 55.02,64.38 55.02,65.18 55.63,65.79 55.63,67.42 v2(56.13,67.92)
ARM_VIDS: length 33.8
  TOP w0.102: v2(52.96,65.91) 53.47,66.42 U24.AW36
  TOP w0.127: U35.10 31.72,52.03 R414.1 30.73,53.02 v1(30.48,53.02)
  L3 w0.114: v1(30.48,53.02) 36.11,53.02 37.63,54.54 37.63,57.74 44.12,64.24 50.1,64.24 51.39,65.52 52.57,65.52 v2(52.96,65.91)
ARMCLKN_C: length 9.8
  TOP w0.102: U24.B37 90.52,65.26 90.81,64.97 v2(90.84,64.97)
  BOTTOM w0.102: C725.2 88.84,57.41 88.84,62.55 90.5,64.21 90.5,64.62 v2(90.84,64.97)
ARMCLKP_C: length 9.8
  TOP w0.102: v2(90.02,64.92) 90.02,64.92 U24.C37
  BOTTOM w0.102: C726.2 88.58,57.41 88.58,62.65 90.24,64.31 90.24,64.7 v2(90.02,64.92)
AT_CLKN: length 29.4
  TOP w0.102: v1(66.93,109.73) 66.7,109.5 66.7,109.22 66.76,109.16 C177.2 ; v1(57.86,129.41) 57.86,129.51 57.73,129.64 57.12,129.64 56.99,129.51 U14.16
  L3 w0.089: v1(57.86,129.41) 57.86,129.46 57.62,129.71 57.27,129.71 56.93,129.37 56.93,127.14 59.27,124.8 60.54,124.8 61.26,124.08 61.64,124.08 61.93,123.79 61.93,123.38 62.19,123.13 62.19,115.13 65.43,111.89 66.29,111.89 66.84,111.34 66.84,110.25 66.68,110.09 66.68,109.97 v1(66.93,109.73)
AT_CLKN_C: length 10.7
  TOP w0.102: U24.AL1 61.25,101.42 61.14,101.52 61.14,103.31 63.49,105.66 64.97,105.66 66.76,107.45 66.76,107.96 67.06,108.26 C177.1
AT_CLKP: length 29.4
  TOP w0.102: U14.17 57.06,130.01 57.18,129.9 57.68,129.9 v1(57.86,130.07) ; v1(66.29,109.7) 66.45,109.55 66.45,109.27 66.34,109.16 C176.2
  L3 w0.089: v1(57.86,130.07) 57.71,129.92 57.18,129.92 56.72,129.46 56.72,127.05 59.18,124.59 60.45,124.59 61.18,123.86 61.55,123.86 61.72,123.7 61.72,123.29 61.98,123.04 61.98,115.04 65.34,111.67 66.2,111.67 66.62,111.25 66.62,110.34 66.47,110.18 66.47,109.88 v1(66.29,109.7)
AT_CLKP_C: length 10.7
  TOP w0.102: U24.AM1 60.79,101.42 60.89,101.52 60.89,103.42 63.39,105.92 64.87,105.92 66.51,107.56 66.51,107.86 66.11,108.26 C176.1
AVID_OEZ: length 239.4
  TOP w0.127: v1(136.53,115.06) 136.53,116.59 137.49,117.55 R263.1 ; U35.14 29.12,49.4 29,49.28 28.57,49.28 28.47,49.38 U35.15 28.47,50.99 28.18,51.28 27.46,51.28 26.29,52.45 26.29,54.58 27.28,55.57 R406.1 28.52,55.57 29.01,56.06 v1(29.01,56.24)
  L8 w0.114: v1(136.53,115.06) 134.11,112.65 134.11,84.22 135.99,82.34 135.99,53.76 137.63,52.11 137.63,51.27 139.16,49.74 139.16,34.11 135.89,30.84 29.99,30.84 24.47,36.37 24.47,45.25 28.02,48.8 28.02,55.25 v1(29.01,56.24)
BD_ID0: length 84.5
  TOP w0.127: v1(30.29,159.14) 30.29,159.14 30.29,158.68 31.27,157.7 CN3.104
  L3 w0.114: v1(98.12,150.75) 97.97,150.75 97.65,151.06 95.82,151.06 93.56,153.32 93.56,154.34 82.65,165.25 37.95,165.25 31.84,159.14 v1(30.29,159.14)
  BOTTOM w0.127: v1(98.12,150.75) 98.26,150.89 U50.4
BD_ID1: length 86.3
  TOP w0.127: v1(29.69,160.2) 30.13,159.76 30.3,159.76 30.73,159.33 30.73,158.95 31.48,158.2 CN3.106
  L3 w0.114: v1(29.69,160.2) 30.08,159.81 32.16,159.81 37.85,165.49 83.91,165.49 93.8,155.6 93.8,153.42 95.65,151.57 v1(97.66,151.57)
  BOTTOM w0.127: U50.5 97.72,151.54 97.69,151.57 v1(97.66,151.57)
BD_ID2: length 85.2
  TOP w0.127: CN3.108 31.48,158.7 30.99,159.2 30.99,159.61 v1(30.35,160.25)
  L3 w0.114: v1(30.35,160.25) 31.92,160.25 34.72,163.05 34.72,164.41 36.04,165.74 84.01,165.74 94.08,155.67 94.08,153.76 v1(95.44,152.4)
  BOTTOM w0.127: v1(95.44,152.4) 95.68,152.64 98.56,152.64 99.02,152.19 U50.6
BD_PRESENT: length 86.3
  TOP w0.127: CN3.102 31.26,157.2 29.97,158.5 29.97,158.81 v1(29.65,159.13)
  L3 w0.114: v1(29.65,159.13) 30.08,158.71 31.74,158.71 38.01,164.97 82.22,164.97 93.32,153.87 93.32,153.22 95.92,150.62 v1(97.47,150.62)
  BOTTOM w0.127: U50.3 101.79,150.24 101.45,149.9 98.2,149.9 v1(97.47,150.62)
BPCAP: length 5
  TOP w0.254: C86.2 C85.1 125.22,131.24 126.64,129.82 126.85,129.82 127.16,129.5 U13.35
BSC_JTAG_SRSTN: length 132.9
  TOP w0.127: R513.1 v1(165.74,36.83) ; v1(167.44,152.04) R52.1
  L8 w0.114: v1(165.74,36.83) 163.7,38.87 163.7,42.42 154.71,51.42 154.71,67.1 153.09,68.72 153.09,72.22 152.55,72.75 152.55,82.65 154.15,84.24 154.15,110.75 153.28,111.62 153.28,117.11 154.05,117.88 154.05,121.64 156.51,124.1 156.51,131.34 156.37,131.49 156.37,137.06 156.88,137.58 157.95,137.58 159.24,138.86 160.83,138.86 163.45,141.48 163.45,144.27 164.26,145.09 167.56,145.09 167.89,145.41 167.89,150.5 167.44,150.95 v1(167.44,152.04)
BSC_JTAG_TCK: length 139.2
  TOP w0.127: v1(165.74,41.66) 165.17,41.08 R491.1 ; C828.1 168.71,156.21 167.77,156.21 167.39,156.59 U4.2 167.39,157.87 167.77,158.24 v1(168.38,158.24)
  L8 w0.114: v1(165.74,41.66) 165.5,41.66 155.44,51.72 155.44,67.54 154.34,68.63 154.34,78.1 155.69,79.45 155.69,100.28 157.72,102.31 157.72,107.06 158.81,108.15 158.81,119.55 159.84,120.57 159.84,130.19 157.11,132.92 157.11,134.91 158.74,136.54 159.56,136.54 160.3,137.27 161.57,137.27 164.17,139.88 164.17,143.97 164.56,144.36 167.86,144.36 169.39,145.89 169.39,151.09 168.38,152.1 v1(168.38,158.24)
BSC_JTAG_TDI: length 133.8
  TOP w0.127: R506.1 v1(165.74,38.23) ; v1(166.9,153.21) 166.74,153.21 R45.1
  L8 w0.114: v1(165.74,38.23) 163.94,40.02 163.94,42.52 154.95,51.52 154.95,67.2 153.33,68.82 153.33,72.32 152.79,72.85 152.79,82.55 154.39,84.14 154.39,110.85 153.52,111.72 153.52,117.01 154.29,117.78 154.29,121.54 156.76,124 156.76,131.44 156.61,131.59 156.61,136.96 156.98,137.33 158.05,137.33 158.48,137.76 160.08,137.76 163.69,141.38 163.69,144.17 164.36,144.84 167.66,144.84 168.91,146.09 168.91,147.45 168.14,148.22 168.14,150.6 167.89,150.84 167.89,152.65 167.34,153.21 v1(166.9,153.21)
BSC_JTAG_TDO: length 134.7
  TOP w0.127: R493.1 v1(165.74,39.62) ; R51.1 166.42,154.18 v1(166.88,154.64)
  L8 w0.114: v1(166.88,154.64) 166.88,154.01 168.14,152.75 168.14,150.94 168.38,150.7 168.38,148.32 169.15,147.55 169.15,145.99 167.76,144.6 164.46,144.6 163.93,144.07 163.93,141.28 160.18,137.52 158.58,137.52 158.15,137.09 157.08,137.09 156.85,136.86 156.85,131.69 157,131.54 157,121.51 158.57,119.94 158.57,114.23 157.93,113.59 157.93,113.23 158.57,112.59 158.57,108.38 157.3,107.11 157.3,102.46 155.38,100.53 155.38,99.24 154.63,98.49 154.63,84.04 154.24,83.65 154.24,82.42 153.03,81.22 153.03,72.95 153.57,72.42 153.57,68.92 155.19,67.3 155.19,51.62 164.19,42.62 164.19,41.18 v1(165.74,39.62)
BSC_JTAG_TMS: length 129.1
  TOP w0.127: v1(168.81,153.54) 168.34,154.01 R46.1 ; R485.1 v1(165.74,42.42)
  L8 w0.114: v1(168.81,153.54) 168.81,152 169.63,151.19 169.63,145.62 167.27,143.26 164.8,143.26 164.41,142.88 164.41,139.78 161.67,137.03 160.4,137.03 159.66,136.3 158.88,136.3 157.35,134.77 157.35,133.02 160.17,130.2 160.17,120.42 159.05,119.3 159.05,108.05 157.96,106.96 157.96,102.21 155.93,100.18 155.93,79.35 154.58,78 154.58,68.73 155.68,67.64 155.68,51.82 165.07,42.42 v1(165.74,42.42)
CLK1_ELF: length 19.2
  TOP w0.127: U14.41 48.39,131.51 47.88,131 47.88,128.8 47.76,128.69 47.76,126.7 47.88,126.58 47.88,126.51 47.66,126.29 47.66,125.63 47.75,125.54 47.75,124.59 47.24,124.08 45.09,124.08 44.39,123.37 44.39,123.01 44.59,122.8 44.59,122.07 44.26,121.74 44.26,121.1 43.88,120.73 R221.2 R227.1 42.98,117.72 C118.1
CLK1_REF_SEL: length 79.3
  TOP w0.127: v1(50.93,122.81) 51.37,122.81 51.82,123.25 R253.2
  L10 w0.114: v1(99.14,129.03) 98.93,128.83 98.26,128.83 98.15,128.71 97.77,128.71 97.5,128.98 97.5,129.31 97.14,129.66 94.3,129.66 94.2,129.57 91.47,129.57 90.55,130.49 82.96,130.49 82.79,130.66 78.97,130.66 78.82,130.82 76.4,130.82 73.48,133.73 67.5,133.73 67.17,134.06 60.94,134.06 58.12,136.89 51.67,136.89 49.89,135.1 49.89,128.2 49.09,127.41 49.09,127.05 49.28,126.86 49.28,125.78 47.48,123.98 47.48,122.99 47.89,122.59 50.7,122.59 v1(50.93,122.81)
  BOTTOM w0.127: U53.27 98.91,125.33 98.74,125.49 98.74,128.64 v1(99.14,129.03)
CLK1_SYNC: length 2.1
  TOP w0.127: v1(48.54,130.76) 48.79,131.01 U14.42
  BOTTOM w0.127: R228.2 48.54,131.48 v1(48.54,130.76)
CLK2_ELF: length 7.1
  TOP w0.127: U15.41 67.5,130.62 67.31,130.81 67.31,132.72 66.67,133.35 C112.1 R219.2
CLK2_REF_SEL: length 53
  TOP w0.127: v1(60,127.02) 59.93,127.02 59.57,127.37 R265.2
  L10 w0.114: v1(99.19,128.22) 98.75,127.78 92.86,127.78 92.01,128.63 91.08,128.63 89.95,129.76 82.66,129.76 82.58,129.84 80,129.84 79.52,129.36 78.21,129.36 77.47,130.09 76.1,130.09 73.96,132.23 67.7,132.23 66.75,133.17 60.4,133.17 59.82,132.59 59.82,127.2 v1(60,127.02)
  BOTTOM w0.127: v1(99.19,128.22) 99.19,127.46 100.66,125.98 U53.26
CLK2_SYNC: length 2.8
  TOP w0.127: R214.2 66.69,130.99 67.08,130.61 67.08,129.13 67,129.05 U15.42
CLK3_ELF: length 5.1
  TOP w0.127: C497.1 86.82,111.7 86.82,112.57 87.22,112.97 R299.1 87.5,113.6 88.12,114.22 U19.41
