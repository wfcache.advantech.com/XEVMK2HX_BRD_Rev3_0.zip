# Allegro board 19C2830503-01-JOB.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SOC_DDR3B_EA0: length 129.4
  TOP w0.102: U24.AA32 71.44,70.42 v2(70.99,69.98) ; U41.N3 67.84,38.5 v2(68.24,38.9) ; v2(91.66,38.9) 91.64,38.9 U43.N3 ; U40.N3 56.58,38.9 v2(56.61,38.9) ; U42.N3 79.95,38.9 v2(79.98,38.9)
  TOP w0.127: v1(103.4,37.3) 103.07,37.64 R464.1 ; U39.N3 44.9,38.9 v2(44.93,38.9)
  L3 w0.102: 95.89,37.71 92.86,37.71 v2(91.66,38.9) ; 48.29,48.9 48.03,48.64 47.62,48.64 47.35,48.36 46.19,48.36 45.87,48.05 45.87,45.04 45.69,44.86 45.69,43.38 45.31,43 45.31,39.22 45,38.9 v2(44.93,38.9) ; 66.9,61.62 67.36,61.62 67.39,61.59 ; 69.91,64.27 70.4,64.76 70.4,68.67 70.6,68.87 70.6,69.58 v2(70.99,69.98)
  L3 w0.114: 69.91,64.27 69.35,64.27 67.44,62.36 66.85,62.36 66.73,62.23 66.73,61.8 66.9,61.62 ; 67.39,61.59 67.44,61.54 67.44,57.06 67.41,57.04 67.41,56.44 66.95,55.98 66.12,55.98 65.94,55.8 65.94,55.14 65.81,55.02 65.59,55.02 65.47,55.14 65.47,55.92 65.35,56.03 65.12,56.03 65.01,55.92 65.01,55.19 64.88,55.07 64.68,55.07 64.55,55.19 64.55,55.92 64.44,56.03 64.21,56.03 64.09,55.92 64.09,55.19 63.97,55.07 63.76,55.07 63.64,55.19 63.64,55.92 63.52,56.03 63.29,56.03 63.18,55.92 63.18,55.19 63.05,55.07 62.85,55.07 62.72,55.19 62.72,55.92 62.61,56.03 62.38,56.03 62.27,55.92 62.27,55.22 62.14,55.09 61.94,55.09 61.81,55.22 61.81,55.92 61.69,56.03 61.47,56.03 61.35,55.92 61.35,55.19 61.22,55.07 61.02,55.07 60.89,55.19 60.89,55.92 60.78,56.03 60.55,56.03 60.22,55.7 55.09,55.7 48.29,48.9 ; 95.89,37.71 96.51,37.08 103.19,37.08 v1(103.4,37.3)
  L8 w0.114: v2(91.66,38.9) 91.26,38.5 80.38,38.5 v2(79.98,38.9) 79.58,38.5 77.8,38.5 77.69,38.39 77.69,38.14 77.57,38.02 77.35,38.02 77.23,38.14 77.23,38.39 77.12,38.5 76.89,38.5 76.77,38.39 76.77,38.14 76.66,38.02 76.43,38.02 76.32,38.14 76.32,38.39 76.2,38.5 75.97,38.5 75.86,38.39 75.86,38.14 75.75,38.02 75.52,38.02 75.4,38.14 75.4,38.39 75.29,38.5 73.4,38.5 73.27,38.38 72.93,38.38 72.81,38.5 70.35,38.5 70.23,38.38 68.77,38.38 v2(68.24,38.9) 67.84,38.5 67.28,38.5 67.25,38.48 57.03,38.48 v2(56.61,38.9) 56.21,38.5 52.59,38.5 52.48,38.39 52.48,38.24 52.36,38.13 52.14,38.13 52.02,38.24 52.02,38.39 51.91,38.5 51.68,38.5 51.56,38.39 51.56,38.24 51.45,38.13 51.22,38.13 51.11,38.24 51.11,38.39 50.99,38.5 47.49,38.5 47.48,38.5 47.16,38.5 47.15,38.5 45.33,38.5 v2(44.93,38.9)
SOC_DDR3B_EA1: length 130.3
  TOP w0.102: U40.P7 v2(59,38.09) ; U39.P7 v2(47.31,38.09) ; v2(74.17,68.92) 74.02,68.92 73.52,69.42 U24.W33 ; U43.P7 94.27,37.7 94.05,37.92 v2(94.05,38.09) ; U42.P7 v2(82.37,38.09) ; U41.P7 v2(70.63,38.09)
  L3 w0.102: 73.03,64.24 73.03,69.33 73.14,69.44 73.42,69.44 73.53,69.33 73.53,69.04 73.69,68.88 74.13,68.88 v2(74.17,68.92) ; 49.12,39.29 48.62,39.29 48.49,39.17 48.49,38.71 48.3,38.52 47.75,38.52 v2(47.31,38.09)
  L3 w0.114: 49.12,39.29 49.33,39.5 51.53,39.5 54.25,42.21 55.42,42.21 56.18,42.98 56.18,44.4 56.64,44.86 58.75,44.86 59.77,45.87 62.2,45.87 63.3,46.96 64.52,46.96 65.66,48.11 67.79,48.11 68.02,48.34 68.02,49.3 68.42,49.7 68.58,49.7 69.21,49.07 69.39,49.07 69.53,49.21 69.53,49.39 68.9,50.02 68.9,50.18 69.07,50.35 69.23,50.35 69.83,49.75 69.99,49.75 70.15,49.91 70.15,50.07 69.55,50.67 69.55,50.83 69.71,50.99 69.87,50.99 70.59,50.27 70.77,50.27 70.92,50.42 70.92,50.6 70.2,51.32 70.2,51.48 70.36,51.64 70.52,51.64 71.44,50.72 71.62,50.72 71.77,50.86 71.77,51.04 70.84,51.96 70.84,52.12 74.7,55.98 74.7,58.71 74.03,59.38 74.03,59.74 74.04,59.75 74.04,61.76 73.94,61.86 73.94,63.32 73.03,64.24
  L8 w0.114: v1(106.43,37.47) 105.71,38.18 102.55,38.18 101.9,37.53 100.97,37.53 100.64,37.21 96.52,37.21 96.3,37.43 95.74,37.43 95.47,37.7 94.44,37.7 v2(94.05,38.09)
  L10 w0.114: v2(94.05,38.09) 92.29,38.09 91.91,37.7 89.8,37.7 89.53,37.97 86.36,37.97 86.11,37.72 84.7,37.72 84.32,38.1 83.69,38.1 83.55,38.25 83.55,38.25 83.32,38.48 82.93,38.48 82.54,38.09 v2(82.37,38.09) 81.15,38.09 80.75,37.69 77.91,37.69 77.8,37.81 77.8,38.01 77.68,38.13 77.45,38.13 77.34,38.01 77.34,37.81 77.22,37.69 77,37.69 76.88,37.81 76.88,38.01 76.77,38.13 76.54,38.13 76.42,38.01 76.42,37.81 76.31,37.69 75.8,37.69 75.51,37.97 73.91,37.97 73.66,38.23 73.51,38.38 72.93,38.38 72.83,38.48 71.26,38.48 70.88,38.09 v2(70.63,38.09) 69.79,38.09 69.37,38.5 62.25,38.5 62.23,38.48 59.56,38.48 59.17,38.09 v2(59,38.09) 58.81,38.09 58.4,38.5 57.76,38.5 57.65,38.39 57.65,38.2 57.52,38.07 57.32,38.07 57.19,38.2 57.19,38.39 57.07,38.5 55.63,38.5 55.62,38.51 55.62,38.51 55.27,38.86 50.29,38.86 49.91,38.48 47.7,38.48 v2(47.31,38.09)
  BOTTOM w0.127: R790.1 106.37,37.47 v1(106.43,37.47)
SOC_DDR3B_EA2: length 125.1
  TOP w0.102: U40.P3 56.6,38.12 v2(56.62,38.12) ; v2(91.68,38.09) 91.63,38.09 U43.P3 ; v2(79.99,38.09) 79.99,38.07 79.63,37.7 U42.P3 ; v2(68.26,38.12) 67.84,37.7 U41.P3 ; v2(74.04,69.98) 73.59,70.42 U24.W32
  TOP w0.127: v2(44.93,38.1) 44.9,38.1 U39.P3
  L3 w0.102: v2(74.04,69.98) 73.24,70.78 71.25,70.78 70.38,69.91 70.38,69.84 70.13,69.6 68.83,69.6 68.58,69.85 68.58,70.12 68.22,70.48 67,70.48 66.43,69.91 66.43,67.8 65.94,67.3 65.86,67.3 65.4,66.84 65.4,66.77 65,66.37 65,66.37 ; v2(44.93,38.1) 44.7,38.1 44.26,38.54 43.72,38.54
  L3 w0.114: 43.72,38.54 43.33,38.15 41.1,38.15 40.46,38.79 40.46,49.35 42.04,50.93 46.24,50.93 49.38,54.07 49.38,54.52 59.63,64.76 59.63,65.08 60.08,65.54 60.18,65.54 60.63,65.99 60.63,66.08 60.92,66.37 65,66.37
  L8 w0.114: v2(44.93,38.1) 45.33,37.7 51.14,37.7 51.26,37.59 51.26,37.52 51.38,37.39 51.59,37.39 51.71,37.52 51.71,37.59 51.83,37.7 52.06,37.7 52.17,37.59 52.17,37.41 52.3,37.29 52.5,37.29 52.63,37.41 52.63,37.59 52.74,37.7 56.21,37.7 v2(56.62,38.12) 57.04,37.7 61.21,37.7 61.42,37.49 65.68,37.49 65.9,37.7 67.84,37.7 v2(68.26,38.12) 68.68,37.69 69.19,37.69 69.34,37.85 70.21,37.85 70.36,37.69 72.16,37.69 72.26,37.59 73.52,37.59 73.63,37.71 73.63,38.01 73.75,38.13 73.98,38.13 74.09,38.01 74.09,37.62 74.22,37.49 74.42,37.49 74.55,37.62 74.55,37.97 74.68,38.1 74.88,38.1 75.01,37.97 75.01,37.71 75.12,37.59 78.1,37.59 78.2,37.69 79.59,37.69 v2(79.99,38.09) 80.38,37.7 91.29,37.7 v2(91.68,38.09)
  BOTTOM w0.102: v2(91.68,38.09) 93.01,38.09 93.4,37.71 95.77,37.71 95.87,37.6 96.59,37.6
  BOTTOM w0.127: R782.1 98.93,39.37 97.17,37.6 96.59,37.6
SOC_DDR3B_EA3: length 133.9
  TOP w0.102: v2(79.17,38.09) 79.16,38.09 U42.N2 ; U43.N2 90.83,38.11 v2(90.83,38.09) ; U24.Y34 v2(72.02,67.92) ; v2(55.8,38.12) 55.77,38.12 U40.N2 ; U41.N2 67.05,38.5 v2(67.44,38.12)
  TOP w0.127: R462.1 v1(106.43,38.1) ; U39.N2 44.09,38.12 v2(44.12,38.12)
  L3 w0.102: v2(44.12,38.12) 44.52,37.72 45.09,37.72 45.72,38.35 45.72,42.83 46.09,43.21 46.09,44.69 46.28,44.87 46.28,47.6 46.63,47.96 47.08,47.96 47.72,47.32 48.26,47.32 48.48,47.55 48.48,47.82 48.94,48.29 49.63,48.29 50.04,48.69 50.04,49.15 ; 69.6,63.36 70.76,64.52 71.15,64.52 71.42,64.79 71.42,68.1 71.59,68.26 71.96,68.26 72.09,68.13 72.09,67.99 v2(72.02,67.92) ; v2(90.83,38.09) 91.24,37.68 91.9,37.68 92.68,36.9 96.35,36.9 96.59,36.66
  L3 w0.114: 50.04,49.15 50.04,49.39 54.75,54.1 55.45,54.1 55.57,54.22 55.57,54.74 55.69,54.86 55.9,54.86 56.02,54.74 56.02,54.22 56.14,54.1 59.46,54.1 59.57,53.99 59.57,53.53 59.69,53.42 59.92,53.42 60.03,53.53 60.03,53.99 60.15,54.1 60.37,54.1 60.49,53.99 60.49,53.53 60.6,53.42 60.83,53.42 60.95,53.53 60.95,53.99 61.06,54.1 61.29,54.1 61.4,53.99 61.4,53.53 61.52,53.42 61.75,53.42 61.86,53.53 61.86,53.99 61.97,54.1 62.2,54.1 62.32,53.99 62.32,53.53 62.43,53.42 62.66,53.42 62.77,53.53 62.77,53.99 62.89,54.1 63.12,54.1 63.23,53.99 63.23,53.53 63.35,53.42 63.57,53.42 63.69,53.53 63.69,53.99 63.8,54.1 64.03,54.1 64.15,53.99 64.15,53.64 64.27,53.52 64.48,53.52 64.6,53.64 64.6,53.99 64.72,54.1 66.27,54.1 68.21,56.05 68.21,56.71 68.59,57.09 69.28,57.09 69.6,57.4 69.6,63.36 ; v1(106.43,38.1) 105.28,36.96 104.09,36.96 103.82,36.68 102.74,36.68 102.19,36.14 100.9,36.14 100.37,36.66 96.59,36.66
  L5 w0.114: v2(90.83,38.09) 90.43,37.69 79.57,37.69 v2(79.17,38.09) 78.76,37.68 78.19,37.68 78.11,37.6 75.92,37.6 75.81,37.48 75.81,36.97 75.69,36.86 75.47,36.86 75.35,36.97 75.35,37.48 75.24,37.6 72.93,37.6 72.83,37.69 67.86,37.69 v2(67.44,38.12) 67.01,37.69 65.89,37.69 65.68,37.49 63.92,37.49 63.8,37.6 63.8,37.81 63.69,37.92 63.46,37.92 63.35,37.81 63.35,37.6 63.23,37.49 63,37.49 62.89,37.6 62.89,37.81 62.78,37.92 62.55,37.92 62.43,37.81 62.43,37.6 62.32,37.49 61.42,37.49 61.22,37.69 59.63,37.69 59.63,37.69 56.23,37.69 v2(55.8,38.12) 55.38,37.69 52.66,37.69 52.55,37.58 52.55,37.47 52.42,37.34 52.22,37.34 52.09,37.47 52.09,37.58 51.98,37.69 51.75,37.69 51.63,37.58 51.63,37.48 51.52,37.36 51.29,37.36 51.18,37.48 51.18,37.58 51.06,37.69 44.54,37.69 v2(44.12,38.12)
SOC_DDR3B_EA4: length 125.1
  TOP w0.102: U40.P8 59.8,38.09 v2(59.79,38.09) ; v2(48.11,38.09) 48.22,38.09 48.5,37.81 U39.P8 ; v2(94.84,38.09) 94.85,38.09 U43.P8 ; v2(71.42,38.09) 71.81,37.7 U41.P8 ; v2(74.02,67.92) 73.52,68.42 U24.W34 ; U42.P8 83.55,37.7 v2(83.16,38.09)
  L3 w0.102: v2(48.11,38.09) 48.38,38.09 48.8,38.51 50.11,38.51 50.29,38.68 51.03,38.68
  L3 w0.114: v2(74.02,67.92) 74.04,67.92 74.22,68.1 74.22,68.25 74.12,68.35 73.81,68.35 73.25,67.79 73.25,64.43 75.13,62.55 75.13,55.47 74.45,54.79 74.45,54.51 75.12,53.84 75.12,53.66 74.87,53.41 74.69,53.41 73.78,54.32 73.62,54.32 73.46,54.15 73.46,53.99 74.37,53.08 74.37,52.9 74.22,52.76 74.04,52.76 73.13,53.67 72.97,53.67 72.81,53.51 72.81,53.35 73.58,52.58 73.58,52.4 73.44,52.25 73.26,52.25 72.49,53.02 72.33,53.02 72.16,52.86 72.16,52.7 72.96,51.9 72.96,51.73 72.82,51.58 72.64,51.58 71.84,52.38 71.68,52.38 71.52,52.21 71.52,52.05 72.49,51.08 72.49,50.92 71.42,49.86 70.79,49.86 69.6,48.67 68.96,48.67 67.61,47.32 65.5,47.32 64.74,46.56 63.55,46.56 61.85,44.86 59.49,44.86 57.8,43.17 57.11,43.17 55.66,41.72 54.32,41.72 51.28,38.68 51.03,38.68
  L8 w0.114: v2(94.84,38.09) 95.24,38.49 96.98,38.49 97.26,38.22 100.75,38.22 101.26,38.73 v1(102.62,38.73)
  L10 w0.114: v2(48.11,38.09) 48.38,38.09 48.77,37.7 50.02,37.7 50.48,38.16 53.73,38.16 54.04,38.48 54.4,38.48 54.63,38.25 54.63,37.93 54.86,37.7 59.17,37.7 59.55,38.09 v2(59.79,38.09) 60.82,38.09 61.42,37.49 65.68,37.49 65.9,37.7 70.8,37.7 71.18,38.09 v2(71.42,38.09) 71.64,38.09 72.26,37.47 75.26,37.47 75.82,36.91 76.32,36.91 76.43,37.02 76.43,37.2 76.55,37.31 76.78,37.31 76.89,37.2 76.89,37.02 77,36.91 77.23,36.91 77.35,37.02 77.35,37.2 77.46,37.31 77.69,37.31 77.8,37.2 77.8,37.02 77.92,36.91 80.59,36.91 81.39,37.7 82.54,37.7 82.92,38.09 v2(83.16,38.09) 83.32,38.09 83.9,37.51 84.94,37.51 85.54,36.92 90.97,36.92 90.97,36.92 91.53,36.92 91.53,36.92 91.9,36.92 92.69,37.7 94.21,37.7 94.6,38.09 v2(94.84,38.09)
  BOTTOM w0.127: v1(102.62,38.73) 103.07,39.19 R781.1
SOC_DDR3B_EA5: length 127.2
  TOP w0.102: U41.P2 67.02,37.68 v2(67.39,37.3) ; v2(90.81,37.3) 90.81,37.33 U43.P2 ; U42.P2 78.75,37.68 v2(79.13,37.3) ; v2(55.76,37.3) 55.76,37.33 U40.P2 ; U24.V34 74.52,68.42 v2(75.02,67.92)
  TOP w0.127: U39.P2 44.07,37.33 v2(44.07,37.3)
  L3 w0.102: v2(44.07,37.3) 44.48,36.9 44.48,36.42 45.17,35.73 47.11,35.73 47.45,36.07 47.45,36.78 47.73,37.06 47.73,37.44 48,37.71 50.1,37.71 50.41,38.02
  L3 w0.114: v2(75.02,67.92) 75.03,67.94 75.03,68.38 74.98,68.43 74.7,68.43 74.52,68.25 74.52,67.54 74.4,67.41 73.66,67.41 73.53,67.28 73.53,64.54 75.53,62.54 75.53,53.49 72.97,50.93 72.97,50.44 70.59,48.06 68.85,48.06 67.89,47.09 67.89,46.45 67.56,46.13 66.95,46.13 66.82,46.25 66.82,46.9 66.71,47.02 66.48,47.02 66.36,46.9 66.36,46.25 66.24,46.13 64.65,46.13 64.63,46.15 63.77,46.15 61.9,44.27 61.01,44.27 59.84,43.1 58.95,43.1 58.28,42.43 58.12,42.43 57.83,42.71 57.67,42.71 57.51,42.55 57.51,42.39 57.79,42.1 57.79,41.94 56.74,40.89 56.59,40.89 56.59,40.89 54.08,40.89 51.25,38.07 50.46,38.07 50.41,38.02
  L5 w0.114: v2(44.07,37.3) 44.51,36.87 51.89,36.87 52.01,36.75 52.01,36.45 52.13,36.32 52.34,36.32 52.46,36.45 52.46,36.75 52.58,36.87 54.79,36.87 54.82,36.9 55.36,36.9 v2(55.76,37.3) 56.16,36.9 58.84,36.9 58.85,36.9 62,36.9 62.11,36.78 62.11,36.61 62.23,36.5 62.46,36.5 62.57,36.61 62.57,36.78 62.69,36.9 62.91,36.9 63.03,36.78 63.03,36.61 63.14,36.5 63.37,36.5 63.49,36.61 63.49,36.78 63.6,36.9 66.98,36.9 v2(67.39,37.3) 67.82,36.88 72.14,36.88 72.8,36.22 76.33,36.22 76.44,36.33 76.44,36.61 76.56,36.73 76.79,36.73 76.9,36.61 76.9,36.33 77.01,36.22 77.47,36.22 78.16,36.91 78.73,36.91 v2(79.13,37.3) 79.52,36.91 82.08,36.91 82.11,36.87 89.85,36.87 89.86,36.88 90.39,36.88 v2(90.81,37.3)
  BOTTOM w0.102: v2(90.81,37.3) 91.02,37.3 91.41,37.68 91.98,37.68 94.21,35.45
  BOTTOM w0.127: R792.1 99.34,36.03 98.87,36.03 97.31,34.48 95.19,34.48 94.21,35.45
SOC_DDR3B_EA6: length 121.5
  TOP w0.102: v2(83.12,37.26) 83.2,37.26 U42.R8 ; v2(74.02,65.92) 73.52,66.42 U24.W36 ; U41.R8 71.78,36.9 v2(71.4,37.29) ; v2(48.13,37.29) 48.13,37.28 U39.R8 ; v2(59.79,37.31) 60.19,36.91 U40.R8 ; 97.92,37.34 95.63,37.34 95.24,36.94 U43.R8 94.86,37.28 v2(94.86,37.28)
  TOP w0.127: R463.1 99.31,37.97 v1(99.06,37.72) 98.68,37.34 97.92,37.34
  L3 w0.102: v2(74.02,65.92) 73.99,65.95 73.99,66.42 74.12,66.55 74.47,66.55 74.6,66.42 74.6,65.53 74.47,65.41 73.89,65.41 73.79,65.3 73.79,64.71 ; v2(48.13,37.29) 48.26,37.41 50.37,37.41 50.62,37.67 51.05,37.67
  L3 w0.114: 73.79,64.71 75.93,62.57 75.93,52.67 75.53,52.26 75.37,52.26 75.21,52.42 75.05,52.42 74.89,52.26 74.89,52.1 75.05,51.94 75.05,51.78 74.88,51.62 74.72,51.62 74.57,51.77 74.4,51.77 74.24,51.61 74.24,51.45 74.4,51.29 74.4,51.13 74.24,50.97 74.08,50.97 73.92,51.13 73.76,51.13 73.6,50.97 73.6,50.8 73.75,50.65 73.75,50.49 72.31,49.05 72.19,49.05 70.92,47.78 69.9,47.78 69.77,47.64 69.77,47.47 69.89,47.35 70.89,47.35 71.02,47.22 71.02,46.91 70.89,46.79 70.56,46.79 70.48,46.71 70.48,46.61 69.62,45.75 69.41,45.75 69.29,45.86 69.29,47.45 69.17,47.57 68.96,47.57 68.84,47.45 68.84,45.86 68.72,45.75 64.03,45.75 62.99,44.7 62.99,44.54 63.33,44.21 63.33,44.05 63.16,43.89 63,43.89 62.67,44.22 62.51,44.22 61.83,43.54 61.83,42.74 61.41,42.32 60.1,42.32 59.93,42.49 59.15,42.49 56.78,40.12 53.99,40.12 51.54,37.67 51.05,37.67
  L10 w0.114: v2(48.13,37.29) 48.33,37.08 53.72,37.08 54,36.8 54,36.5 54.41,36.09 57.38,36.09 58.18,36.9 59.34,36.9 59.75,37.31 v2(59.79,37.31) 60.74,37.31 61.82,36.23 65.49,36.23 65.63,36.08 69.23,36.08 69.98,36.83 70.87,36.83 71.32,37.29 v2(71.4,37.29) 71.55,37.29 72.58,36.26 75.3,36.26 76.26,35.3 77.89,35.3 78.05,35.46 78.34,35.46 78.5,35.3 80.43,35.3 81.99,36.85 82.57,36.85 82.98,37.26 v2(83.12,37.26) 83.36,37.26 84.71,35.91 88.4,35.91 88.61,35.69 89.43,35.69 89.82,35.3 91.59,35.3 93.15,36.85 94.43,36.85 v2(94.86,37.28)
SOC_DDR3B_EA7: length 129.3
  TOP w0.102: U42.R2 78.76,36.9 v2(79.15,36.52) ; U40.R2 55.39,36.9 v2(55.78,36.52) ; v2(90.83,36.52) 90.44,36.9 U43.R2 ; U24.W37 73.73,65.42 74.2,64.95 v2(74.2,64.92) ; v2(67.41,36.52) 67.02,36.9 U41.R2
  TOP w0.127: v1(102.62,35.94) 103.07,36.39 R467.1 ; U39.R2 44.09,36.52 v2(44.09,36.52)
  L3 w0.102: v2(44.09,36.52) 45.08,35.53 47.19,35.53 47.65,35.99 47.65,36.57 47.92,36.85 48.23,36.85 48.59,37.21 51.05,37.21
  L3 w0.114: v2(74.2,64.92) 74.2,64.73 76.33,62.6 76.33,52.41 72.62,48.69 72.62,48.11 71.81,47.29 71.81,46.74 71.59,46.52 70.82,46.52 69.49,45.19 68.58,45.19 68.47,45.07 68.47,44.84 68.35,44.73 68.13,44.73 68.01,44.84 68.01,45.07 67.9,45.19 67.67,45.19 67.55,45.07 67.55,44.84 67.44,44.73 67.21,44.73 67.1,44.84 67.1,45.07 66.98,45.19 64.92,45.19 64.7,44.96 64.7,44.8 65.38,44.12 65.38,43.94 65.23,43.79 65.05,43.79 64.37,44.48 64.21,44.48 64.05,44.31 64.05,44.15 64.83,43.37 64.83,43.19 64.69,43.05 64.51,43.05 63.85,43.71 63.67,43.71 63.53,43.56 63.53,43.38 63.81,43.1 63.81,42.93 63.65,42.77 63.49,42.77 63.08,43.18 62.92,43.18 61.45,41.72 59.12,41.72 57,39.6 57,39.53 56.77,39.29 54.1,39.29 52.02,37.21 51.05,37.21
  L5 w0.102: 78.06,35.43 78.1,35.43 78.92,36.25 78.92,36.29 v2(79.15,36.52) 80.23,35.43
  L5 w0.114: v2(44.09,36.52) 44.54,36.07 45.19,36.07 45.59,35.66 49.67,35.66 49.69,35.67 51.07,35.67 51.18,35.79 51.18,35.89 51.31,36.02 51.51,36.02 51.64,35.89 51.64,35.79 51.75,35.67 53.15,35.67 53.7,36.23 54.73,36.23 54.82,36.13 55.39,36.13 v2(55.78,36.52) 56.73,35.56 60.58,35.56 61.09,36.07 63.95,36.07 64.11,36.23 65.68,36.23 65.93,35.97 66.87,35.97 v2(67.41,36.52) 68.77,35.16 77.79,35.16 78.06,35.43 ; v2(90.83,36.52) 90.42,36.1 87.88,36.1 86.94,35.16 80.5,35.16 80.23,35.43
  L8 w0.114: v1(102.62,35.94) 102.62,36.07 101.98,36.7 101.89,36.7 101.58,37.01 101.22,37.01 100.9,36.7 96.33,36.7 96.14,36.89 91.56,36.89 91.18,36.52 v2(90.83,36.52)
SOC_DDR3B_EA8: length 125.6
  TOP w0.102: U39.T8 48.14,36.47 v2(48.08,36.47) ; v2(71.4,36.45) 71.74,36.1 U41.T8 ; U42.T8 83.19,36.47 v2(83.13,36.47) ; U43.T8 94.88,36.47 v2(94.82,36.47) ; v2(59.77,36.47) 59.82,36.47 U40.T8 ; U24.AA33 v2(71.02,68.92)
  L3 w0.102: 71.37,70.21 71.37,69.28 v2(71.02,68.92) ; 50.55,36.88 48.73,36.88 48.31,36.47 v2(48.08,36.47)
  L3 w0.114: 71.37,70.21 71.74,70.57 72.82,70.57 73.94,69.44 75.06,69.44 75.41,69.1 75.41,63.94 76.73,62.61 76.73,52.1 73.61,48.97 73.61,47.55 73.31,47.25 72.94,47.25 72.71,47.02 72.71,46.65 71.78,45.72 70.48,45.72 69.04,44.27 66.9,44.27 65.95,43.32 65.64,43.32 64.64,42.32 62.71,42.32 61.29,40.89 58.82,40.89 58.09,40.16 58.09,39.85 57,38.76 57,38.74 56.77,38.51 53.98,38.51 52.27,36.8 50.62,36.8 50.55,36.88
  L10 w0.114: v2(94.82,36.47) 92.85,34.5 85.08,34.5 84.31,35.27 84.31,35.29 v2(83.13,36.47) 81.17,34.5 73.2,34.5 71.4,36.3 v2(71.4,36.45) 69.85,34.9 61.33,34.9 v2(59.77,36.47) 59.24,35.94 58.6,35.94 57.53,34.87 52.37,34.87 51.26,35.99 48.56,35.99 v2(48.08,36.47)
  BOTTOM w0.102: v2(94.82,36.47) 94.99,36.47 95.46,36.93
  BOTTOM w0.127: 95.46,36.93 96.01,36.93 96.31,36.63 98.2,36.63 98.78,37.21 102.3,37.21 R788.1
SOC_DDR3B_EA9: length 127.6
  TOP w0.102: U42.R3 79.72,36.9 80,37.19 v2(80,37.3) ; U41.R3 67.87,36.9 v2(68.27,37.3) ; v2(56.64,37.3) 56.58,37.3 U40.R3 ; U43.R3 91.64,37.3 v2(91.69,37.3) ; U24.Y32 72.46,70.42 v2(72.01,69.98)
  TOP w0.127: v2(44.95,37.25) 44.85,37.25 U39.R3
  L3 w0.102: v2(72.01,69.98) 72.26,69.98 72.4,69.84 72.4,67.77 72.07,67.44 71.73,67.44 71.63,67.34 71.63,64.57 71.37,64.31 70.84,64.31 70.05,63.52 70.05,63.18 70.06,63.17 ; v2(44.95,37.25) 44.91,37.21 44.91,37.01 45.03,36.88 45.77,36.88 45.92,37.03 45.92,42.75 46.3,43.12 46.3,44.61 46.48,44.79 46.48,45.97 46.71,46.21
  L3 w0.114: 46.71,46.21 47.04,46.53 47.46,46.53 47.51,46.48 48.26,46.48 49.07,47.29 49.79,47.29 50.42,47.92 50.42,48.96 50.44,48.98 50.44,49.22 54.23,53.01 54.69,53.01 54.81,53.12 54.81,53.58 54.92,53.7 55.15,53.7 55.26,53.58 55.26,52.91 55.39,52.78 55.59,52.78 55.72,52.91 55.72,53.58 55.84,53.7 56.06,53.7 56.18,53.58 56.18,52.91 56.3,52.78 56.51,52.78 56.64,52.91 56.64,53.58 56.75,53.7 56.98,53.7 57.09,53.58 57.09,52.93 57.22,52.81 57.42,52.81 57.55,52.93 57.55,53.58 57.66,53.7 57.89,53.7 58.01,53.58 58.01,52.81 58.13,52.68 58.34,52.68 58.46,52.81 58.46,53.39 58.59,53.52 58.79,53.52 58.92,53.39 58.92,53.12 59.04,53.01 65.77,53.01 70.06,57.3 70.06,63.17
  L8 w0.114: v2(44.95,37.25) 45.3,36.9 47.97,36.9 47.97,36.9 48.29,36.9 48.29,36.9 51.09,36.9 51.21,36.79 51.21,36.68 51.33,36.55 51.54,36.55 51.67,36.68 51.67,36.79 51.78,36.9 52.01,36.9 52.12,36.79 52.12,36.68 52.25,36.55 52.45,36.55 52.58,36.68 52.58,36.79 52.69,36.9 56.24,36.9 v2(56.64,37.3) 57.09,36.85 66.41,36.85 66.46,36.9 67.87,36.9 v2(68.27,37.3) 68.67,36.9 72.84,36.9 73.03,37.08 74.89,37.08 75,36.97 75,36.72 75.11,36.6 75.34,36.6 75.46,36.72 75.46,36.97 75.57,37.08 75.8,37.08 75.91,36.97 75.91,36.72 76.03,36.6 76.26,36.6 76.37,36.72 76.37,36.97 76.49,37.08 76.71,37.08 76.83,36.97 76.83,36.72 76.94,36.6 77.17,36.6 77.29,36.72 77.29,36.97 77.4,37.08 78.01,37.08 78.19,36.91 79.61,36.91 v2(80,37.3) 80.4,36.91 82.08,36.91 82.11,36.87 83.28,36.87 83.32,36.91 91.01,36.91 91.41,37.3 v2(91.69,37.3)
  BOTTOM w0.102: v2(91.69,37.3) 91.31,36.93 91.31,35.56 91.42,35.45
  BOTTOM w0.127: R795.1 99.69,33.59 93.28,33.59 91.42,35.45
SOC_DDR3B_EA10: length 126.4
  TOP w0.102: v2(72.01,63.92) 72.51,64.42 U24.Y38 ; U42.L7 v2(82.35,40.5) ; U43.L7 v2(94.04,40.5) ; v2(47.1,40.5) 47.5,40.1 U39.L7 ; U41.L7 v2(70.62,40.5) ; U40.L7 v2(58.99,40.5)
  TOP w0.127: v1(102.75,41.5) 102.74,41.49 102.74,41.09 R455.1
  L3 w0.102: 49.86,44.91 48.72,44.91 48.48,44.67 48.48,44.32 48.26,44.1 47.27,44.1 47.12,43.94 47.12,40.52 v2(47.1,40.5) ; v2(72.01,63.92) 72.01,64.08 71.88,64.21 71.58,64.21 71.45,64.08 71.45,63.6 71.58,63.47 72.31,63.47 72.69,63.09 72.69,62.81 72.57,62.69 72.3,62.69 71.66,62.05
  L3 w0.114: 49.86,44.91 50.68,44.91 50.8,44.78 50.8,42.34 50.93,42.21 51.1,42.21 51.26,42.38 51.26,43.87 51.39,44 52.16,44 52.27,44.11 52.27,44.34 52.16,44.45 51.39,44.45 51.26,44.58 51.26,44.78 51.39,44.91 51.9,44.91 52.57,45.58 52.57,46.29 52.41,46.45 52.41,47.99 52.52,48.11 52.75,48.11 52.87,47.99 52.87,46.81 52.99,46.69 53.2,46.69 53.32,46.81 53.32,48.16 53.45,48.29 53.65,48.29 53.78,48.16 53.78,47.41 53.89,47.29 54.46,47.29 54.58,47.42 54.58,49.25 54.66,49.33 54.83,49.33 55.06,49.1 55.22,49.1 55.38,49.26 55.38,49.42 55.15,49.65 55.15,49.82 55.35,50.01 56.13,50.01 56.25,49.9 56.25,49.59 56.36,49.48 56.59,49.48 56.7,49.59 56.7,49.9 56.82,50.01 57.05,50.01 57.16,49.9 57.16,49.59 57.28,49.48 57.5,49.48 57.62,49.59 57.62,49.9 57.73,50.01 58.78,50.01 58.9,49.89 58.9,49.07 59.03,48.95 59.54,48.95 60.12,49.52 60.5,49.52 60.5,49.53 61.8,49.53 62.13,49.86 64.21,49.86 65.05,50.7 66.45,50.7 71.66,55.91 71.66,62.05
  L10 w0.114: v1(102.75,41.5) 102.53,41.27 101.22,41.27 100.33,40.39 97.92,40.39 97.41,40.89 94.7,40.89 94.31,40.5 v2(94.04,40.5) 93.65,40.89 82.74,40.89 v2(82.35,40.5) 81.96,40.89 78.2,40.89 77.76,40.45 77.26,40.45 77.15,40.57 77.15,40.83 77.04,40.94 76.81,40.94 76.69,40.83 76.69,40.57 76.58,40.45 76.35,40.45 76.24,40.57 76.24,40.83 76.12,40.94 75.89,40.94 75.78,40.83 75.78,40.57 75.66,40.45 72.96,40.45 72.52,40.89 71.29,40.89 70.9,40.5 v2(70.62,40.5) 69.42,41.71 65.84,41.71 65.02,40.89 59.37,40.89 v2(58.99,40.5) 57.78,41.7 54.15,41.7 53.34,40.89 47.49,40.89 v2(47.1,40.5)
SOC_DDR3B_EA11: length 123.3
  TOP w0.102: v2(59.01,37.28) 59.05,37.24 59.05,37.23 U40.R7 ; U41.R7 70.99,36.9 v2(70.61,37.29) ; v2(93.94,37.28) 93.94,37.28 93.95,37.28 94.32,36.9 U43.R7 ; v2(72.01,62.93) 71.52,63.42 U24.AA39 ; v2(82.25,37.28) 82.38,37.28 U42.R7 ; U39.R7 47.35,37.26 v2(47.35,37.3)
  L3 w0.102: 50.24,45.76 48.6,45.76 47.61,44.78 47.4,44.78 46.91,44.29 46.91,41.07 46.53,40.69 46.53,38.12 v2(47.35,37.3)
  L3 w0.114: 50.24,45.76 50.29,45.81 50.86,45.81 50.98,45.69 50.98,45.43 51.09,45.31 51.32,45.31 51.43,45.43 51.43,45.69 51.55,45.81 52.02,45.81 52.15,45.94 52.15,46.14 52.02,46.27 51.21,46.27 51.08,46.39 51.08,46.6 51.21,46.72 51.88,46.72 51.99,46.84 51.99,47.07 51.88,47.18 51.45,47.18 51.33,47.29 51.33,47.52 51.45,47.64 51.88,47.64 51.99,47.75 51.99,47.98 51.88,48.09 51.57,48.09 51.45,48.22 51.45,48.45 51.93,48.94 52.1,48.94 52.49,48.54 52.65,48.54 52.82,48.7 52.82,48.86 52.42,49.26 52.42,49.42 52.63,49.63 52.83,49.63 53.43,49.03 53.76,49.03 54.41,49.69 54.41,49.85 54.13,50.13 54.13,50.29 54.29,50.46 54.45,50.46 54.74,50.17 54.9,50.17 55.14,50.42 59.2,50.42 59.33,50.29 59.33,49.91 59.45,49.78 59.66,49.78 59.78,49.91 59.78,50.98 59.91,51.1 60.13,51.1 60.24,50.99 60.24,50.06 60.37,49.94 60.57,49.94 60.7,50.06 60.7,50.99 60.81,51.1 61.04,51.1 61.16,50.99 61.16,50.06 61.28,49.94 61.49,49.94 61.61,50.06 61.61,50.99 61.73,51.1 61.96,51.1 62.07,50.99 62.07,50.39 62.2,50.27 62.4,50.27 62.53,50.39 62.53,50.99 62.64,51.1 62.87,51.1 62.99,50.99 62.99,50.39 63.11,50.27 63.32,50.27 63.44,50.39 63.44,50.99 63.56,51.1 66.24,51.1 71.26,56.12 71.26,62.18 v2(72.01,62.93)
  L10 w0.114: v2(47.35,37.3) 47.35,37.42 47.61,37.68 48.43,37.68 48.81,37.3 50.25,37.3 50.55,37.59 54.33,37.59 54.48,37.44 54.48,37.08 54.65,36.92 57.55,36.92 57.91,37.28 v2(59.01,37.28) 59.22,37.28 59.63,37.69 60.73,37.69 61.72,36.7 65.42,36.7 65.63,36.92 69.23,36.92 69.6,37.29 v2(70.61,37.29) 70.85,37.29 71.24,37.67 71.56,37.67 72.02,37.21 73.23,37.21 73.48,36.96 75.18,36.96 76.04,36.1 77.22,36.1 77.34,36.22 77.34,36.44 77.45,36.55 77.68,36.55 77.8,36.44 77.8,36.22 77.91,36.1 80.17,36.1 81.35,37.28 v2(82.25,37.28) 82.59,37.28 82.96,37.64 83.37,37.64 83.73,37.29 84.72,37.29 85.7,36.31 88.56,36.31 88.78,36.09 91.85,36.09 93.05,37.28 v2(93.94,37.28)
  BOTTOM w0.102: v2(93.94,37.28) 94.32,36.9 95.03,36.9 95.39,37.27
  BOTTOM w0.127: R789.1 99.69,37.97 99.44,38.23 98.81,38.23 97.66,37.08 96.59,37.08 96.4,37.27 95.39,37.27
SOC_DDR3B_EA12: length 123.6
  TOP w0.102: U42.N7 v2(82.37,38.89) ; U43.N7 v2(94.06,38.89) ; v2(47.32,38.89) 47.32,38.63 47.45,38.5 U39.N7 ; U24.Y35 v2(72.02,66.92) ; U40.N7 v2(59,38.89) ; U41.N7 v2(70.64,38.89)
  TOP w0.127: v1(100.41,38.66) 99.88,39.19 R458.1
  L3 w0.102: 72.83,63.62 72.6,63.84 72.6,67.12 72.48,67.25 72.14,67.25 72.02,67.12 v2(72.02,66.92) ; 73.2,61.9 73.3,62
  L3 w0.114: 72.83,63.62 73.3,63.14 73.3,62 ; 73.2,61.9 73.2,61.04 73.08,60.91 72.59,60.91 72.46,60.78 72.46,57.18 72.72,56.92 72.72,55.78 66.8,49.86 65.38,49.86 64.53,49.01 62.48,49.01 62.26,48.79 62.26,47.4 62.13,47.27 61.9,47.27 61.77,47.4 61.77,47.93 61.72,47.98 61.59,48.11 61.11,48.11 60.99,47.98 60.99,47.41 60.86,47.29 60.33,47.29 60.17,47.44 60.17,47.6 60.05,47.73 59.77,47.73 59.64,47.6 59.64,47.42 59.51,47.29 58.6,47.29 58.47,47.17 58.47,46.69 58.34,46.56 57.25,46.56 57.12,46.69 57.12,47.62 56.83,47.92 56.26,47.92 56.13,47.79 56.13,46.08 55.93,45.87 53.47,45.87 53.23,45.63 53.23,43.47 52.9,43.14 52.42,43.14 52.27,43 52.27,42.25 51.19,41.17 49.76,41.17 49.63,41.3 49.63,41.91 49.53,42.01 49.02,42.01 48.9,42.14 48.9,42.37 49.02,42.49 49.89,42.49 50.16,42.77 50.16,43.17 50.04,43.29 48.74,43.29 48.52,43.07 48.52,42.72 48.28,42.49 47.76,42.49 47.75,42.49 47.62,42.37 47.62,40.84 47.74,40.73 47.74,40.21 47.83,40.12 48.06,40.12 48.18,39.99 48.18,39.73 48.06,39.6 47.83,39.6 47.7,39.47 47.7,39.01 47.57,38.89 v2(47.32,38.89)
  L10 w0.114: v1(100.41,38.66) 99.77,39.29 94.54,39.29 94.13,38.89 v2(94.06,38.89) 93.64,39.3 85.66,39.3 85.22,39.75 84.07,39.75 83.65,39.33 82.82,39.33 v2(82.37,38.89) 81.95,39.3 77.66,39.3 77.54,39.19 77.54,39.08 77.43,38.96 77.2,38.96 77.09,39.08 77.09,39.19 76.97,39.3 76.74,39.3 76.63,39.19 76.63,39.08 76.51,38.96 76.29,38.96 76.17,39.08 76.17,39.19 76.06,39.3 75.83,39.3 75.71,39.19 75.71,39.08 75.6,38.96 75.37,38.96 75.26,39.08 75.26,39.19 75.14,39.3 74.13,39.3 73.95,39.49 71.37,39.49 70.76,38.89 v2(70.64,38.89) 69.41,40.12 65.52,40.12 65.08,39.68 60.29,39.68 59.91,39.29 59.41,39.29 v2(59,38.89) 57.77,40.12 55.47,40.12 55.29,39.93 54.64,39.93 54.45,40.12 53.96,40.12 53.53,39.69 48.13,39.69 v2(47.32,38.89)
SOC_DDR3B_EA13: length 125.9
  TOP w0.102: v2(71.14,62.75) 71.14,62.56 71.92,61.77 72.36,61.77 72.64,62.05 72.64,63.3 U24.Y39 ; v2(68.3,36.47) 67.94,36.1 U41.T3 ; v2(91.69,36.48) 91.7,36.48 91.32,36.1 U43.T3 ; U42.T3 79.67,36.1 80.01,36.44 v2(80.01,36.52) ; v2(56.64,36.52) 56.6,36.52 U40.T3
  TOP w0.127: v2(44.98,36.46) 44.86,36.46 U39.T3
  L3 w0.102: v2(44.98,36.46) 44.98,36.27 45.32,35.93 47.02,35.93 47.24,36.16 47.24,36.83 46.33,37.74 46.33,40.89 46.7,41.27 46.7,44.38 47.31,44.98 47.53,44.98 48.52,45.97 50.09,45.97 51.03,46.91 51.03,48.62
  L3 w0.114: 51.03,48.62 52.67,50.26 52.83,50.26 53.43,49.65 53.61,49.65 53.76,49.79 53.76,49.97 53.15,50.58 53.15,50.74 53.43,51.02 53.77,51.02 53.98,51.22 53.98,51.56 54.08,51.66 54.36,51.66 54.48,51.55 54.48,50.99 54.59,50.88 54.82,50.88 54.94,50.99 54.94,51.55 55.05,51.66 55.28,51.66 55.39,51.55 55.39,50.99 55.51,50.88 55.74,50.88 55.85,50.99 55.85,51.55 55.96,51.66 56.19,51.66 56.31,51.55 56.31,50.99 56.42,50.88 56.65,50.88 56.76,50.99 56.76,51.55 56.88,51.66 57.11,51.66 57.22,51.55 57.22,50.99 57.34,50.88 57.57,50.88 57.68,50.99 57.68,51.55 57.79,51.66 58.02,51.66 58.14,51.55 58.14,50.99 58.25,50.88 58.48,50.88 58.59,50.99 58.59,51.55 58.71,51.66 58.94,51.66 59.05,51.55 59.05,51.24 59.17,51.13 59.32,51.13 59.44,51.24 59.44,51.36 59.59,51.51 66.07,51.51 70.86,56.31 70.86,62.13 70.71,62.28 70.71,62.89 70.84,63.02 71.01,63.02 71.14,62.89 v2(71.14,62.75)
  L8 w0.114: v2(91.69,36.48) 91.29,36.07 90.67,36.07 90.62,36.02 82.14,36.02 82.04,36.12 80.41,36.12 v2(80.01,36.52) 79.6,36.1 78.17,36.1 78.08,36.2 77.27,36.2 77.15,36.08 77.15,35.75 77.04,35.64 76.81,35.64 76.7,35.75 76.7,36.08 76.58,36.2 76.35,36.2 76.24,36.08 76.24,35.75 76.13,35.64 75.9,35.64 75.78,35.75 75.78,36.08 75.67,36.2 72.52,36.2 72.26,35.94 69.34,35.94 68.81,36.47 v2(68.3,36.47) 67.91,36.07 64.92,36.07 64.76,36.23 61.12,36.23 60.71,35.81 58.67,35.81 57.97,36.52 v2(56.64,36.52) 56.22,36.09 54.75,36.09 54.61,36.23 53.75,36.23 53.34,35.81 52.62,35.81 52.51,35.7 52.51,35.53 52.38,35.41 52.18,35.41 52.05,35.53 52.05,35.7 51.93,35.81 45.63,35.81 v2(44.98,36.46)
  BOTTOM w0.127: v2(91.69,36.48) 91.69,36.44 94.1,34.04 98.74,34.04 R794.1
SOC_DDR3B_EA14: length 124.6
  TOP w0.102: v2(93.93,36.47) 94.08,36.47 U43.T7 ; U41.T7 70.91,36.1 v2(70.59,36.42) ; v2(70.99,63.92) 71.49,64.42 U24.AA38 ; v2(46.86,36.32) 46.86,36.04 46.99,35.92 47.57,35.92 47.7,36.04 U39.T7 ; U42.T7 82.39,36.47 v2(82.25,36.47) ; U40.T7 59.04,36.45 v2(58.93,36.45)
  TOP w0.127: v1(100.2,35.86) 99.88,36.19 R466.1
  L3 w0.102: 46.9,45.75 46.71,45.57 46.71,44.73 46.5,44.52 46.5,43.04 46.13,42.67 46.13,42.44 46.33,42.24 46.33,42.03 46.13,41.83 46.13,41.63 46.33,41.42 46.33,41.22 46.13,41.02 46.13,37.24 46.25,37.11 46.51,37.11 46.63,36.98 46.63,36.75 46.51,36.63 45.59,36.63 45.47,36.5 45.47,36.3 45.59,36.17 46.72,36.17 v2(46.86,36.32)
  L3 w0.114: 46.9,45.75 48,45.75 48.5,46.25 49.95,46.25 50.75,47.04 50.75,48.9 54.04,52.2 58.93,52.2 59.04,52.31 59.04,52.48 59.17,52.6 59.37,52.6 59.5,52.48 59.5,52.04 59.63,51.92 59.83,51.92 59.96,52.04 59.96,52.46 60.07,52.58 60.3,52.58 60.41,52.46 60.41,52.04 60.54,51.92 60.74,51.92 60.87,52.04 60.87,52.46 60.99,52.58 61.21,52.58 61.33,52.46 61.33,52.04 61.46,51.92 61.66,51.92 61.79,52.04 61.79,52.46 61.9,52.58 62.13,52.58 62.24,52.46 62.24,52.04 62.37,51.92 62.57,51.92 62.7,52.04 62.7,52.46 62.81,52.58 63.04,52.58 63.16,52.46 63.16,52.07 63.28,51.94 63.49,51.94 63.62,52.07 63.62,52.46 63.73,52.58 63.96,52.58 64.07,52.46 64.07,52.07 64.2,51.94 64.4,51.94 64.53,52.07 64.53,52.46 64.64,52.58 64.87,52.58 64.99,52.46 64.99,52.11 65.1,51.99 65.32,51.99 65.62,52.29 65.78,52.29 65.94,52.13 66.1,52.13 66.27,52.3 66.27,52.46 66.11,52.62 66.11,52.78 66.27,52.94 66.43,52.94 66.59,52.78 66.75,52.78 66.91,52.94 66.91,53.1 66.75,53.26 66.75,53.43 66.92,53.59 67.08,53.59 67.24,53.43 67.4,53.43 67.56,53.59 67.56,53.75 67.4,53.91 67.4,54.07 67.56,54.23 67.72,54.23 67.88,54.07 68.04,54.07 68.21,54.24 68.21,54.4 68.05,54.56 68.05,54.72 68.21,54.88 68.37,54.88 68.52,54.73 68.7,54.73 68.84,54.87 68.84,55.05 68.69,55.2 68.69,55.37 70.46,57.13 70.46,61.95 70.34,62.07 70.34,63.51 70.76,63.92 v2(70.99,63.92)
  L8 w0.114: v1(100.2,35.86) 100,36.07 94.33,36.07 v2(93.93,36.47)
  L10 w0.114: v2(46.86,36.32) 47.41,36.87 50.64,36.87 50.93,36.58 51.94,36.58 53.24,35.28 57.23,35.28 58.39,36.45 v2(58.93,36.45) 59.2,36.45 59.61,36.85 60.81,36.85 62.36,35.3 69.46,35.3 v2(70.59,36.42) 70.83,36.42 71.24,36.84 71.56,36.84 71.79,36.61 71.79,36.54 73.43,34.9 80.68,34.9 v2(82.25,36.47) 82.42,36.64 82.76,36.64 82.97,36.85 83.29,36.85 85.25,34.9 91.76,34.9 93.32,36.47 v2(93.93,36.47)
SOC_DDR3B_EA15: length 128.6
  TOP w0.102: U40.M7 v2(59,39.69) ; U39.M7 v2(47.31,39.69) ; v2(72.02,65.92) U24.Y36 ; v2(82.37,39.69) 82.37,39.54 82.6,39.3 U42.M7 ; U43.M7 v2(94.05,39.69) ; U41.M7 v2(70.63,39.69)
  TOP w0.127: R444.1 105.61,42.11 v1(105.09,41.59)
  L3 w0.102: 49.12,44.15 48.79,44.15 48.49,43.85 48.49,43.53 48.27,43.31 47.57,43.31 47.37,43.1 47.37,40.78 47.49,40.66 47.49,40.35 47.26,40.12 46.94,40.12 46.81,40 46.81,39.32 46.94,39.19 47.09,39.19 47.31,39.42 v2(47.31,39.69) ; 72.06,62.13 72.24,62.31 72.9,62.31 73.03,62.43 73.03,63.07 72.4,63.69 72.4,66.4 72.27,66.52 71.98,66.52 71.86,66.4 71.86,66.05 71.98,65.92 v2(72.02,65.92)
  L3 w0.114: 49.12,44.15 49.55,44.58 50.32,44.58 50.44,44.45 50.44,42.21 50.22,41.99 50.22,41.83 50.35,41.71 51.16,41.71 51.87,42.42 51.87,43.16 52.3,43.59 52.68,43.59 52.92,43.83 52.92,46.01 53.26,46.36 55.47,46.36 55.6,46.48 55.6,48.36 56.29,49.05 57.15,49.05 57.49,48.7 57.49,47.19 57.62,47.07 57.84,47.07 57.96,47.19 57.96,47.44 58.08,47.55 58.41,47.55 58.52,47.66 58.52,47.89 58.41,48.01 58.08,48.01 57.96,48.12 57.96,48.39 58.09,48.51 58.71,48.51 58.82,48.4 58.82,48.22 58.94,48.11 59.17,48.11 59.28,48.22 59.28,48.4 59.39,48.51 59.99,48.51 60.6,49.12 62.03,49.12 62.33,49.43 64.36,49.43 65.23,50.29 66.62,50.29 72.29,55.96 72.29,56.72 72.06,56.95 72.06,61.28 72.19,61.41 72.62,61.41 72.75,61.54 72.75,61.74 72.62,61.87 72.19,61.87 72.06,61.99 72.06,62.13
  L10 w0.114: v1(105.09,41.59) 104.57,41.59 104.19,41.22 103.09,41.22 102.75,40.87 102.23,40.87 101.96,40.6 101.96,40.59 101.64,40.26 100.84,40.26 100.27,39.69 v2(94.05,39.69) 93.62,40.12 91.51,40.12 91.49,40.13 90.22,40.13 90.2,40.12 89.9,40.12 89.88,40.11 82.98,40.11 82.57,39.69 v2(82.37,39.69) 81.93,40.13 81.67,40.13 81.55,40.02 81.55,39.69 81.44,39.57 81.21,39.57 81.09,39.69 81.09,40.44 81,40.54 80.7,40.54 80.57,40.41 80.57,40.24 80.44,40.12 78.2,40.12 78.19,40.13 77.85,40.13 77.72,40.01 71.37,40.01 71.06,39.69 v2(70.63,39.69) 69.43,40.89 65.66,40.89 64.86,40.09 59.4,40.09 v2(59,39.69) 57.8,40.89 54.23,40.89 53.43,40.09 52.37,40.09 52.16,40.31 51.31,40.31 51.09,40.09 47.71,40.09 v2(47.31,39.69)
SOC_DDR3B_EBA_0: length 127.2
  TOP w0.102: v2(79.15,38.9) 79.15,38.91 U42.M2 ; U43.M2 90.83,38.91 v2(90.83,38.9) ; v2(67.41,38.9) 67.02,39.29 U41.M2 ; U24.AA37 v2(71.02,64.92) ; v2(55.78,38.9) 55.64,38.9 55.38,39.15 U40.M2
  TOP w0.127: v2(44.09,38.92) 44.08,38.92 U39.M2
  L3 w0.102: v2(44.09,38.92) 44.26,38.92 44.7,38.48 45.04,38.48 45.52,38.96 45.52,42.92 45.89,43.29 45.89,44.77 46.08,44.96 46.08,47.85 46.38,48.16 47.34,48.16 47.42,48.09 48.06,48.09 49.07,49.1 ; v2(71.02,64.92) 71.22,65.13 71.22,66.42 71.1,66.54 70.73,66.54 70.6,66.42 70.6,64.65 70.59,64.63 69.86,63.91 69.44,63.91 69.42,63.88
  L3 w0.114: 69.42,63.88 69.29,63.75 69.29,62.84 69.16,62.71 68.2,62.71 67.79,62.31 67.79,61.93 67.96,61.76 67.96,60.95 68.08,60.83 68.08,60.5 67.84,60.25 67.84,60.03 67.96,59.91 68.48,59.91 68.6,59.8 68.6,59.57 68.48,59.45 67.96,59.45 67.84,59.34 67.84,59.11 67.96,59 68.48,59 68.6,58.88 68.6,58.65 68.48,58.54 67.96,58.54 67.84,58.43 67.84,58.2 67.96,58.08 68.43,58.08 68.55,57.96 68.55,57.61 67.81,56.87 67.81,56.21 67.03,55.43 66.87,55.43 66.75,55.56 66.58,55.56 66.42,55.4 66.42,55.24 66.55,55.11 66.55,54.95 66.11,54.51 60.32,54.51 60.21,54.62 60.21,55.18 60.09,55.3 59.87,55.3 59.75,55.18 59.75,54.62 59.64,54.51 59.41,54.51 59.29,54.62 59.29,55.18 59.18,55.3 58.95,55.3 58.84,55.18 58.84,54.62 58.72,54.51 58.49,54.51 58.38,54.62 58.38,55.18 58.27,55.3 58.04,55.3 57.92,55.18 57.92,54.62 57.81,54.51 57.58,54.51 57.47,54.62 57.47,55.18 57.35,55.3 57.12,55.3 57.01,55.18 57.01,54.64 56.88,54.51 56.68,54.51 56.55,54.64 56.55,55.18 56.44,55.3 55.27,55.3 49.07,49.1
  L5 w0.114: v2(44.09,38.92) 44.52,38.5 50.92,38.5 51.04,38.38 51.04,38.28 51.17,38.15 51.37,38.15 51.5,38.28 51.5,38.46 51.62,38.58 51.83,38.58 51.95,38.46 51.95,38.28 52.08,38.15 52.28,38.15 52.41,38.28 52.41,38.38 52.52,38.5 55.38,38.5 v2(55.78,38.9) 56.17,38.5 58.84,38.5 58.84,38.5 59.16,38.5 59.17,38.5 61.3,38.5 61.31,38.5 62.59,38.5 62.7,38.61 62.7,38.77 62.82,38.89 63.05,38.89 63.16,38.77 63.16,38.61 63.27,38.5 63.5,38.5 63.62,38.61 63.62,38.77 63.73,38.89 63.96,38.89 64.07,38.77 64.07,38.61 64.19,38.5 67.01,38.5 v2(67.41,38.9) 67.8,38.51 68.55,38.51 68.59,38.48 72.83,38.48 72.93,38.38 73.27,38.38 73.37,38.48 74.98,38.48 75.09,38.36 75.09,38.16 75.2,38.05 75.43,38.05 75.55,38.16 75.55,38.36 75.66,38.48 75.89,38.48 76,38.36 76,38.16 76.12,38.05 76.35,38.05 76.46,38.16 76.46,38.36 76.58,38.48 78.73,38.48 v2(79.15,38.9) 79.56,38.48 84.68,38.48 84.81,38.61 89.77,38.61 89.88,38.5 90.43,38.5 v2(90.83,38.9)
  BOTTOM w0.102: 96.59,38.48 91.25,38.48 v2(90.83,38.9)
  BOTTOM w0.127: R775.1 97.46,40.77 97.22,40.53 97.22,38.93 96.77,38.48 96.59,38.48
SOC_DDR3B_EBA_1: length 128.9
  TOP w0.102: U39.N8 48.5,38.51 v2(48.11,38.9) ; U40.N8 60.19,38.51 v2(59.79,38.9) ; U41.N8 71.82,38.53 71.45,38.9 v2(71.42,38.9) ; U42.N8 83.55,38.51 v2(83.16,38.9) ; U43.N8 94.84,38.9 v2(94.84,38.9) ; U24.AA34 v2(71.02,67.92)
  TOP w0.127: R465.1 v1(106.3,36.7)
  L3 w0.102: v2(71.02,67.92) 71.07,67.87 71.07,67.67 70.94,67.54 70.74,67.54 70.61,67.67 70.61,68.22 70.84,68.45 71.53,68.45 71.63,68.55 71.63,70.13 71.85,70.36 72.17,70.36 72.81,69.72 72.81,64 72.86,63.95
  L3 w0.114: 72.86,63.95 73.64,63.17 73.64,59.85 73.48,59.69 73.1,59.69 72.86,59.45 72.86,59.26 72.97,59.15 73.67,59.15 73.79,59.03 73.79,58.81 73.67,58.69 72.97,58.69 72.86,58.58 72.86,57.52 73,57.38 73.41,57.38 73.84,56.95 73.84,56.32 66.95,49.43 65.58,49.43 64.69,48.54 62.84,48.54 62.6,48.3 62.6,48.14 62.73,48.01 62.73,47.44 61.8,46.51 59.49,46.51 59.18,46.2 57.1,46.2 56.97,46.08 56.97,45.92 56.71,45.66 55.97,45.66 54.99,44.68 54.99,44.42 54.86,44.3 54.66,44.3 54.53,44.42 54.53,44.73 54.41,44.86 53.82,44.86 53.62,44.65 53.62,43.03 52.73,42.14 52.72,42.14 51.51,40.92 51.51,40.75 51.3,40.54 50.24,40.54 49.91,40.87 49.43,40.87 49.3,41 49.3,41.58 49.21,41.67 48.64,41.67 48.51,41.54 48.51,41.45 48.51,41.44 48.51,41.12 48.51,41.11 48.51,40.21 48.64,40.08 48.9,40.08 49.02,39.95 49.02,39.67 48.9,39.55 48.49,39.55 48.11,39.17 v2(48.11,38.9)
  L10 w0.114: v1(106.3,36.7) 106.17,36.83 102.87,36.83 102.17,37.53 100.77,37.53 99.92,38.38 97.66,38.38 97.56,38.48 95.49,38.48 95.07,38.9 v2(94.84,38.9) 94.44,38.5 83.79,38.5 83.38,38.9 v2(83.16,38.9) 82.94,38.9 82.53,38.5 81.89,38.5 81.78,38.61 81.78,38.8 81.66,38.91 81.43,38.91 81.32,38.8 81.32,38.61 81.21,38.5 80.98,38.5 80.86,38.61 80.86,38.8 80.75,38.91 80.52,38.91 80.41,38.8 80.41,38.61 80.29,38.5 74.98,38.5 74.87,38.61 74.87,38.77 74.75,38.89 74.53,38.89 74.41,38.77 74.41,38.61 74.3,38.5 74,38.5 73.25,39.24 72.52,39.24 72.48,39.27 72.08,39.27 71.71,38.9 v2(71.42,38.9) 71.2,38.9 70.8,38.5 70.47,38.5 69.67,39.29 65.33,39.29 65.31,39.28 60.42,39.28 60.04,38.9 v2(59.79,38.9) 59.61,38.9 59.18,38.48 58.8,38.48 57.99,39.29 57.69,39.29 57.58,39.18 57.58,39.04 57.45,38.91 57.25,38.91 57.12,39.04 57.12,39.18 57.01,39.29 48.49,39.29 v2(48.11,38.9)
SOC_DDR3B_EBA_2: length 132.4
  TOP w0.102: U43.M3 91.62,39.69 v2(91.67,39.69) ; U41.M3 67.86,39.3 v2(68.25,39.69) ; U24.AB35 70.51,67.41 v2(70.02,66.92) ; v2(56.62,39.69) 56.57,39.69 U40.M3 ; v2(79.98,39.69) 79.94,39.69 U42.M3
  TOP w0.127: U39.M3 44.89,39.69 v2(44.93,39.69) ; v1(106.17,40.26) 106.17,40.33 R454.1
  L3 w0.102: v2(44.93,39.69) 45.11,39.87 45.11,42.24 44.93,42.42 44.93,42.91 45.49,43.46 45.49,44.94 45.67,45.13 45.67,48.31 45.93,48.57 47.04,48.57 47.5,49.02 47.76,49.02 ; 69.7,66.64 69.58,66.75 69.51,66.75 69.4,66.87 69.4,67.08 69.53,67.21 69.89,67.21 70.02,67.08 v2(70.02,66.92)
  L3 w0.114: 69.7,66.64 69.7,66.15 69.58,66.04 69.56,66.04 69.44,65.93 69.44,64.67 69.32,64.54 69.21,64.54 67.38,62.71 66.87,62.71 65.99,61.83 65.99,61.28 66.14,61.13 66.8,61.13 66.93,61 66.93,60.38 66.8,60.26 66.28,60.26 66.17,60.14 66.17,59.86 66.28,59.75 66.88,59.75 67.01,59.62 67.01,59.37 66.88,59.24 66.28,59.24 66.17,59.13 66.17,58.85 66.28,58.73 66.82,58.73 66.95,58.61 66.95,58.29 66.82,58.17 65.05,58.17 64.92,58.04 64.92,57.78 65.05,57.66 66.8,57.66 66.93,57.53 66.93,56.56 66.8,56.44 66.47,56.44 66.36,56.55 66.36,56.98 66.24,57.1 66.02,57.1 65.9,56.98 65.9,56.55 65.79,56.44 59.69,56.44 59.56,56.31 59.56,56.24 59.44,56.11 59.18,56.11 59.06,56.24 59.06,56.72 58.93,56.85 58.73,56.85 58.6,56.72 58.6,56.24 58.47,56.11 58.27,56.11 58.14,56.24 58.14,56.77 58.02,56.9 57.81,56.9 57.68,56.77 57.68,56.24 57.56,56.11 57.35,56.11 57.23,56.24 57.23,56.77 57.1,56.9 56.9,56.9 56.77,56.77 56.77,56.24 56.64,56.11 56.44,56.11 56.31,56.24 56.31,57.02 56.19,57.15 55.98,57.15 55.86,57.02 55.86,56.34 55.73,56.21 54.95,56.21 47.76,49.02
  L8 w0.102: v2(91.67,39.69) 93.51,39.69 93.89,40.07 94.21,40.07 94.59,39.69 97.92,39.69
  L8 w0.114: v2(91.67,39.69) 91.27,39.29 85.27,39.29 85.09,39.47 84.77,39.47 84.59,39.29 80.38,39.29 v2(79.98,39.69) 79.59,39.29 77.51,39.29 77.4,39.18 77.4,39.03 77.28,38.91 77.05,38.91 76.94,39.03 76.94,39.18 76.83,39.29 76.6,39.29 76.48,39.18 76.48,39.03 76.37,38.91 76.14,38.91 76.03,39.03 76.03,39.18 75.91,39.29 75.68,39.29 75.57,39.18 75.57,39.03 75.45,38.91 75.23,38.91 75.11,39.03 75.11,39.18 75,39.29 74.77,39.29 74.65,39.18 74.65,39.03 74.54,38.91 74.31,38.91 74.2,39.03 74.2,39.18 74.08,39.29 70.28,39.29 70.08,39.09 68.85,39.09 v2(68.25,39.69) 67.86,39.3 57,39.3 v2(56.62,39.69) 56.23,39.3 52.7,39.3 52.58,39.19 52.58,39.03 52.47,38.91 52.24,38.91 52.13,39.03 52.13,39.24 52,39.37 51.8,39.37 51.67,39.24 51.67,39.03 51.55,38.91 51.33,38.91 51.21,39.03 51.21,39.19 51.1,39.3 45.32,39.3 v2(44.93,39.69) ; v1(106.17,40.26) 105.41,39.5 104.4,39.5 104.27,39.63 103.91,39.63 103.77,39.5 101.98,39.5 101.67,39.81 98.03,39.81 97.92,39.69
SOC_DDR3B_ECAS#: length 132.3
  TOP w0.102: U41.K3 v2(68.23,41.32) ; U43.K3 v2(91.65,41.32) ; v2(69.02,65.92) U24.AC36 ; U42.K3 v2(79.97,41.32) ; U40.K3 v2(56.6,41.32)
  TOP w0.127: v2(44.09,40.51) 44.49,40.9 U39.K3 ; R457.1 v1(106.3,39.5)
  L3 w0.102: v2(44.09,40.51) 44.48,40.9 44.48,48.77 ; 68.32,64.45 68.4,64.53 68.4,65.8 68.53,65.92 v2(69.02,65.92) ; 96.59,40.89 92.07,40.89 v2(91.65,41.32) ; 61.09,62.08 62.46,62.08
  L3 w0.114: 62.46,62.08 62.61,61.93 62.61,61.74 62.5,61.63 61.47,61.63 61.34,61.5 61.34,61.3 61.47,61.17 62.5,61.17 62.61,61.05 62.61,60.83 62.5,60.71 61.37,60.71 61.24,60.58 61.24,60.38 61.37,60.25 62.69,60.25 62.81,60.13 62.81,59.92 62.69,59.8 61.14,59.8 61.01,59.67 61.01,59.47 61.14,59.34 62.5,59.34 62.61,59.23 62.61,59 62.5,58.88 60.91,58.88 60.78,58.76 60.78,58.55 60.91,58.43 62.5,58.43 62.61,58.31 62.61,57.78 62.74,57.66 63.78,57.66 63.91,57.78 63.91,59.44 64.19,59.72 64.19,61.7 64.39,61.9 64.97,61.9 66.4,63.32 67.2,63.32 68.32,64.45 ; 61.09,62.08 60.15,61.13 60.15,59.99 58.14,57.99 55.56,57.99 46.85,49.28 44.96,49.28 44.48,48.8 44.48,48.77 ; v1(106.3,39.5) 104.65,39.5 104.39,39.75 103.63,39.75 103.25,39.37 102.49,39.37 101.73,40.13 100.71,40.13 99.95,40.89 96.59,40.89
  L8 w0.114: v2(44.09,40.51) 44.47,40.89 56.17,40.89 v2(56.6,41.32) 57.02,40.89 63.72,40.89 64.1,40.51 65.08,40.51 65.46,40.89 66.78,40.89 66.79,40.89 67.81,40.89 v2(68.23,41.32) 68.63,40.92 72.36,40.92 73.03,40.26 73.62,40.26 73.74,40.37 73.74,40.96 73.85,41.07 74.08,41.07 74.19,40.96 74.19,40.37 74.31,40.26 74.8,40.26 75.44,40.89 79.54,40.89 v2(79.97,41.32) 80.39,40.89 86.3,40.89 86.33,40.87 88.05,40.87 88.08,40.89 91.23,40.89 v2(91.65,41.32)
SOC_DDR3B_ECC0: length 36.9
  TOP w0.102: U41.E3 67.89,44.9 68.25,45.26 70.61,45.26 v2(70.68,45.33) ; U24.AF32 66.44,70.42 66.04,70.03 v2(66.04,69.93)
  L8 w0.102: v2(66.04,69.93) 66.04,69.85 66.5,69.39
  L8 w0.114: v2(70.68,45.33) 71.07,45.72 71.96,45.72 72.14,45.9 72.69,45.9 73.51,46.71 73.51,48.56 73.3,48.77 73.3,55.83 72.75,56.39 72.75,68.94 72.29,69.39 66.5,69.39
SOC_DDR3B_ECC1: length 37.1
  TOP w0.102: U41.F7 71.24,44.1 71.37,43.97 71.37,43.76 71.27,43.66 70.52,43.66 v2(70.31,43.88) ; U24.AF34 v2(66.02,67.92)
  L8 w0.102: v2(66.02,67.92) 66.02,67.54 66.21,67.34 69.14,67.34 69.4,67.08
  L8 w0.114: v2(70.31,43.88) 69.84,44.34 69.35,44.34 69.09,44.6 69.09,45.21 70.34,46.46 70.34,47.78 70.84,48.29 70.84,48.62 70.28,49.17 70.28,50.09 70.6,50.41 70.76,50.41 71.56,49.62 71.74,49.62 71.88,49.76 71.88,49.94 71.09,50.73 71.09,50.89 71.27,51.08 71.27,61.34 70.1,62.51 70.1,62.94 69.9,63.14 69.39,63.14 69.27,63.27 69.27,63.53 69.39,63.65 69.96,63.65 70.08,63.77 70.08,64 69.96,64.11 69.3,64.11 69.19,64.23 69.19,64.49 69.56,64.86 69.56,66.92 69.4,67.08
SOC_DDR3B_ECC2: length 36.9
  TOP w0.102: v2(67.06,69.98) 67.5,70.42 U24.AE32 ; v2(66.56,44.51) 67.25,44.51 67.34,44.42 67.34,44.25 67.19,44.1 U41.F2
  L8 w0.102: 67.56,66.17 67.43,66.3 66.03,66.3 65.64,66.7 65.64,70.87 65.76,70.99 67.49,70.99 67.61,70.87 67.61,70.1 67.49,69.98 v2(67.06,69.98)
  L8 w0.114: 67.56,66.17 67.56,62.23 68.08,61.72 68.08,56.3 67.39,55.61 67.39,52.05 64.69,49.36 64.69,46.33 64.9,46.12 64.9,45.96 64.61,45.68 64.61,45.5 64.76,45.35 64.93,45.35 65.22,45.64 65.38,45.64 66.51,44.51 v2(66.56,44.51)
SOC_DDR3B_ECC3: length 36.9
  TOP w0.102: U24.AF35 v2(66.02,66.92) ; v2(69.68,43.83) 69.68,42.95 69.55,42.82 68.55,42.82 68.45,42.93 68.45,43.1 68.58,43.23 69.11,43.23 69.24,43.36 69.24,43.87 69.06,44.04 69.06,44.35 69.27,44.55 72.14,44.55 72.26,44.42 72.26,44.23 72.14,44.1 U41.F8
  L8 w0.102: v2(66.02,66.92) 66.4,66.54 68.48,66.54 68.64,66.38 68.64,63.29
  L8 w0.114: v2(69.68,43.83) 69.22,43.83 68.55,44.5 68.55,45.14 69.47,46.05 69.47,48.03 69.77,48.34 69.77,50.27 70.69,51.18 70.69,61.24 68.64,63.29
SOC_DDR3B_ECC4: length 37.1
  TOP w0.102: U24.AE33 v2(67.02,68.92) ; v2(70.43,42.55) 70.39,42.5 U41.H3
  L8 w0.102: v2(67.02,68.92) 66.64,68.54 66.64,67.67 66.76,67.54 69.79,67.54 69.88,67.46
  L8 w0.114: v2(70.43,42.55) 70.74,42.85 70.74,43.99 69.98,44.75 69.98,45.67 70.87,46.56 70.87,47.8 72.39,49.33 72.39,51.08 72.28,51.2 71.93,51.2 71.82,51.31 71.82,51.54 71.93,51.65 72.28,51.65 72.39,51.77 72.39,52 72.28,52.11 71.93,52.11 71.82,52.22 71.82,61.81 71.5,62.13 71.02,62.13 70.48,62.66 70.48,67.23 70.26,67.46 69.88,67.46
SOC_DDR3B_ECC5: length 37
  TOP w0.102: v2(72.21,42.87) 71.85,42.5 U41.H8 ; v2(67.02,65.92) U24.AE36
  L8 w0.102: 66.67,62.08 66.64,62.12 66.64,65.54 v2(67.02,65.92)
  L8 w0.114: 66.67,62.08 66.94,61.82 66.94,56.85 66.24,56.15 66.24,52.53 62.74,49.02 62.74,44.48 65.18,42.04 67.59,42.04 68.12,42.57 68.43,42.57 69,42 69.3,42 69.42,42.11 69.42,42.53 69.53,42.65 69.76,42.65 69.88,42.53 69.88,42.11 69.99,42 70.75,42 71.24,42.49 71.84,42.49 v2(72.21,42.87)
SOC_DDR3B_ECC6: length 37.2
  TOP w0.102: U41.G2 67.02,43.5 66.85,43.66 66.7,43.66 66.6,43.56 66.6,42.94 v2(66.58,42.93) ; v2(68.02,65.92) U24.AD36
  L8 w0.102: 68.4,64.54 68.4,65.54 v2(68.02,65.92)
  L8 w0.114: 68.4,64.54 67.94,64.08 67.94,62.33 68.54,61.74 68.54,57.11 68.62,57.02 69.2,57.02 69.29,56.93 69.29,56.08 69.16,55.96 68.47,55.96 68.34,55.83 68.34,55.49 68.22,55.38 67.96,55.38 67.84,55.27 67.84,55.04 67.96,54.92 68.22,54.92 68.34,54.81 68.34,54.38 68.22,54.26 67.97,54.26 67.84,54.14 67.84,53.93 67.97,53.81 68.4,53.81 68.52,53.68 68.52,53.48 68.4,53.35 67.96,53.35 67.84,53.24 67.84,51.86 66.79,50.81 66.79,50.65 67.12,50.33 67.12,50.15 66.97,50 66.79,50 66.47,50.33 66.31,50.33 66.15,50.17 66.15,50 66.89,49.26 66.89,49.08 66.74,48.94 66.56,48.94 65.82,49.68 65.66,49.68 65.15,49.17 65.15,46.61 65.71,46.05 65.87,46.05 66.24,46.42 66.4,46.42 66.56,46.26 66.56,46.1 66.19,45.73 66.19,45.57 66.35,45.41 66.52,45.41 66.89,45.78 67.05,45.78 67.21,45.62 67.21,45.45 66.84,45.08 66.84,44.92 66.94,44.82 66.94,43.29 v2(66.58,42.93)
SOC_DDR3B_ECC7: length 37
  TOP w0.102: U24.AE34 67.06,67.96 67.06,67.93 v2(67.02,67.93) ; U41.H7 71.03,42.5 v2(71.45,42.93)
  L8 w0.114: v2(67.02,67.93) 67.03,67.93 67.64,68.54 70.06,68.54 70.15,68.45 71.09,68.45 71.6,67.94 71.6,62.56 72.29,61.87 72.29,55.5 72.4,55.38 72.73,55.38 72.85,55.27 72.85,55.04 72.73,54.93 72.4,54.93 72.29,54.81 72.29,54.58 72.4,54.47 72.73,54.47 72.85,54.35 72.85,54.13 72.73,54.01 72.4,54.01 72.29,53.9 72.29,53.67 72.4,53.55 72.73,53.55 72.85,53.44 72.85,53.21 72.73,53.1 72.4,53.1 72.29,52.98 72.29,52.75 72.4,52.64 72.73,52.64 72.85,52.53 72.85,49.05 72.61,48.81 72.61,47.16 72.69,47.07 72.69,46.71 72.49,46.52 71.28,46.52 70.29,45.53 70.29,44.9 71.12,44.07 71.12,43.26 v2(71.45,42.93)
SOC_DDR3B_ECKE_0: length 126.4
  TOP w0.102: v2(73.18,40.84) 73.11,40.9 U41.K9 ; v2(49.73,40.48) 49.31,40.9 U39.K9 ; U24.AB39 70.52,62.83 71.75,61.59 ; U40.K9 60.99,40.9 v2(61.42,40.48) ; v2(96.47,40.4) 96.47,40.47 U43.K9 ; U42.K9 84.7,40.56 v2(84.7,40.5)
  TOP w0.127: 71.75,61.59 72.03,61.32 72.03,59.18 72.21,59 72.68,59 72.77,58.92 72.77,58.25 72.68,58.17 71.5,58.17 71.32,57.99 71.32,56.11 71.45,55.99 72.09,55.99 72.21,55.86 72.21,55.61 72.09,55.48 71.45,55.48 71.32,55.35 71.32,55.1 71.45,54.97 72.36,54.97 72.49,54.84 72.49,54.59 72.36,54.46 71.45,54.46 71.32,54.34 71.32,54.08 71.45,53.96 72.54,53.96 72.67,53.83 72.67,53.57 72.54,53.45 71.45,53.45 71.32,53.32 71.32,52.93 71.45,52.81 73.86,52.81 73.99,52.93 73.99,57.86 73.86,57.99 v1(73.38,57.99)
  L3 w0.102: 50.05,40.16 50.11,40.11 51.05,40.11
  L3 w0.114: v1(73.38,57.99) 74.24,57.12 74.24,56.16 67.08,49 65.79,49 64.24,47.45 63.2,47.45 61.87,46.13 59.61,46.13 58.75,45.26 56.36,45.26 55.4,44.3 55.4,42.67 55.22,42.49 53.82,42.49 51.44,40.11 51.05,40.11 ; 50.05,40.16 v2(49.73,40.48)
  L5 w0.102: v2(61.42,40.48) 61.83,40.89
  L5 w0.114: v2(49.73,40.48) 50.15,40.89 57.03,40.89 57.14,40.78 57.14,40.65 57.26,40.54 57.49,40.54 57.6,40.65 57.6,40.78 57.72,40.89 57.94,40.89 58.06,40.78 58.06,40.65 58.17,40.54 58.4,40.54 58.52,40.65 58.52,40.78 58.63,40.89 61,40.89 v2(61.42,40.48) ; 61.83,40.89 66.46,40.89 66.46,40.89 66.78,40.89 66.79,40.89 68.05,40.89 68.08,40.92 68.71,40.92 68.82,40.81 68.82,40.65 68.94,40.54 69.17,40.54 69.28,40.65 69.28,40.81 69.39,40.92 69.62,40.92 69.74,40.81 69.74,40.65 69.85,40.54 70.08,40.54 70.19,40.65 70.19,40.81 70.31,40.92 73.1,40.92 v2(73.18,40.84) 73.51,40.51 75.46,40.51 75.83,40.87 76.13,40.87 76.25,40.76 76.25,40.4 76.36,40.28 76.59,40.28 76.71,40.4 76.71,40.76 76.82,40.87 78.09,40.87 78.1,40.89 80.9,40.89 80.9,40.89 84.31,40.89 v2(84.7,40.5) 85.09,40.89 85.98,40.89 86,40.87 89.86,40.87 89.88,40.89 93.09,40.89 93.87,40.12 96.19,40.12 v2(96.47,40.4)
  L8 w0.114: v1(105.28,40.19) 105.28,40.21 104.51,40.98 102.4,40.98 102.11,41.27 100.46,41.27 99.58,40.4 v2(96.47,40.4)
  BOTTOM w0.127: v1(105.28,40.19) 105.28,40.64 105.54,40.89 R772.1
SOC_DDR3B_ECKN_0: length 126.6
  TOP w0.102: v2(94.84,41.29) 94.82,41.29 U43.K7 ; U24.AD39 68.52,63.61 68.63,63.72 68.85,63.72 68.92,63.65 68.92,62.79 69.88,61.84 69.88,61.63 69.85,61.61 69.85,61.59 ; v2(48.11,41.29) 48.09,41.29 U39.K7 ; v2(59.79,41.32) 59.79,41.31 U40.K7 ; v2(83.16,41.32) 82.75,40.91 U42.K7 ; U41.K7 71.02,40.91 v2(71.42,41.32)
  TOP w0.127: v1(69.09,59.56) 69.27,59.39 69.57,59.39 69.85,59.67 69.85,61.59 ; v1(99.17,43.26) 99.28,43.15 99.62,43.15 99.88,43.42 R443.1
  L10 w0.114: v1(69.09,59.56) 68.87,59.35 68.2,59.35 67.97,59.12 67.97,55.48 68.23,55.22 68.99,55.22 69.1,55.11 69.1,54.72 68.99,54.6 68.23,54.6 67.97,54.35 67.97,53.75 67.29,53.07 67.29,52.71 69.8,50.2 69.8,50.02 69.54,49.76 69.36,49.76 66.85,52.27 66.49,52.27 66.07,51.85 66.07,51.48 67.35,50.21 67.35,50.03 67.09,49.76 66.91,49.76 65.63,51.04 65.27,51.04 64.52,50.29 64.52,46.74 65.07,46.18 65.79,46.18 65.91,46.05 65.91,45.61 65.79,45.48 62.9,45.48 62.64,45.21 62.64,44.98 62.22,44.56 59.16,44.56 58.52,45.2 56.23,45.2 55.27,46.16 48.87,46.16 46.88,44.17 46.88,41.87 47.22,41.53 47.98,41.53 48.11,41.4 v2(48.11,41.29) 48.48,41.67 49.06,41.67 49.19,41.53 52.92,41.53 53.57,42.18 55.6,42.18 56.11,42.68 57.56,42.68 58.75,41.49 59.62,41.49 v2(59.79,41.32) 60.16,41.69 61.71,41.69 62.2,42.18 65.18,42.18 65.3,42.05 67.54,42.05 68.17,42.68 69.03,42.68 70.2,41.52 71.23,41.52 v2(71.42,41.32) 71.87,41.76 72.58,41.76 72.92,41.41 74.01,41.41 74.51,41.91 75.15,41.91 75.66,41.4 77.52,41.4 78.37,42.25 79.55,42.25 79.86,42.56 80.54,42.56 81.69,41.41 83.06,41.41 v2(83.16,41.32) 83.59,41.74 83.8,41.74 83.97,41.91 86.78,41.91 87.03,42.16 91.14,42.16 91.67,42.68 92.1,42.68 93.35,41.44 94.7,41.44 v2(94.84,41.29) 95.12,41.56 95.28,41.56 95.6,41.88 97.91,41.88 98.81,40.98 99.9,40.98 100.47,41.56 100.47,42.79 100,43.26 v1(99.17,43.26)
