# Allegro board 19C2830503-01-JOB.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SOC_XFI_CLKN_R: length 10.5
  TOP w0.102: U24.AU20 v2(55.02,82.92)
  BOTTOM w0.102: v2(55.02,82.92) 55.02,83.15 arc(55.01,83.21) 54.98,83.25 54.94,83.29 54.91,83.29 arc(54.9,83.29) 54.89,83.29 54.34,83.29 arc(54.19,83.26) 54.06,83.17 arc(53.94,83.09) 53.79,83.06 53.15,83.06 arc(52.86,83) 52.61,82.83 48.94,79.17 arc(48.69,79) 48.4,78.94 47.91,78.94 arc(47.88,78.94) 47.86,78.92 arc(47.76,78.77) 47.72,78.58 R669.2
SOC_XFI_CLKP: length 72.9
  TOP w0.102: U15.17 66,121.19 arc(65.98,121.11) 65.94,121.04 arc(65.89,120.97) 65.88,120.89 65.88,120.73 arc(65.83,120.5) 65.7,120.31 65.62,120.23 arc(65.53,120.12) 65.46,119.99 65.4,119.85 arc(65.37,119.78) 65.32,119.72 65.26,119.67 arc(65.05,119.53) 64.81,119.48 64.78,119.48 arc(64.75,119.48) 64.72,119.46 64.68,119.42 arc(64.65,119.38) 64.63,119.34 arc(64.62,119.3) 64.62,119.26 64.62,119.23 arc(64.64,119.12) 64.7,119.02 v1(64.73,119)
  L8 w0.102: v1(64.73,119) 64.64,119 arc(64.59,118.99) 64.55,118.96 arc(64.52,118.92) 64.51,118.87 64.51,118.58 arc(64.54,118.43) 64.63,118.3 arc(64.76,118.22) 64.91,118.19 67.5,118.19 arc(67.7,118.23) 67.86,118.34 68.28,118.75 arc(68.61,118.97) 69,119.05 69.6,119.05 arc(69.95,118.98) 70.25,118.78 arc(70.45,118.49) 70.52,118.14 70.52,115.56 arc(70.44,115.17) 70.22,114.84 69.58,114.2 arc(69.26,113.99) 68.9,113.92 68.79,113.92 arc(68.69,113.9) 68.61,113.84 65.5,110.74 arc(65.34,110.49) 65.28,110.2 65.28,109.26 arc(65.2,108.87) 64.98,108.54 61.9,105.45 arc(61.57,105.23) 61.18,105.16 51.57,105.16 arc(51.28,105.1) 51.03,104.93 42.84,96.74 arc(42.68,96.5) 42.62,96.2 42.62,86.17 arc(42.68,85.88) 42.84,85.63 43.34,85.14 arc(43.5,84.89) 43.56,84.6 43.56,82.28 arc(43.5,81.99) 43.34,81.74 42.64,81.05 arc(42.48,80.8) 42.42,80.51 42.42,80.31 arc(42.48,80.17) 42.62,80.11 v1(42.79,80.11)
  BOTTOM w0.102: R658.1 46.82,79.42 arc(46.74,79.23) 46.54,79.15 46.26,79.15 arc(45.97,79.2) 45.73,79.37 44.9,80.19 arc(44.65,80.36) 44.36,80.42 44,80.42 arc(43.61,80.34) 43.28,80.12 43.13,79.97 arc(42.92,79.93) v1(42.79,80.11)
SOC_XFI_CLKP_R: length 10.5
  TOP w0.102: v2(55.02,83.92) U24.AU19
  BOTTOM w0.102: v2(55.02,83.92) 55.02,83.67 arc(55.01,83.62) 54.98,83.58 arc(54.94,83.55) 54.89,83.54 54.34,83.54 arc(54.09,83.49) 53.89,83.35 arc(53.84,83.32) 53.79,83.31 53.15,83.31 arc(52.76,83.23) 52.43,83.01 48.76,79.35 arc(48.6,79.24) 48.4,79.2 47.91,79.2 arc(47.83,79.21) 47.77,79.25 arc(47.73,79.31) 47.72,79.38 R658.2
SOC_XFI_MDIO: length 37.3
  TOP w0.102: U24.AT33 56.52,69.55 v2(56.9,69.93)
  TOP w0.127: v1(39.5,49.28) 39.5,50.48 38.75,51.23 38.75,51.61 R425.2 38.98,52.62 38.98,52.85 40.44,54.31 40.44,56.97 39.97,57.44 39.97,61.48 43.41,64.92 v1(43.41,65.33)
  L3 w0.102: 51.82,67.64 54.48,70.3 56.49,70.3 56.86,69.93 v2(56.9,69.93)
  L3 w0.114: v1(43.41,65.33) 44.35,65.33 46.66,67.64 51.82,67.64
  BOTTOM w0.127: U36.4 39.1,48.52 39.5,48.92 v1(39.5,49.28)
SOC_XFI_MDIO_3V3: length 181.6
  L3 w0.114: v1(29.08,108.84) 29.49,109.25 29.9,109.25 31.57,107.58 31.57,89.89 31.78,89.68 31.78,89.02 31.36,88.6 31.36,87.17 36.07,82.46 36.93,82.46 37.39,82 37.39,80.02 38.27,79.14 38.27,74.33 36.31,72.37 36.31,59.23 33.37,56.29 32.03,54.95 30.1,54.95 27.97,52.82 27.97,51.34 31.2,48.11 31.2,46.03 v1(30.79,45.61)
  L8 w0.114: J2.C9 13.51,160.81 14.71,159.61 27.9,159.61 29.5,158.01 29.5,154.38 27.9,152.77 27.9,149.26 32.04,145.12 37.24,145.12 37.4,145.28 40.82,145.28 41.98,144.13 44.95,144.13 45.81,143.26 45.81,140.85 47.9,138.76 47.9,137.15 48.04,137.02 48.04,130.2 47.51,129.67 47.51,128.94 46.43,127.86 45.53,127.86 44.85,127.17 43.84,127.17 43.42,126.76 43.01,126.76 38.68,122.43 38.68,117.38 36.51,115.2 33.67,115.2 29.48,111.01 29.48,109.23 v1(29.08,108.84)
  BOTTOM w0.127: U36.5 39.1,45.99 38.73,46.36 37.53,46.36 R438.1 35.79,46.9 31.72,46.9 31.55,46.73 30.61,46.73 30.31,46.43 30.31,46.06 30.58,45.8 30.6,45.8 v1(30.79,45.61)
SOC_XFI_RX_DN0: length 80.8
  TOP w0.102: v6(35.99,108.89) 35.71,108.61 arc(35.61,108.54) 35.49,108.51 35.47,108.51 arc(35.41,108.5) 35.35,108.48 arc(35.31,108.48) 35.28,108.46 35.19,108.36 arc(35.08,108.21) 35.04,108.02 35.04,107.49 arc(35.12,107.1) 35.34,106.77 36.63,105.48 arc(36.74,105.31) 36.78,105.12 36.78,93.15 arc(36.86,92.76) 37.08,92.43 37.7,91.81 arc(38.03,91.59) 38.42,91.52 41.65,91.52 arc(41.84,91.48) 42,91.37 42.19,91.18 arc(42.3,91.01) 42.34,90.82 42.34,88.83 arc(42.38,88.63) 42.49,88.47 43.74,87.22 arc(43.9,87.11) 44.1,87.07 45.34,87.07 arc(45.41,87.06) 45.47,87.02 arc(45.51,86.96) 45.52,86.89 C241.1
  L3 w0.089: J2.D2 14.57,143.31 arc(14.44,143.29) 14.34,143.21 14.29,143.17 arc(14.18,143.01) 14.15,142.83 14.15,142.48 arc(14.19,142.28) 14.3,142.11 arc(14.47,142) 14.67,141.96 24.58,141.96 arc(24.87,141.9) 25.12,141.74 27.09,139.76 arc(27.25,139.52) 27.31,139.22 27.31,118.79 arc(27.32,118.68) 27.36,118.58 27.43,118.4 arc(27.48,118.31) 27.55,118.22 33.74,112.03 arc(33.83,111.92) 33.9,111.8 34.02,111.52 arc(34.07,111.37) 34.09,111.21 34.09,109.51 arc(34.14,109.22) 34.31,108.97 34.51,108.77 arc(34.76,108.6) 35.05,108.55 35.64,108.55 arc(35.78,108.57) 35.89,108.65 arc(35.97,108.76) v6(35.99,108.89)
SOC_XFI_RX_DN1: length 79.7
  TOP w0.102: C237.1 arc(45.55,92.28) 45.49,92.48 arc(45.32,92.65) 45.09,92.71 arc(44.47,92.82) 43.94,93.17 39.24,97.87 arc(38.77,98.57) 38.61,99.38 38.61,99.72 arc(38.5,100.07) v6(38.23,100.3)
  L3 w0.089: J2.D4 14.69,148.31 arc(14.5,148.35) 14.35,148.45 arc(14.24,148.61) 14.21,148.79 14.21,149.11 arc(14.25,149.32) 14.36,149.49 14.39,149.52 arc(14.57,149.64) 14.78,149.68 24.44,149.68 arc(24.65,149.64) 24.82,149.52 26.75,147.59 arc(26.87,147.41) 26.91,147.21 26.91,145.04 arc(26.97,144.72) 27.14,144.43 arc(27.25,144.25) 27.27,144.04 arc(27.35,143.19) 27.76,142.44 arc(27.82,142.38) 27.88,142.33 29.72,140.48 arc(29.84,140.3) 29.88,140.1 29.88,135.29 arc(29.96,134.92) 30.17,134.6 30.9,133.87 arc(31.02,133.69) 31.06,133.49 31.06,128.12 arc(31,127.83) 30.83,127.58 29.76,126.51 arc(29.59,126.26) 29.54,125.97 29.54,119.94 arc(29.61,119.57) 29.82,119.25 38.26,110.81 arc(38.38,110.64) 38.42,110.43 38.42,101.75 arc(38.44,101.37) 38.51,100.99 38.57,100.73 arc(38.58,100.68) 38.59,100.63 38.6,100.52 arc(38.59,100.44) 38.54,100.37 38.54,100.36 arc(38.47,100.32) 38.38,100.3 v6(38.23,100.3)
SOC_XFI_RX_DP0: length 80.8
  TOP w0.102: C238.1 45.52,87.64 arc(45.5,87.54) 45.45,87.46 45.39,87.4 arc(45.31,87.34) 45.21,87.33 44.1,87.33 arc(44,87.34) 43.92,87.4 42.67,88.65 arc(42.62,88.73) 42.6,88.83 42.6,90.82 arc(42.54,91.11) 42.37,91.36 42.18,91.55 arc(41.94,91.71) 41.65,91.77 38.42,91.77 arc(38.12,91.83) 37.88,91.99 37.26,92.61 arc(37.09,92.86) 37.03,93.15 37.03,105.12 arc(36.98,105.41) 36.81,105.66 35.52,106.95 arc(35.36,107.2) 35.3,107.49 35.3,108.02 arc(35.32,108.11) 35.37,108.18 35.41,108.23 arc(35.44,108.25) 35.47,108.25 35.49,108.25 35.61,108.26 35.66,108.26 arc(35.71,108.25) 35.75,108.22 35.92,108.05 arc(35.97,107.97) v6(35.99,107.87)
  L3 w0.089: v6(35.99,107.87) 35.99,107.94 arc(35.96,108.09) 35.88,108.22 arc(35.75,108.3) 35.6,108.33 35.05,108.33 arc(34.68,108.41) 34.36,108.62 34.16,108.82 arc(33.95,109.14) 33.87,109.51 33.87,111.21 arc(33.86,111.32) 33.82,111.43 33.7,111.71 arc(33.65,111.8) 33.59,111.88 27.39,118.07 arc(27.3,118.19) 27.23,118.32 27.16,118.49 arc(27.11,118.64) 27.1,118.79 27.1,139.22 arc(27.06,139.43) 26.94,139.61 24.96,141.58 arc(24.79,141.7) 24.58,141.74 14.67,141.74 arc(14.39,141.8) 14.15,141.96 arc(13.99,142.2) 13.93,142.48 13.93,142.85 arc(13.81,143.17) J2.C2
SOC_XFI_RX_DP1: length 79.7
  TOP w0.102: C234.1 arc(45.37,93.08) 45.09,92.96 arc(44.56,93.05) 44.12,93.34 39.41,98.05 arc(39.01,98.66) 38.86,99.38 38.86,99.72 arc(38.97,100.07) v6(39.24,100.3)
  L3 w0.089: J2.C4 13.58,148.31 arc(13.66,148.33) 13.72,148.37 13.83,148.47 arc(13.95,148.65) 13.99,148.87 13.99,149.11 arc(14.05,149.4) 14.21,149.64 14.24,149.67 arc(14.49,149.84) 14.78,149.9 24.44,149.9 arc(24.73,149.84) 24.98,149.67 26.91,147.74 arc(27.07,147.5) 27.13,147.21 27.13,145.04 arc(27.17,144.79) 27.3,144.58 arc(27.45,144.32) 27.48,144.02 arc(27.56,143.25) 27.93,142.58 29.88,140.63 arc(30.04,140.39) 30.1,140.1 30.1,135.29 arc(30.16,135) 30.32,134.75 31.05,134.02 arc(31.22,133.78) 31.27,133.49 31.27,128.12 arc(31.2,127.75) 30.99,127.43 29.91,126.35 arc(29.79,126.18) 29.75,125.97 29.75,119.94 arc(29.81,119.65) 29.97,119.4 38.41,110.97 arc(38.58,110.72) 38.63,110.43 38.63,101.75 arc(38.65,101.39) 38.72,101.04 38.79,100.73 arc(38.8,100.68) 38.8,100.63 arc(38.94,100.36) v6(39.24,100.3)
SOC_XFI_RXN0_C: length 12.9
  TOP w0.102: U24.AV19 54.52,83.6 arc(54.5,83.69) 54.45,83.77 54.43,83.78 arc(54.38,83.82) 54.31,83.83 54.23,83.83 arc(54.21,83.83) 54.2,83.82 54.12,83.74 arc(54.11,83.72) 54.1,83.7 54.1,82.24 arc(54.08,82.14) 54.03,82.06 53.87,81.9 arc(53.79,81.85) 53.69,81.83 53.03,81.83 arc(52.91,81.85) 52.81,81.91 51.82,82.91 47.39,87.34 arc(47.37,87.35) 47.35,87.35 46.79,87.35 arc(46.69,87.33) 46.61,87.28 46.5,87.16 arc(46.44,87.08) 46.42,86.98 C241.2
SOC_XFI_RXN1_C: length 13.8
  TOP w0.102: U24.AW20 53.52,82.63 arc(53.46,82.77) 53.32,82.82 arc(53.14,82.86) 52.99,82.96 47.32,88.63 arc(47.21,88.8) 47.17,88.99 47.17,92.42 arc(47.16,92.46) 47.14,92.49 47.12,92.51 arc(47.07,92.55) 47.01,92.56 46.82,92.56 arc(46.72,92.54) 46.64,92.48 46.49,92.34 arc(46.44,92.26) 46.42,92.17 C237.2
SOC_XFI_RXP0_C: length 12.8
  TOP w0.102: U24.AV18 54.52,84.21 arc(54.47,84.09) 54.34,84.04 54.23,84.04 arc(54.14,84.02) 54.05,83.96 53.97,83.88 arc(53.92,83.8) 53.9,83.7 53.9,82.24 arc(53.89,82.22) 53.88,82.2 53.73,82.04 arc(53.71,82.03) 53.69,82.03 53.03,82.03 arc(52.99,82.04) 52.95,82.06 47.53,87.48 arc(47.45,87.53) 47.35,87.55 46.76,87.55 arc(46.67,87.57) 46.59,87.63 46.5,87.72 arc(46.44,87.8) 46.42,87.89 C238.2
SOC_XFI_RXP1_C: length 13.8
  TOP w0.102: C234.2 46.42,93.23 arc(46.44,93.13) 46.5,93.05 46.66,92.89 arc(46.74,92.83) 46.84,92.81 47.01,92.81 arc(47.17,92.78) 47.3,92.69 47.35,92.64 arc(47.4,92.56) 47.42,92.46 47.42,88.99 arc(47.44,88.89) 47.5,88.81 53.17,83.14 arc(53.24,83.1) 53.32,83.08 arc(53.35,83.08) 53.38,83.07 53.4,83.07 arc(53.42,83.08) 53.44,83.09 53.47,83.12 arc(53.5,83.17) 53.52,83.24 U24.AW19
SOC_XFI_TX_DN0: length 95.7
  TOP w0.102: U24.AT19 56.37,83.42 v5(55.88,82.93)
  L3 w0.089: v5(55.88,82.93) arc(55.91,83.18) 56.13,83.31 arc(56.26,83.34) 56.36,83.42 arc(56.54,83.77) 56.48,84.17 arc(56.25,84.43) 55.91,84.53 43.31,84.53 arc(42.93,84.46) 42.61,84.24 42.59,84.22 arc(42.41,84.1) 42.2,84.06 40.8,84.06 arc(40.43,83.99) 40.11,83.78 39.39,83.05 arc(39.21,82.93) 39,82.89 37.99,82.89 arc(37.7,82.95) 37.46,83.11 arc(37.27,83.24) 37.04,83.29 arc(36.82,83.33) 36.64,83.45 32.9,87.19 arc(32.74,87.44) 32.68,87.73 32.68,89.78 arc(32.64,89.96) 32.54,90.12 arc(32.44,90.27) 32.4,90.45 32.4,110.31 arc(32.34,110.6) 32.18,110.85 25.9,117.12 arc(25.74,117.37) 25.68,117.66 25.68,138.32 arc(25.62,138.61) 25.46,138.86 25.3,139.01 arc(25.05,139.18) 24.76,139.24 15.42,139.24 arc(14.59,139.56) 14.2,140.36 arc(14.34,140.71) J2.D1
SOC_XFI_TX_DN1: length 98.4
  TOP w0.102: v2(57.02,82.92) 57.1,83 57.25,83 57.52,82.73 U24.AR20
  L10 w0.089: v2(57.02,82.92) 57.02,83.28 arc(57.01,83.33) 56.98,83.38 arc(56.93,83.41) 56.88,83.42 56.8,83.42 arc(56.73,83.43) 56.66,83.45 56.53,83.5 arc(56.42,83.64) 56.38,83.81 56.38,86.25 arc(56.46,86.63) 56.67,86.95 57,87.27 arc(57.31,87.49) 57.69,87.56 58.95,87.56 arc(59.12,87.59) 59.27,87.69 arc(59.36,87.84) 59.4,88.01 59.4,96.99 arc(59.39,97.05) 59.39,97.11 arc(59.31,97.33) 59.18,97.51 59.15,97.55 57.58,99.12 arc(57.4,99.23) 57.19,99.28 56.75,99.28 arc(56.38,99.35) 56.06,99.56 55.39,100.23 arc(55.21,100.35) 55.01,100.39 53.99,100.39 arc(53.61,100.47) 53.29,100.68 49.03,104.94 arc(48.85,105.06) 48.64,105.11 44.27,105.11 arc(43.9,105.18) 43.58,105.39 30.98,117.99 arc(30.77,118.31) 30.7,118.68 30.7,123.05 arc(30.65,123.26) 30.54,123.44 28.23,125.75 arc(28.01,126.06) 27.94,126.44 27.94,132.51 arc(27.9,132.72) 27.78,132.9 26.93,133.75 arc(26.71,134.07) 26.64,134.45 26.64,145.22 arc(26.6,145.43) 26.48,145.6 25,147.09 arc(24.82,147.21) 24.61,147.25 14.81,147.25 arc(14.58,147.2) 14.38,147.07 14.37,147.06 arc(14.25,146.87) 14.21,146.65 14.21,146.3 ; 14.21,146.3 14.21,146.25 arc(14.22,146.2) 14.25,146.15 14.51,145.89 arc(14.6,145.83) J2.D3 ; 14.21,146.3 14.2,146.3 14.21,146.3
SOC_XFI_TX_DP0: length 95.7
  TOP w0.102: v2(55.8,83.92) 56.2,83.92 56.52,84.24 U24.AT18
  L3 w0.089: v2(55.8,83.92) arc(55.87,83.78) 55.93,83.64 arc(56.01,83.56) 56.12,83.53 arc(56.17,83.54) 56.21,83.57 arc(56.32,83.81) 56.29,84.07 arc(56.13,84.25) 55.91,84.32 43.31,84.32 arc(43.01,84.26) 42.77,84.09 42.74,84.07 arc(42.5,83.9) 42.2,83.85 40.8,83.85 arc(40.51,83.79) 40.26,83.62 39.54,82.9 arc(39.3,82.74) 39,82.68 37.99,82.68 arc(37.62,82.75) 37.31,82.96 arc(37.19,83.04) 37.04,83.07 arc(36.74,83.13) 36.49,83.3 32.75,87.04 arc(32.54,87.36) 32.46,87.73 32.46,89.78 arc(32.44,89.88) 32.38,89.97 arc(32.24,90.19) 32.18,90.45 32.18,110.31 arc(32.14,110.52) 32.02,110.7 25.75,116.97 arc(25.54,117.29) 25.46,117.66 25.46,138.32 arc(25.42,138.53) 25.3,138.7 25.15,138.86 arc(24.97,138.98) 24.76,139.02 15.42,139.02 arc(14.44,139.4) 13.98,140.34 arc(13.98,140.42) 13.99,140.5 arc(13.85,140.82) J2.C1
  vias: v5(55.8,83.92)
SOC_XFI_TX_DP1: length 98.4
  TOP w0.102: U24.AR19 57.5,83.42 57.07,83.85 v2(57.07,83.95)
  L10 w0.089: v2(57.07,83.95) 57.07,83.81 arc(57.06,83.74) 57.02,83.69 arc(56.97,83.65) 56.9,83.64 56.8,83.64 arc(56.77,83.64) 56.74,83.65 56.65,83.69 arc(56.61,83.74) 56.6,83.81 56.6,86.25 arc(56.66,86.55) 56.82,86.79 57.15,87.12 arc(57.4,87.29) 57.69,87.34 58.95,87.34 arc(59.21,87.39) 59.42,87.54 arc(59.56,87.75) 59.61,88.01 59.61,96.99 arc(59.54,97.36) 59.33,97.67 57.73,99.27 arc(57.48,99.43) 57.19,99.49 56.75,99.49 arc(56.46,99.55) 56.22,99.72 55.54,100.39 arc(55.3,100.55) 55.01,100.61 53.99,100.61 arc(53.69,100.67) 53.45,100.83 49.18,105.1 arc(48.93,105.26) 48.64,105.32 44.27,105.32 arc(43.98,105.38) 43.73,105.54 31.14,118.14 arc(30.97,118.39) 30.91,118.68 30.91,123.05 arc(30.85,123.34) 30.69,123.59 28.38,125.9 arc(28.21,126.15) 28.16,126.44 28.16,132.51 arc(28.1,132.81) 27.93,133.05 27.08,133.91 arc(26.91,134.15) 26.86,134.45 26.86,145.22 arc(26.8,145.51) 26.63,145.76 25.15,147.24 arc(24.9,147.41) 24.61,147.46 14.81,147.46 arc(14.5,147.4) 14.23,147.23 14.23,147.23 arc(14.05,146.96) 13.99,146.65 13.99,146.12 arc(13.94,145.99) 13.81,145.94 arc(13.67,145.84) J2.C3
SOC_XFIMD_CLK: length 34.9
  TOP w0.102: v2(57.93,67.91) 57.93,68.01 U24.AR34
  TOP w0.127: R426.2 39.99,52 40.24,51.75 v1(40.24,51.36)
  L3 w0.102: 55.1,61.59 57.6,64.1 57.6,65.88 57.43,66.05 57.43,67.42 v2(57.93,67.91)
  L3 w0.114: 55.1,61.59 52.55,59.05 44.82,59.05 41.27,55.5 41.27,52.39 v1(40.24,51.36)
  BOTTOM w0.127: U36.3 38.6,48.38 38.99,48.77 38.99,50.42 39.93,51.36 v1(40.24,51.36)
SOC_XFIMD_CLK_3V3: length 176.3
  L3 w0.114: v1(29.72,108.81) 31.33,107.2 31.33,89.79 31.54,89.58 31.54,89.12 31.12,88.7 31.12,87.07 35.97,82.22 36.17,82.22 36.67,82.22 37.15,81.74 37.15,79.92 38.03,79.04 38.03,74.43 36.07,72.47 36.07,59.54 31.75,55.22 30.03,55.22 27.73,52.92 27.73,50.73 30.76,47.7 v1(30.76,46.25)
  L8 w0.114: J2.D9 15.57,159.94 27.91,159.94 29.74,158.11 29.74,154.28 28.14,152.67 28.14,149.36 32.14,145.36 37.13,145.36 37.3,145.52 40.95,145.52 42.1,144.38 43.85,144.38 44.55,145.07 44.91,145.07 46.05,143.92 46.05,140.95 48.21,138.8 48.21,137.26 48.98,136.49 48.98,129.87 46.73,127.62 45.63,127.62 44.95,126.93 44.51,126.93 41.94,124.36 41.94,123.28 38.93,120.27 38.93,117.28 36.61,114.96 33.77,114.96 29.72,110.91 v1(29.72,108.81)
  BOTTOM w0.127: U36.6 38.6,45.78 38.28,46.1 R439.1 35.84,46.65 31.83,46.65 31.43,46.25 v1(30.76,46.25)
SOCCLKSEL_R: length 1.4
  TOP w0.102: U24.AL4 61.38,98.42 v2(61.02,98.78)
  BOTTOM w0.102: v2(61.02,98.78) 60.7,98.47 R622.1
SPI1DIN: length 2.5
  TOP w0.102: v2(85.94,74.87) 85.94,74.87 86.5,75.42 U24.F27
  BOTTOM w0.102: TP83.1 86.58,74.23 v2(85.94,74.87)
SPI_GPIO_INT0: length 18.3
  TOP w0.127: U7.58 161.71,144.69 159.27,142.25 152.76,142.25 151.19,143.83 150.61,143.83 v1(150.22,143.43)
  BOTTOM w0.127: v1(150.22,143.43) 149.76,143.43 148.59,142.26 U52.20
SPI_GPIO_INT0_1V8: length 91.9
  L8 w0.114: v1(92.81,164.95) 92.81,165.37 96.55,169.12 99.08,169.12 99.58,168.62 103.58,168.62 104.27,169.3 106.65,169.3 107.45,170.1 112.85,170.1 113.76,169.2 122.42,169.2 123.53,170.31 126.05,170.31 126.24,170.49 126.24,171.2 127.13,172.09 132.97,172.09 132.98,172.1 133.55,172.1 134.31,171.33 136.04,171.33 136.04,171.34 140.96,171.34 143.38,168.91 143.38,165.61 142.75,164.97 142.75,161.22 143.9,160.06 143.9,157.13 146.32,154.72 146.32,154.18 149.2,151.3 150.23,151.3 152.67,148.86 v1(152.67,145.85)
  BOTTOM w0.127: v1(92.81,164.95) 93.21,164.55 U48.20 ; U52.1 148.59,146.05 149,145.64 152.45,145.64 v1(152.67,145.85)
SPI_GPIO_INT1: length 13.3
  TOP w0.127: U7.46 159.96,140.02 158.06,141.91 152.48,141.91 v1(151,143.38)
  BOTTOM w0.127: U52.18 149.89,142.27 v1(151,143.38)
SPI_GPIO_INT1_1V8: length 45.1
  L8 w0.114: v1(149.99,146.11) 148.14,147.96 145.41,147.96 140.16,153.2 112.1,153.2 v1(111.06,154.23)
  BOTTOM w0.127: v1(111.06,154.23) 111.05,154.23 110.95,154.14 U50.20 ; v1(149.99,146.11) 149.89,146.21 U52.3
SPI_GPIO_INT2: length 10.9
  TOP w0.127: U7.43 158.46,140.53 157.33,141.66 151.99,141.66 v1(150.98,142.67)
  BOTTOM w0.127: U52.17 150.54,142.26 150.95,142.67 v1(150.98,142.67)
SPI_GPIO_INT2_1V8: length 84
  L8 w0.114: v1(153.35,145.85) 153.35,148.52 150.33,151.54 149.3,151.54 146.56,154.28 146.56,154.82 144.16,157.22 144.16,160.15 143,161.31 143,164.72 143.64,165.35 143.64,169.42 141.48,171.58 136.14,171.58 135.38,172.34 126.98,172.34 126.06,171.42 124.3,171.42 122.32,169.44 113.97,169.44 113.68,169.72 113.68,169.78 113.12,170.35 107.35,170.35 106.55,169.55 102.8,169.55 v1(102.34,169.08)
  BOTTOM w0.127: U47.20 102.57,164.55 102.11,165.01 102.11,168.85 v1(102.34,169.08) ; v1(153.35,145.85) 152.91,146.3 152.39,146.3 151.98,145.89 150.88,145.89 150.54,146.24 U52.4
SPI_GPIO_INT3: length 66.2
  TOP w0.127: U7.42 157.96,140.52 157.26,141.21 v1(155.7,141.21)
  L8 w0.114: v1(155.7,141.21) 155.36,140.87 155.36,140.42 155.05,140.1 154.86,140.1 152.88,138.12 152.88,137.13 151.01,135.26 146.76,135.26 146.42,135.6 139.59,135.6 137.96,133.97 124.47,133.97 123.66,133.16 119.25,133.16 118.16,132.07 111.89,132.07 111.76,131.94 110.03,131.94 109.91,132.07 102.05,132.07 v1(100.67,130.68)
  BOTTOM w0.127: v1(100.67,130.68) 100.67,130.09 100.88,129.88 U53.20
SPI_GPIO_RESET: length 64.3
  TOP w0.127: U7.37 155.46,140.01 154.92,140.54 v1(154.86,140.54)
  L8 w0.114: v1(154.86,140.54) 152.64,138.32 152.64,137.23 150.91,135.5 146.94,135.5 146.6,135.84 139.49,135.84 137.86,134.21 124.37,134.21 123.56,133.4 118.27,133.4 118.11,133.24 112.48,133.24 111.42,132.18 110.13,132.18 110.01,132.31 101.63,132.31 v1(100.67,131.35)
  BOTTOM w0.127: v1(100.67,131.35) 100.84,131.18 U53.18 ; U52.13 153.14,140.74 153.34,140.54 v1(154.86,140.54)
SPI_GPIO_RESET_1V8: length 78.9
  L8 w0.114: v1(151.25,149.66) 151.25,149.94 150.13,151.06 149.1,151.06 147.15,153.01 144.31,153.01 141.27,156.04 138.03,156.04 137.44,155.45 132.87,155.45 131.99,154.57 112.95,154.57 110.68,156.84 106.59,156.84 v1(106.58,156.86) 104.88,158.56 104.88,163.49 102.55,165.81 v1(102.55,165.85) 100.89,167.51 99.06,167.51 98.33,168.24 97.2,168.24 v1(95.28,166.32)
  BOTTOM w0.127: v1(106.58,156.86) 107.35,156.86 107.87,156.34 107.87,155.7 108.14,155.44 U50.18 ; v1(95.28,166.32) 94.81,165.85 U48.18 ; U52.8 153.14,148.51 151.99,149.66 v1(151.25,149.66) ; U47.18 v1(102.55,165.85)
SRIO_SGMII_CLKN: length 92.7
  TOP w0.102: v1(45.06,67.03) 45.11,66.98 45.22,66.98 C319.1 ; U15.15 65,120.98 64.88,120.87 64.88,120.36 64.16,119.63 63.25,119.63 63.12,119.5 63.12,119.24 v1(63.31,119.05)
  L8 w0.102: v1(63.31,119.05) 63.31,119.06 63.12,119.26 63.12,119.38 63.5,119.76 67.63,119.76 67.81,119.94 70.07,119.94 71.08,118.94 71.08,110.57 69.98,109.47 69.36,109.47 64.41,104.52 51.62,104.52 43.21,96.11 43.21,94.08 44.2,93.09 47.35,93.09 47.85,92.58 47.85,82.96 49.05,81.76 49.05,71.2 46.53,68.68 44.62,68.68 44.37,68.43 44.37,67.53 44.67,67.23 44.86,67.23 v1(45.06,67.03)
SRIO_SGMII_CLKP: length 93
  TOP w0.102: C317.1 45.4,67.69 v1(45.06,67.69) ; v1(62.68,119.06) 62.87,119.26 62.87,119.61 63.15,119.88 64.05,119.88 64.63,120.46 64.63,120.92 64.5,121.05 U15.14
  L8 w0.102: v1(62.68,119.06) 62.87,119.26 62.87,119.49 63.39,120.02 67.53,120.02 67.71,120.19 70.18,120.19 71.33,119.04 71.33,110.47 70.08,109.22 69.47,109.22 64.52,104.27 51.72,104.27 43.46,96.01 43.46,94.19 44.3,93.34 47.45,93.34 48.11,92.69 48.11,83.06 49.3,81.87 49.3,71.09 46.64,68.43 44.73,68.43 44.63,68.33 44.63,67.64 44.78,67.49 44.86,67.49 v1(45.06,67.69)
SRIOSGMIICLKN_C: length 7.9
  TOP w0.102: C319.2 46.55,66.87 46.86,67.18 52.43,67.18 53.04,67.8 53.34,67.8 53.52,67.62 U24.AW35
SRIOSGMIICLKP_C: length 7.9
  TOP w0.102: C317.2 46.55,67.62 46.74,67.44 52.32,67.44 52.93,68.05 53.42,68.05 53.52,68.15 U24.AW34
SW7-P1: length 7.8
  TOP w0.508: R233.1 172.59,121.16 176.75,125.31 ATT.2
SW8-P1: length 6.7
  TOP w0.127: PWR.2 174.71,134.37 R152.1
SYS_CLKN: length 28.4
  TOP w0.102: v1(69.57,109.92) 69.52,109.88 69.52,109.4 69.76,109.16 C179.1 ; U14.15 57.02,129.01 57.08,128.95 57.41,128.95 58.24,128.12 58.37,128.12 v1(58.57,128.32)
  L3 w0.089: v1(69.57,109.92) 69.36,110.13 69.36,110.6 66.17,113.79 65.41,113.79 64.64,114.55 64.64,116.33 65.37,117.06 65.37,119.26 64.71,119.92 64.71,122 63.18,123.53 63.18,124.87 60.08,127.97 58.85,127.97 58.57,128.24 v1(58.57,128.32)
SYS_CLKP: length 28.4
  TOP w0.102: v1(68.93,109.98) 68.93,109.94 69.27,109.61 69.27,109.32 69.11,109.16 C178.1 ; U14.14 56.98,128.51 57.17,128.7 57.3,128.7 58.14,127.86 58.27,127.86 v1(58.57,127.56)
  L3 w0.089: v1(68.93,109.98) 69.15,110.2 69.15,110.51 66.08,113.58 65.32,113.58 64.43,114.46 64.43,116.42 65.15,117.15 65.15,119.18 64.5,119.83 64.5,121.91 62.97,123.44 62.97,124.78 60,127.75 58.76,127.75 v1(58.57,127.56)
SYSCLKN_C: length 14.3
  TOP w0.102: U24.AK3 62.22,99.42 62.12,99.52 62.12,101.86 62.14,101.89 62.14,103.06 63.86,104.78 65.79,104.78 68.07,107.06 69,107.06 69.41,107.46 69.41,108.01 69.65,108.26 C179.2
SYSCLKP_C: length 14.3
  TOP w0.102: U24.AL3 61.81,99.42 61.9,99.51 61.92,99.52 61.92,101.86 61.89,101.89 61.89,103.17 63.75,105.03 65.68,105.03 67.97,107.31 68.9,107.31 69.15,107.57 69.15,108.05 68.93,108.26 C178.2
T_TDIS: length 4.1
  TOP w0.127: R54.1 91.95,151.2 91.95,150.37 92.63,149.68 EMU1.15
TCLKB_N: length 153
  TOP w0.102: AMC1.78 4.77,92.21 5.05,91.92 6.98,91.92 7.39,92.33 9.17,92.33 9.47,92.02 9.47,91.77 v1(9.75,91.49) ; v1(98.02,120.02) 97.92,119.91 97.61,119.91 97.48,120.05 C147.1
  L8 w0.102: v1(9.75,91.49) 9.5,91.24 9.5,85.29 10.39,84.4 10.39,78.96 11.83,77.52 15.21,77.52 23.87,86.18 32.13,86.18 33.65,87.7 33.65,88.76 33.66,88.76 33.66,90.33 34.86,91.53 34.86,96.49 35.19,96.82 35.19,100.44 41.27,106.53 41.27,113.36 43.61,115.7 44.32,115.7 44.53,115.49 45.39,115.49 46.34,116.45 46.34,121.89 47.47,123.02 47.47,123.65 47.82,124 51.24,124 51.92,123.32 59.68,123.32 60.38,122.62 62.09,122.62 63.12,123.64 63.12,126.49 64.14,127.51 69.82,127.51 71.09,128.78 77.24,128.78 78.94,127.07 82.78,127.07 83.01,127.3 90.09,127.3 90.91,126.49 91.93,126.49 92.96,125.45 92.96,124.43 93.45,123.95 93.83,123.95 95.5,122.28 95.5,121.11 96.85,119.76 97.76,119.76 v1(98.02,120.02)
TCLKB_N_C: length 5.1
  TOP w0.127: C147.2 95.9,119.85 95.26,119.85 94.67,120.44 R272.1 94.04,119.89 U19.9
TCLKB_P: length 153
  TOP w0.102: C149.1 97.48,119.56 97.58,119.66 97.74,119.66 v1(98.02,119.38) ; AMC1.77 4.82,91.46 5.03,91.67 7.09,91.67 7.49,92.08 9.06,92.08 9.22,91.92 9.22,91.72 v1(9.04,91.54)
  L8 w0.102: v1(9.04,91.54) 9.25,91.34 9.25,85.18 10.13,84.29 10.13,78.86 11.72,77.27 15.32,77.27 23.98,85.92 32.24,85.92 33.91,87.6 33.91,88.7 33.91,90.22 35.12,91.43 35.12,96.38 35.45,96.71 35.45,100.34 41.53,106.42 41.53,113.25 43.72,115.44 44.22,115.44 44.35,115.31 44.42,115.24 45.5,115.24 46.55,116.29 46.55,121.81 47.73,122.99 47.73,123.55 47.92,123.74 51.14,123.74 51.82,123.06 59.57,123.06 60.27,122.36 62.2,122.36 63.37,123.54 63.37,126.39 64.24,127.25 69.93,127.25 71.2,128.52 77.13,128.52 78.84,126.82 82.88,126.82 83.11,127.05 89.99,127.05 90.8,126.24 91.82,126.24 92.71,125.35 92.71,124.33 93.34,123.7 93.72,123.7 95.25,122.17 95.25,121 96.74,119.51 97.89,119.51 v1(98.02,119.38)
TCLKB_P_C: length 5.1
  TOP w0.127: C149.2 96.01,119.57 95.16,119.57 94.67,119.09 R273.1 94.06,119.61 93.2,119.61 92.98,119.39 U19.8
TCLKC_N: length 6
  BOTTOM w0.127: R740.2 8.31,61.21 6.88,61.21 6.13,60.46 5.1,60.46 4.85,60.71 AMC1.135
TCLKC_P: length 6
  BOTTOM w0.127: R742.1 8.29,60.96 6.99,60.96 6.24,60.21 5.1,60.21 4.85,59.96 AMC1.136
TCLKD_N: length 112.6
  TOP w0.102: v1(58.32,121.18) 58.13,121.37 58.13,122.24 57.38,122.99 54.03,122.99 53.85,123.17 53.85,124.03 53.95,124.13 54.41,124.13 54.61,123.93 C142.1
  L8 w0.102: v1(9.02,59.34) 9.36,59.68 9.36,60.75 10.8,62.19 10.8,74.22 13.26,76.68 15.6,76.68 24.23,85.31 32.42,85.31 34.47,87.36 34.47,87.8 34.47,88.47 35.67,89.68 35.67,95.82 36.04,96.19 36.04,100.15 41.56,105.66 45.72,105.66 48.82,108.76 48.82,112.1 50.13,113.41 57.68,113.41 59.23,114.96 59.23,121.67 58.97,121.92 58.17,121.92 58.01,121.77 58.01,121.35 58.19,121.18 v1(58.32,121.18)
  BOTTOM w0.102: v1(9.02,59.34) 9.24,59.11 9.24,58.95 9.16,58.88 7.62,58.88 6.8,58.06 5.26,58.06 4.87,58.46 AMC1.138
TCLKD_N_C: length 4.3
  TOP w0.127: v1(54.61,125.48) C142.2 54.31,124.78 54.13,124.97 54.13,126.49 54.23,126.59 54.23,127.26
  BOTTOM w0.127: C142.2 v1(54.61,125.48)
TCLKD_P: length 112.6
  TOP w0.102: C141.1 53.59,123.5 53.59,123.06 53.92,122.73 57.28,122.73 57.87,122.14 57.87,121.39 v1(57.63,121.15)
  L8 w0.102: v1(9.65,59.36) 9.61,59.4 9.61,60.65 11.05,62.09 11.05,74.12 13.36,76.43 15.7,76.43 24.33,85.06 32.52,85.06 34.72,87.26 34.72,87.9 34.72,88.37 35.93,89.57 35.93,95.72 36.3,96.08 36.3,100.04 41.67,105.41 45.83,105.41 49.07,108.65 49.07,111.99 50.24,113.16 57.78,113.16 59.48,114.85 59.48,121.77 59.08,122.17 58.06,122.17 57.76,121.87 57.76,121.28 v1(57.63,121.15)
  BOTTOM w0.102: v1(9.65,59.36) 9.49,59.2 9.49,58.85 9.27,58.62 7.72,58.62 6.91,57.81 5.26,57.81 5.16,57.71 AMC1.139
TCLKD_P_C: length 4.3
  TOP w0.127: U14.8 53.73,126.59 53.82,126.5 53.82,125.07 53.54,124.78 C141.2 v1(53.21,125.48)
  BOTTOM w0.127: C141.2 v1(53.21,125.48)
TETRISPLLOBSCLKN: length 15
  TOP w0.102: 93.09,62.23 90.12,62.23 88.9,63.45 88.9,64.04 U24.D38
  TOP w0.127: TP51.1 90.93,55.32 93.4,57.79 93.4,61.92 93.09,62.23
TETRISPLLOBSCLKP: length 13.6
  TOP w0.102: U24.C38 89.9,64.04 90.9,64.04 92.3,62.64 93.18,62.64
  TOP w0.127: TP52.1 92.33,55.63 93.66,56.95 93.66,62.17 93.18,62.64
TIMI_MUX_OEZ: length 124.5
  TOP w0.127: v1(105.92,67.56) 105.92,66.68 107.44,65.15 108.97,65.15 109.65,64.47 109.65,61.89 109.09,61.34 U28.7 107.95,61.34 107.57,60.96 106.93,60.96 106.06,61.84 U28.1
  L3 w0.114: v1(99.69,157.99) 100.26,157.42 100.26,154.67 100.08,154.49 100.08,145.41 105.05,140.44 105.84,140.44 110.97,135.31 110.97,134.52 115.39,130.1 115.39,128.82 116.33,127.88 116.33,117.07 117.73,115.67 117.73,114.17 117.47,113.92 113.44,113.92 112.68,113.16 v1(112.68,112.94)
  L5 w0.114: v1(112.68,112.94) 112.68,112.93 112.68,112.17 111.56,111.06 111.56,106.41 108.83,103.68 108.83,70.73 105.92,67.82 v1(105.92,67.56)
  BOTTOM w0.127: v1(99.69,157.99) 99.69,159.62 97.36,161.95 U47.5
TRGRSTZ: length 76.9
  TOP w0.127: v1(103.89,152.53) 102.8,152.53 R56.1 101.62,152.18 EMU1.6 ; v1(139.7,145.54) 140.31,144.93 140.31,137.84 143.07,135.08 150.26,135.08 150.65,134.68 153.61,134.68 154.31,133.99 155.32,133.99 156.41,135.07 156.41,139.32 U7.39
  L8 w0.114: v1(139.7,145.54) 140.48,146.32 140.48,147.82 136.23,152.07 134.57,152.07 133.68,152.96 109.57,152.96 108.88,152.27 104.14,152.27 v1(103.89,152.53)
TRIP1: length 8.3
  TOP w1.016: ESD1.4 159.21,174.57 R6.2 R5.2 152.09,174.57 R2.1
TRIP2: length 4.7
  TOP w0.508: v3(34.59,174.68) 34.77,174.5 R1.1
  BOTTOM w0.508: ESD1.2 34.5,174.8 34.59,174.71 v3(34.59,174.68)
TRIP3: length 132.9
  TOP w0.508: R2.2 148.97,174.68 147.93,175.72 v1(147.9,175.72)
  L10 w0.508: v3(21.5,175.55) 43.17,175.55 44.89,173.83 47.64,173.83 49.4,175.59 83.57,175.59 85.33,173.83 87.29,173.83 89.11,175.65 143.56,175.65 144.17,175.03 145.8,175.03 146.48,175.72 v1(147.9,175.72)
  BOTTOM w0.508: ESD1.3 v3(21.5,175.55)
TSCOMPOUT_E: length 287.8
  TOP w0.127: v1(28.07,158.83) 28.07,159.81 29.35,161.1 30.53,161.1 30.93,160.7 CN3.116 33.42,160.7 33.76,161.04 35.38,161.04 36.21,160.2 CN3.113 39.22,160.2 39.99,160.97 40.84,160.97 41.58,161.72 v1(41.58,161.75) ; U24.AB1 70.52,102.9 72.77,105.16 72.77,114.68 70.48,116.97 60.2,116.97 57.41,114.18 48.54,114.18 48.27,113.91 44.59,113.91 43.85,114.65 v1(43.85,114.76)
  L3 w0.114: v1(23.15,106.13) 19.99,102.97 18.73,102.97 18.43,102.68 18.43,102.3 20.01,100.72 20.01,95.63 19.49,95.11 18.02,95.11 17.42,94.51 17.42,92.68 19.91,90.19 25.64,90.19 33.59,82.24 33.59,81.67 35.08,80.19 35.08,77.85 35.41,77.52 35.41,76.02 34.12,74.73 25.4,74.73 24.49,73.82 19.93,73.82 19.25,73.15 16.62,73.15 14.57,71.1 14.57,64.24 18.6,60.2 21.62,60.2 22.1,59.72 22.1,57.35 CN17.5 CN17.7
  L8 w0.114: v1(28.07,158.83) 29.26,157.63 29.26,154.48 27.65,152.87 27.65,149.16 32.93,143.88 36.72,143.88 37.63,144.8 40.12,144.8 41.3,143.62 44.76,143.62 45.28,143.11 45.28,140.57 45.85,140 45.85,138.03 47.56,136.32 47.56,130.74 47.01,130.19 47.01,129.45 46.33,128.77 44.96,128.77 43.2,127 42.91,127 38.44,122.53 38.44,117.48 36.41,115.44 32.46,115.44 v1(23.15,106.13)
  L10 w0.114: v1(43.85,114.76) 43.7,114.9 43.7,121.5 43.33,121.87 43.33,123.53 42.78,124.08 42.5,124.08 40.79,125.79 40.79,144.04 39.24,145.58 39.24,150.3 40.5,151.56 40.5,152.85 40.15,153.21 39.82,153.21 39.57,153.47 39.57,157.12 41.7,159.25 41.7,161.63 v1(41.58,161.75)
TSPUSHEVT0: length 175.5
  TOP w0.127: v1(28.04,158.17) 28.51,158.64 28.51,159.9 29.46,160.85 30.42,160.85 31.07,160.2 CN3.114
  L3 w0.114: v1(22.44,106.13) 22.43,106.12 22.43,105.96 19.72,103.25 17.95,103.25 17.37,102.67 17.37,102.31 17.62,102.05 18.34,102.05 19.77,100.62 19.77,95.84 19.29,95.36 17.92,95.36 17.18,94.61 17.18,92.58 19.81,89.95 25.54,89.95 33.35,82.14 33.35,81.5 34.75,80.11 34.75,77.67 35.14,77.28 35.14,76.28 33.86,75.01 25.33,75.01 24.39,74.07 19.83,74.07 19.15,73.39 16.52,73.39 14.33,71.2 14.33,64.13 19.53,58.93 CN17.3
  L8 w0.114: v1(28.04,158.17) 29.02,157.19 29.02,154.58 27.41,152.97 27.41,149.06 33.16,143.32 37.39,143.32 37.65,143.58 37.65,143.98 38.23,144.56 40.02,144.56 41.2,143.38 42.98,143.38 43.93,142.44 43.93,139.6 47.31,136.22 47.31,131.38 46.77,130.83 46.77,129.55 46.23,129.01 44.86,129.01 44.26,128.41 42.06,128.41 41.03,127.37 41.03,125.66 38.2,122.83 38.2,119.38 34.5,115.68 31.12,115.68 25.85,110.42 25.85,109.23 23.3,106.68 22.98,106.68 v1(22.44,106.13)
TSPUSHEVT0_E: length 103.3
  TOP w0.102: U24.AC2 69.52,100.88 69.9,101.26 69.9,103.27 70.64,104.01
  TOP w0.127: CN3.109 39.87,159.2 v2(40.1,159.44) ; 70.64,104.01 72.26,105.64 72.26,114.41 70.34,116.33 60.28,116.33 57.62,113.67 48.9,113.67 48.58,113.35 42.61,113.35 42.42,113.16 v1(42.17,113.16)
  L10 w0.114: v2(40.1,159.44) 40.01,159.34 39.79,159.34 33.5,153.05 33.5,139.69 34.29,138.89 34.42,138.89 37.34,135.98 37.85,135.47 37.85,126.3 38.24,125.9 38.24,125.83 41.13,122.94 41.96,122.94 42.61,122.3 42.61,121.57 42.98,121.2 42.98,115.87 42.17,115.06 v1(42.17,113.16)
TSPUSHEVT1_E: length 105
  TOP w0.102: U24.AC1 69.52,103.25 70.28,104.01
  TOP w0.127: CN3.111 39.31,159.7 39.5,159.89 40.64,159.89 v1(41.02,160.27) ; 70.28,104.01 72.01,105.74 72.01,114.28 70.21,116.08 60.39,116.08 57.73,113.42 49.03,113.42 48.53,112.92 43.89,112.92 43.15,112.17 v1(42.59,112.17)
  L10 w0.114: v1(41.02,160.27) 40.51,159.77 40.51,159.12 35.17,153.77 35.17,150.27 33.74,148.84 33.74,139.79 34.39,139.13 34.52,139.13 37.44,136.22 38.1,135.56 38.1,126.38 38.48,126 38.48,125.93 39.72,124.69 41.1,124.69 42.04,123.75 42.04,123.21 42.85,122.4 42.85,121.67 43.22,121.3 43.22,115.77 42.6,115.16 42.6,112.97 42.53,112.89 42.53,112.24 v1(42.59,112.17)
TSRX_CLK0N: length 75.2
  TOP w0.102: v2(58.02,101.92) 58.43,101.92 58.52,101.83 U24.AP1 ; CN3.101 39.32,157.2 39.47,157.35 39.8,157.35 39.95,157.51 41.63,157.51 41.78,157.35 42.59,157.35 43.25,156.69 45.8,156.69 v1(46.05,156.44)
  L10 w0.089: v1(46.05,156.44) 46.24,156.63 46.41,156.63 46.61,156.43 46.61,155.6 44.56,153.56 44.56,150.96 45.66,149.87 45.66,146.56 48.68,143.54 48.68,140.68 49.95,139.41 49.95,137.12 47.75,134.93 47.75,130.43 47.51,130.19 47.51,129.5 47.92,129.1 47.92,125.59 46.02,123.69 46.02,122.76 46.74,122.05 46.74,114.15 58.49,102.4 58.49,102.01 58.4,101.92 v2(58.02,101.92)
TSRX_CLK0P: length 75.1
  TOP w0.102: U24.AN1 v2(59.02,101.92) ; v1(46.08,157.07) 45.95,156.95 43.36,156.95 42.7,157.61 41.88,157.61 41.73,157.76 39.85,157.76 39.7,157.61 39.45,157.61 39.35,157.7 CN3.103
  L10 w0.089: v2(59.02,101.92) 58.81,101.92 58.7,102.03 58.7,102.49 46.95,114.24 46.95,122.14 46.24,122.85 46.24,123.6 48.13,125.5 48.13,129.19 47.73,129.59 47.73,130.1 47.97,130.34 47.97,134.84 50.16,137.03 50.16,139.5 48.9,140.77 48.9,143.63 45.87,146.65 45.87,149.96 44.78,151.05 44.78,153.47 46.82,155.51 46.82,156.52 46.5,156.84 46.3,156.84 v1(46.08,157.07)
TSRX_CLK1N: length 76.3
  TOP w0.102: v1(43.71,158.04) 43.48,158.27 42.16,158.27 42.08,158.34 39.54,158.34 39.4,158.2 CN3.105 ; U24.AP3 58.52,99.24 58.7,99.06 58.93,99.06 59.03,99.16 59.03,99.8 v2(58.9,99.92)
  L10 w0.089: v1(43.71,158.04) 43.89,158.22 44.32,158.22 44.55,157.99 44.55,155.47 43.18,154.1 43.18,150.57 44.87,148.88 44.87,146.27 47.75,143.39 47.75,136 46.99,135.24 46.99,130.74 46.75,130.5 46.75,129.19 47.16,128.78 47.16,125.95 45.26,124.05 45.26,117.67 45.61,117.32 45.61,114.19 57.11,102.69 57.11,101.89 57.67,101.33 57.97,101.33 58.34,100.97 58.34,100.65 58.57,100.42 58.86,100.42 58.95,100.33 58.95,99.97 v2(58.9,99.92)
TSRX_CLK1P: length 76.3
  TOP w0.102: v2(58.96,100.99) 58.96,100.76 59.11,100.62 59.11,100.28 59.52,99.87 U24.AN3 ; CN3.107 39.45,158.7 39.55,158.6 42.19,158.6 42.27,158.52 43.56,158.52 v1(43.71,158.67)
  L10 w0.089: v1(43.71,158.67) 43.95,158.43 44.41,158.43 44.77,158.08 44.77,155.38 43.4,154.01 43.4,150.66 45.09,148.97 45.09,146.36 47.97,143.48 47.97,135.91 47.21,135.15 47.21,130.65 46.96,130.41 46.96,129.28 47.37,128.87 47.37,125.86 45.48,123.96 45.48,117.76 45.83,117.41 45.83,114.28 57.33,102.78 57.33,101.98 57.76,101.55 58.06,101.55 58.55,101.06 58.55,100.74 58.65,100.63 58.86,100.63 58.96,100.74 v2(58.96,100.99)
TSSYNCEVT_E: length 102.4
  TOP w0.102: U24.AC3 69.52,99.42 70.1,100.01 70.1,103.12 71,104.01
  TOP w0.127: v1(43.87,113.97) 44.19,113.65 48.37,113.65 48.65,113.93 57.52,113.93 60.25,116.66 70.41,116.66 72.52,114.55 72.52,105.53 71,104.01 ; CN3.115 39.36,160.7 39.88,161.23 40.49,161.23 40.93,161.67 40.93,161.7 v1(40.94,161.71)
  L10 w0.114: v1(43.87,113.97) 43.41,114.44 43.41,115.62 43.46,115.67 43.46,121.4 43.09,121.77 43.09,122.5 42.28,123.31 42.28,123.85 40.54,125.59 40.54,143.94 39,145.48 39,150.4 40.26,151.66 40.26,152.03 39.97,152.32 39.8,152.32 39.33,152.79 39.33,157.22 41.46,159.35 41.46,161.18 40.94,161.7 v1(40.94,161.71)
TX_CLK: length 4.6
  BOTTOM w0.127: R601.2 138.68,104.95 PHY2.D1
TX_CLK_0: length 5.4
  BOTTOM w0.127: R677.2 138.68,79.25 139.42,78.51 140.73,78.51 PHY1.D1
TX_EN: length 4.5
  BOTTOM w0.127: R600.2 140.08,105.11 142.15,103.04 PHY2.E1
TX_EN_0: length 4.5
  BOTTOM w0.127: PHY1.E1 142.15,79.7 140.14,81.71 R676.2
TX_ER: length 9.1
  BOTTOM w0.127: R591.2 140.84,108.53 140.84,104.9 142.62,103.12 142.62,102.11 143.15,101.58 PHY2.F2
TX_ER_0: length 9.1
  BOTTOM w0.127: R662.2 140.84,84.13 140.84,81.56 142.62,79.78 142.62,77.71 143.15,77.19 PHY1.F2
TXD0: length 4.3
  BOTTOM w0.127: PHY2.F1 143.15,103.13 141.48,104.8 R599.2
TXD0_0: length 4.3
  BOTTOM w0.127: PHY1.F1 143.15,79.76 141.48,81.43 R675.2
TXD1: length 5.5
  BOTTOM w0.102: 143.85,103.49 144.53,102.82 144.53,101.87 PHY2.G2
  BOTTOM w0.127: 143.85,103.49 142.88,104.47 R598.2
TXD1_0: length 5.5
  BOTTOM w0.102: 144.02,79.1 144.53,78.59 144.53,77.84 144.15,77.46 PHY1.G2
  BOTTOM w0.127: 144.02,79.1 144.02,80.52 142.88,81.66 R674.2
TXD2: length 9.9
  BOTTOM w0.127: R595.2 142.11,108.65 142.11,104.67 143.64,103.15 143.64,101.09 144.15,100.58 PHY2.G3
TXD2_0: length 9.9
  BOTTOM w0.127: PHY1.G3 144.15,76.19 143.64,76.7 143.64,79.91 142.11,81.43 142.11,84.26 R666.2
TXD3: length 8.6
  BOTTOM w0.127: PHY2.H2 145.67,102.02 145.67,103.33 144.91,104.09 144.91,108.65 R593.2
TXD3_0: length 8.5
  BOTTOM w0.127: PHY1.H2 145.18,77.1 145.54,77.46 145.54,80.54 144.91,81.18 144.91,84.26 R664.2
TXD4: length 4
  BOTTOM w0.127: PHY2.H1 145.14,103.37 144.27,104.24 R597.2
TXD4_0: length 4
  BOTTOM w0.127: R673.2 144.27,81.31 145.14,80.43 PHY1.H1
TXD5: length 9.7
  BOTTOM w0.102: PHY2.H3 144.73,100.91 144.73,103.14 144.37,103.49
  BOTTOM w0.127: 144.37,103.49 143.51,104.36 143.51,108.65 R594.2
TXD5_0: length 9.7
  BOTTOM w0.102: 144.53,79.1 144.73,78.9 144.73,76.5 145.13,76.1 PHY1.H3
  BOTTOM w0.127: 144.53,79.1 144.53,80.52 143.51,81.54 143.51,84.26 R665.2
TXD6: length 3.8
  BOTTOM w0.127: PHY2.J1 146.14,105.63 R596.2
TXD6_0: length 3.8
  BOTTOM w0.127: PHY1.J1 146,78.24 146,81.38 R672.2
TXD7: length 8.3
  BOTTOM w0.102: 146.43,103.49 146.43,103.25 146.56,103.12 146.56,102.18 146.14,101.77 PHY2.J2
  BOTTOM w0.127: 146.43,103.49 146.43,108.53 R590.2
TXD7_0: length 8.3
  BOTTOM w0.102: 146.3,79.1 146.3,78.64 146.56,78.38 146.56,77.51 PHY1.J2
  BOTTOM w0.127: 146.3,79.1 146.3,84.26 R661.2
UART0_TXD_R: length 8.6
  TOP w0.102: U24.K2 82.52,100.42 82.9,100.8 82.9,103.41 82.3,104.01
  TOP w0.127: R315.1 81.53,106.04 82.3,105.28 82.3,104.01
UART1_RTS_R: length 11.4
  TOP w0.102: U24.M5 80.58,97.42 v2(81.03,97.87)
  BOTTOM w0.127: v2(81.03,97.87) 80.89,98.01 80.89,102.35 81.53,103 R619.1
UART1_RXD_M: length 19.7
  TOP w0.102: v2(82.02,100.92) 81.52,100.42 U24.L2
  TOP w0.127: v1(77.74,114.94) 79.32,114.94 79.84,115.45 U21.5
  L3 w0.102: v2(82.02,100.92) 82.02,101.72 82.12,101.82 82.12,102.27 81.9,102.49 81.53,102.49 80.01,104.01
  L3 w0.114: v1(77.74,114.94) 77.37,114.56 77.37,106.98 79.25,105.11 79.25,104.78 80.01,104.01
UART1_TXD_R: length 9.2
  TOP w0.102: U24.K3 82.52,99.42 83.13,100.04 83.13,103.76 82.88,104.01
  TOP w0.127: 82.88,104.01 82.8,104.09 R316.1
UCD9244_EN: length 14.4
  TOP w0.254: R267.2 121.92,114.75 126.94,114.75 v1(127.31,115.12) ; R245.1 127.69,118.8 v1(128.17,119.28)
  L3 w0.254: v1(128.17,119.28) 127.31,118.42 v1(127.31,115.12)
UCD9244_EN_R: length 2.4
  TOP w0.254: U13.4 128.16,120.36 R245.2
UCD_PWR_MON: length 5.8
  TOP w0.127: U13.2 127.16,121.14 126.8,120.78 125.11,120.78 124.71,120.38 R244.1 125.08,119.7 v1(125.39,120.02)
  BOTTOM w0.127: v1(125.39,120.02) 125.08,119.7 R244.1
UCD_PWR_OK: length 274.9
  TOP w0.127: R244.2 124.71,118.39 127.89,115.21 127.89,114.97 128.16,114.69 129.6,114.69 v1(130.05,115.14) ; U25.24 32.97,81.03 33.7,81.75 v1(34.14,81.75) 34.14,81.7 34.8,81.04 34.8,79.31 R359.1
  L3 w0.114: v1(34.14,81.75) 36.13,79.77 36.13,76.29 36.91,75.51 36.91,74.65 36.73,74.47 25.48,74.47 24.59,73.58 20.03,73.58 19.35,72.9 16.72,72.9 14.86,71.05 14.86,64.34 18.76,60.44 21.72,60.44 22.34,59.82 22.34,49.52 26.42,45.44 26.42,42.44 27.08,41.78 27.08,40.31 26.67,39.9 26.67,33.27 28.23,31.72 107.32,31.72 107.84,32.24 111.61,36 111.61,41.83 113.39,43.61 127.45,43.61 132.95,49.11 132.95,69.06 132.41,69.6 132.41,83.06 131.75,83.72 131.75,111.94 130.05,113.64 v1(130.05,115.14)
URTM_PS#: length 195.5
  L8 w0.114: v1(20.85,108) 21.2,108 29.12,115.93 34.4,115.93 37.71,119.23 37.71,127.07 39.49,128.86 41.73,128.86 42.12,129.24 44.12,129.24 44.72,129.85 46.26,129.85 46.53,130.12 46.53,130.93 47.07,131.48 47.07,136.12 43.69,139.5 43.69,141.2 42.52,142.37 41.87,142.37 39.92,144.32 38.33,144.32 37.93,143.92 37.93,143.51 37.49,143.08 33.06,143.08 27.17,148.96 27.17,153.07 28.78,154.68 28.78,155.75 v1(28.4,156.13)
  BOTTOM w0.127: v1(28.4,156.13) 28.35,156.18 28.33,156.18 27.19,157.32 27.19,159.12 30.42,162.34 30.42,163.3 30.81,163.69 33.21,163.69 34.68,165.16 36.82,165.16 36.85,165.2 77.55,165.2 85.62,157.12 87.1,157.12 97.89,146.33 97.89,135.63 99.07,134.46 99.07,129.59 98.69,129.22 98.69,128.95 98.49,128.74 98.49,125.39 98.8,125.08 100.74,125.08 101.02,124.79 101.76,124.79 U53.28 ; v1(20.85,108) 20.58,108.27 R557.1 R555.2
URTM_PS#_R: length 7.9
  BOTTOM w0.127: J1.C1 16.14,113.17 16.87,113.17 18.16,111.88 R555.1
USB0V85: length 6.8
  TOP w0.381: v2(72.97,90.96) 72.52,91.41 U24.Y11 U24.AA12
  L8 w0.381: v2(72.02,94.92) 73.44,93.5 73.44,91.42 v2(72.97,90.96)
  vias: v1(37.75,97.95) v1(38.39,97.91) v1(49.53,94.82) v1(50.06,94.28)
USB_CLKN: length 18.8
  TOP w0.102: U19.28 84.53,119.89 84.48,119.84 83.82,119.84 v1(83.62,120.04)
  BOTTOM w0.102: R608.1 76.75,109.16 77.04,109.45 77.04,118.47 78,119.43 81.71,119.43 82.17,119.89 83.46,119.89 v1(83.62,120.04)
USB_CLKN_R: length 11.6
  TOP w0.102: v2(74.05,99.92) 74.05,100.04 74.44,100.42 74.52,100.42 U24.V2
  BOTTOM w0.102: R608.2 76.78,108.26 76.96,108.08 76.96,107.04 74.38,104.46 74.38,101.78 74.15,101.54 73.75,101.54 73.41,101.2 73.41,100.43 73.65,100.19 73.83,100.19 74.05,99.96 v2(74.05,99.92)
USB_CLKP: length 18.8
  TOP w0.102: v1(83.62,119.28) 83.62,119.51 83.69,119.58 84.43,119.58 84.62,119.39 U19.29
  BOTTOM w0.102: R607.1 77.5,109.16 77.29,109.37 77.29,118.36 78.11,119.18 81.82,119.18 82.27,119.63 83.41,119.63 83.62,119.43 v1(83.62,119.28)
USB_CLKP_R: length 11.6
  TOP w0.102: v2(74.04,100.76) 74.04,100.43 73.91,100.3 73.64,100.3 U24.W2
  BOTTOM w0.102: R607.2 77.46,108.26 77.22,108.01 77.22,106.93 74.64,104.35 74.64,101.67 74.25,101.29 73.86,101.29 73.66,101.09 73.66,100.53 73.75,100.44 73.93,100.44 74.04,100.55 v2(74.04,100.76)
USB_DM1: length 16.3
  TOP w0.127: U3.7 159.38,164.6 159.5,164.72 159.77,164.72 160.66,163.83 167,163.83 167.49,164.32 167.49,164.77 167.54,164.82 167.77,164.82 v1(167.97,164.62) 168.17,164.82 168.38,164.82 168.48,164.72 D1.2 ; v1(170.81,164.62) 170.84,164.59 FTDI_USB.2
  BOTTOM w0.127: v1(170.81,164.62) 170.6,164.83 168.18,164.83 v1(167.97,164.62)
USB_DP1: length 16.3
  TOP w0.127: U3.8 159.38,165.1 159.51,164.97 159.87,164.97 160.76,164.08 166.89,164.08 167.23,164.43 167.23,164.87 167.44,165.07 167.77,165.07 v1(167.96,165.27) 168.15,165.07 168.38,165.07 168.52,165.22 D1.1 ; FTDI_USB.3 170.83,165.39 v1(170.79,165.35)
  BOTTOM w0.127: v1(167.96,165.27) 168.14,165.08 170.52,165.08 v1(170.79,165.35)
USB_RXN: length 107.3
  TOP w0.102: B22.1 160.99,116.25 arc(160.9,116.23) 160.83,116.19 160.79,116.14 arc(160.69,116.08) 160.58,116.05 arc(160.51,116.04) 160.44,116.02 arc(160.4,115.99) 160.36,115.96 160.34,115.94 arc(160.24,115.8) 160.21,115.64 160.21,115.28 arc(160.16,115.15) 160.03,115.1 159.92,115.1 arc(159.81,115.12) 159.72,115.18 159.72,115.18 arc(159.66,115.27) 159.64,115.38 v1(159.64,115.47) ; v2(73.02,101.92) 73.02,101.92 72.52,101.42 U24.Y1
  L10 w0.114: v1(159.64,115.47) 159.64,115.44 159.47,115.28 arc(159.29,115.16) 159.08,115.11 158.38,115.11 arc(157.99,115.19) 157.67,115.4 arc(157.35,115.62) 156.97,115.7 154.85,115.7 arc(153.88,115.89) 153.05,116.44 152.72,116.78 arc(151.89,117.33) 150.92,117.52 139.96,117.52 arc(139.38,117.4) 138.88,117.07 arc(138.54,116.84) 138.14,116.76 122.85,116.76 arc(122.39,116.86) 122,117.12 arc(121.6,117.38) 121.14,117.47 117.57,117.47 116.72,117.47 arc(116.55,117.51) 116.41,117.6 arc(116.27,117.7) 116.1,117.73 110.43,117.73 arc(110.13,117.79) 109.88,117.96 arc(109.71,118.21) 109.65,118.51 109.65,118.52 arc(109.44,119.58) 108.84,120.49 107.47,121.85 arc(107.04,122.14) 106.53,122.24 106.33,122.24 arc(106.15,122.27) 105.99,122.38 105.39,122.98 arc(104.57,123.53) 103.6,123.72 103.39,123.72 arc(103.11,123.67) 102.88,123.51 arc(102.8,123.46) 102.71,123.44 99.95,123.44 arc(99.52,123.36) 99.15,123.11 arc(98.94,122.97) 98.69,122.92 98.27,122.92 arc(97.78,122.83) 97.37,122.55 97.2,122.38 arc(96.99,122.21) 96.74,122.08 96.59,122.01 arc(96.49,121.98) 96.38,121.97 95.97,121.97 arc(95.51,121.88) 95.11,121.61 94.97,121.48 arc(94.59,121.22) 94.13,121.13 93.58,121.13 arc(93.29,121.07) 93.04,120.9 92.68,120.54 arc(92.51,120.3) 92.46,120 92.46,117.31 arc(92.3,116.51) 91.85,115.84 arc(91.17,115.39) 90.38,115.23 86.8,115.23 arc(86.32,115.13) 85.92,114.86 arc(85.65,114.46) 85.56,113.99 85.56,113.54 arc(85.48,113.13) 85.24,112.78 83.87,111.4 arc(83.04,110.85) 82.07,110.66 80.88,110.66 arc(79.84,110.45) 78.97,109.86 arc(78.25,109.38) 77.4,109.21 77.18,109.21 arc(76.12,109) 75.22,108.4 arc(74.62,107.51) 74.41,106.45 74.41,104.84 arc(74.36,104.47) 74.23,104.13 arc(74.11,103.94) 73.97,103.77 arc(73.53,103.13) 73.38,102.36 arc(73.38,102.33) 73.38,102.29 73.39,102.29 73.39,102.24 arc(73.38,102.19) 73.35,102.16 73.19,101.99 arc(73.11,101.94) 73.02,101.92 v2(73.02,101.92)
USB_RXN_R: length 4.6
  TOP w0.102: SOC_USB.5 165.62,114.76 arc(165.58,114.58) 165.48,114.43 arc(165.33,114.32) 165.14,114.29 164.96,114.29 arc(164.75,114.33) 164.57,114.45 164.52,114.5 arc(164.41,114.67) 164.36,114.88 164.36,115.34 arc(164.32,115.58) 164.18,115.78 arc(163.98,115.91) 163.75,115.96 163.61,115.96 arc(163.48,115.98) 163.37,116.06 163.32,116.1 arc(163.16,116.21) 162.97,116.25 B22.4
USB_RXP: length 107.3
  TOP w0.102: v1(159.64,114.45) 159.64,114.67 arc(159.7,114.82) 159.85,114.88 159.85,114.89 arc(159.86,114.89) 159.86,114.89 arc(159.89,114.89) 159.92,114.88 160.03,114.88 arc(160.31,115) 160.43,115.28 160.43,115.64 arc(160.44,115.72) 160.48,115.78 160.52,115.81 arc(160.53,115.82) 160.54,115.83 arc(160.56,115.83) 160.58,115.84 arc(160.6,115.84) 160.63,115.84 160.63,115.84 160.67,115.84 arc(160.74,115.83) 160.79,115.79 161.06,115.52 arc(161.07,115.5) 161.08,115.48 B22.2 ; v2(73.99,101.92) 73.77,101.92 arc(73.59,101.85) 73.52,101.67 U24.W1
  L10 w0.114: v2(73.99,101.92) 73.96,101.92 arc(73.92,101.93) 73.9,101.95 73.73,102.12 arc(73.65,102.23) 73.62,102.36 arc(73.76,103.03) 74.14,103.6 arc(74.31,103.8) 74.44,104.01 arc(74.6,104.41) 74.65,104.84 74.65,106.45 arc(74.84,107.41) 75.39,108.23 arc(76.21,108.78) 77.18,108.97 77.4,108.97 arc(78.34,109.16) 79.14,109.69 arc(79.94,110.23) 80.88,110.41 82.07,110.41 arc(83.13,110.63) 84.04,111.23 85.41,112.61 arc(85.7,113.04) 85.8,113.54 85.8,113.99 arc(85.88,114.37) 86.09,114.69 arc(86.42,114.91) 86.8,114.99 90.38,114.99 arc(91.27,115.16) 92.02,115.67 arc(92.52,116.42) 92.7,117.31 92.7,120 arc(92.74,120.2) 92.85,120.37 93.21,120.73 arc(93.38,120.85) 93.58,120.89 94.13,120.89 arc(94.68,121) 95.15,121.31 95.28,121.44 arc(95.6,121.65) 95.97,121.73 96.38,121.73 arc(96.53,121.74) 96.68,121.79 96.84,121.85 arc(97.12,122) 97.37,122.21 97.54,122.38 arc(97.87,122.6) 98.27,122.68 98.69,122.68 arc(99.03,122.75) 99.32,122.94 arc(99.61,123.14) 99.95,123.2 102.71,123.2 arc(102.89,123.24) 103.05,123.34 arc(103.2,123.45) 103.39,123.48 103.6,123.48 arc(104.48,123.31) 105.22,122.81 105.82,122.21 arc(106.06,122.05) 106.33,122 106.53,122 arc(106.95,121.91) 107.3,121.68 108.67,120.31 arc(109.22,119.49) 109.41,118.52 109.41,118.51 arc(109.49,118.12) 109.71,117.79 arc(110.04,117.57) 110.43,117.49 116.1,117.49 arc(116.18,117.47) 116.24,117.43 arc(116.46,117.28) 116.72,117.23 117.67,117.23 121.14,117.23 arc(121.51,117.16) 121.83,116.95 arc(122.3,116.63) 122.85,116.52 138.14,116.52 arc(138.63,116.62) 139.05,116.9 arc(139.47,117.18) 139.96,117.28 150.92,117.28 arc(151.8,117.1) 152.55,116.6 152.88,116.27 arc(153.78,115.67) 154.85,115.46 156.97,115.46 arc(157.25,115.4) 157.5,115.23 arc(157.9,114.97) 158.38,114.87 159.06,114.87 arc(159.33,114.82) 159.55,114.67 arc(159.62,114.57) v1(159.64,114.45)
USB_RXP_R: length 4.6
  TOP w0.102: SOC_USB.6 165.62,113.66 165.58,113.77 arc(165.48,113.91) 165.34,114 165.22,114.05 arc(165.17,114.07) 165.12,114.07 164.96,114.07 arc(164.67,114.13) 164.42,114.29 164.37,114.34 arc(164.21,114.59) 164.15,114.88 164.15,115.34 arc(164.12,115.49) 164.03,115.62 arc(163.9,115.71) 163.75,115.74 163.58,115.74 arc(163.43,115.71) 163.3,115.63 163.27,115.59 arc(163.11,115.49) B22.3
USB_TXN: length 108.7
  TOP w0.102: C839.2 161.6,107.04 arc(161.58,106.95) 161.53,106.87 161.52,106.86 arc(161.45,106.81) 161.36,106.79 161.27,106.79 arc(161.11,106.83) 160.98,106.92 arc(160.89,107.05) 160.86,107.21 160.86,107.8 arc(160.82,107.96) 160.73,108.1 arc(160.59,108.2) 160.43,108.23 160.14,108.23 arc(159.96,108.27) 159.8,108.37 159.72,108.45 arc(159.68,108.51) 159.66,108.59 v1(159.66,108.66) ; v2(75.02,102.2) 75.02,101.75 arc(75.01,101.7) 75,101.65 74.97,101.59 arc(74.91,101.5) 74.82,101.44 74.82,101.44 arc(74.78,101.43) 74.75,101.42 U24.V1
  L10 w0.114: v2(75.02,102.2) arc(75.28,102.31) 75.38,102.57 arc(75.43,102.97) 75.65,103.3 76.45,104.1 arc(76.47,104.14) 76.48,104.19 76.48,105.46 arc(76.55,105.8) 76.74,106.09 arc(77.03,106.28) 77.37,106.35 78.45,106.35 arc(78.73,106.38) 79.01,106.46 79.3,106.58 arc(79.68,106.84) 79.94,107.22 arc(80,107.52) 80.16,107.77 80.22,107.83 arc(80.54,108.04) 80.92,108.12 82.61,108.12 arc(83.49,108.29) 84.23,108.79 84.78,109.34 arc(84.86,109.46) 84.89,109.6 arc(84.96,109.95) 85.16,110.25 86.48,111.57 arc(87.38,112.17) 88.44,112.38 89.24,112.38 arc(90.01,112.23) 90.66,111.79 arc(91.04,111.54) 91.48,111.46 arc(91.66,111.49) 91.81,111.59 arc(91.91,111.75) 91.95,111.93 91.95,112.17 arc(92.03,112.55) 92.24,112.88 95.4,116.04 arc(95.5,116.18) 95.53,116.35 arc(95.58,116.58) 95.71,116.77 96.08,117.14 arc(96.48,117.75) 96.62,118.46 96.62,118.7 arc(96.79,119.53) 97.26,120.23 97.57,120.54 arc(97.63,120.59) 97.69,120.62 97.84,120.72 arc(97.92,120.77) 98.01,120.81 98.64,121.07 arc(98.83,121.13) 99.02,121.15 99.69,121.15 arc(99.98,121.2) 100.23,121.37 arc(100.47,121.53) 100.76,121.59 102.94,121.59 arc(103.17,121.52) 103.33,121.34 103.43,121.1 arc(103.57,120.91) 103.77,120.79 105.08,120.79 arc(105.15,120.78) 105.23,120.76 105.26,120.75 arc(105.38,120.67) 105.46,120.55 105.53,120.4 arc(105.57,120.29) 105.59,120.17 105.59,117.93 arc(105.73,117.2) 106.14,116.59 arc(106.75,116.18) 107.47,116.04 114.66,116.04 arc(114.89,116.02) 115.11,115.95 arc(115.41,115.87) 115.72,115.85 118.24,115.85 119.95,115.85 arc(120.93,115.66) 121.75,115.11 121.79,115.07 arc(122.61,114.52) 123.58,114.33 148.86,114.33 arc(149.83,114.13) 150.65,113.58 151.53,112.71 arc(152.35,112.16) 153.33,111.96 156.03,111.96 arc(156.92,111.78) 157.68,111.28 arc(158.19,110.52) 158.37,109.62 158.37,108.93 arc(158.42,108.68) 158.56,108.47 arc(158.77,108.33) 159.02,108.28 159.19,108.28 arc(159.35,108.31) 159.48,108.4 159.61,108.53 arc(159.65,108.59) v1(159.66,108.66)
