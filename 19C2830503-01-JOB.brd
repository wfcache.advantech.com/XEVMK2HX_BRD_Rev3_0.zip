# Allegro board 19C2830503-01-JOB.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
EMIFD1: length 160.7
  TOP w0.102: v2(84.02,64.92) 83.52,65.42 U24.J37
  TOP w0.127: v2(46.07,129.43) U65.3
  L5 w0.114: v2(84.02,64.92) 83.53,64.42 83,64.42 82.41,63.83 82.41,63.77 82.07,63.43 81.99,63.43 81.65,63.09 81.65,61.69 78.18,58.22 74.27,58.22 73.82,58.67 72.87,58.67 72.69,58.49 68.08,58.49 67.03,57.44 57.35,57.44 51.88,62.91 49.08,62.91 47.57,64.41 46.6,64.41 42.8,68.21 42.8,69.63 40.42,72.01 39.35,72.01 38.79,72.57 38.79,73.26 37.17,74.88 37.17,75.23 34.75,77.66 34.75,88.57 33.91,89.41 33.91,90.04 36,92.14 36,100.7 37,101.69 37,114.06 39.22,116.28 39.22,122.94 38.8,123.35 38.8,126.31 v2(38.86,126.37)
  L8 w0.114: v2(38.86,126.37) 39.58,126.37 41.86,128.65 43.86,128.65 44.65,129.43 v2(46.07,129.43)
  L10 w0.114: v2(38.86,126.37) 38.86,140.47 40.06,141.67 40.06,143.53 38.51,145.08 38.51,150.6 38.58,150.67 38.58,156.84 40.91,159.17 40.91,159.39 v2(40.93,159.41)
  BOTTOM w0.102: NAND1.J4 40.58,159.06 v2(40.93,159.41)
EMIFD2: length 136.2
  TOP w0.102: U24.L33 81.98,68.96 v2(82.04,68.96)
  TOP w0.127: v2(45.67,128.27) 45.67,128.44 46.49,129.26 46.49,129.61 46.24,129.86 45.72,129.86 45.64,129.93 U65.4
  L5 w0.102: 57.34,69.79 57.85,70.3 58.17,70.3 58.4,70.08 58.4,69.92 58.77,69.55 59.78,69.55 59.79,69.54 62.17,69.54 62.2,69.57 63.19,69.57 63.9,70.28 65.18,70.28 65.66,69.8 65.66,69.77 65.88,69.55 78.17,69.55 79.18,70.56 80.95,70.56 82.04,69.47 v2(82.04,68.96)
  L5 w0.114: 57.34,69.79 57.09,69.55 56.74,69.55 56.51,69.77 56.51,69.98 56.18,70.31 52,70.31 49.39,72.92 49.39,74.58 46.49,77.48 46.49,99.13 48.51,101.15 48.51,111.52 46.51,113.53 46.51,121.99 45.75,122.75 45.75,123.59 45.56,123.78 45.56,128.16 v2(45.67,128.27)
  L10 w0.114: v2(45.67,128.27) 45.67,128.95 45.45,129.18 45.45,132.57 45.71,132.83 45.71,137.74 46.44,138.48 46.44,142.63 44.88,144.19 44.55,144.19 44.03,144.7 43.15,144.7 42.6,145.26 41.86,145.26 41.14,145.99 41.14,150.49 41.71,151.06 41.71,152.19 42.29,152.77 42.29,156.7 42.53,156.95 v2(42.53,159.31)
  BOTTOM w0.102: v2(42.53,159.31) 42.46,159.39 41.73,159.39 NAND1.K4
EMIFD3: length 139.6
  TOP w0.102: v2(81.99,67.94) 81.99,67.95 U24.L34
  TOP w0.127: U65.5 45.84,130.43 46,130.28 v2(46.1,130.28)
  L5 w0.102: v2(81.99,67.94) 81.56,67.94 81,68.51 79.56,68.51 79.35,68.3 78.86,68.3 78.64,68.08 78.64,68 78.14,67.51 77.78,67.51 77.61,67.34 66.48,67.34 66.3,67.51 52.92,67.51 52.06,68.38
  L5 w0.114: 52.06,68.38 48.37,72.06 48.37,74.23 45.43,77.18 45.43,85.55 42.48,88.5 42.48,95.89 41.67,96.7 41.67,113.54 43.37,115.24 43.37,116.11 45.52,118.26 45.52,121.96 45.11,122.36 45.04,122.36 44.25,123.15 44.25,125.8 43.25,126.8 41.63,126.8 41.48,126.95 41.48,127.91 42.08,128.52 44.07,128.52 45.83,130.28 v2(46.1,130.28)
  L10 w0.114: v1(42.77,156.56) 42.77,155.89 42.54,155.66 42.54,152.68 41.95,152.09 41.95,150.96 41.38,150.39 41.38,149.76 41.75,149.38 41.75,148.54 42.01,148.28 42.86,148.28 43.43,147.7 43.43,146.54 46.74,143.24 46.74,138.37 45.95,137.59 45.95,132.69 45.69,132.43 45.69,130.69 v2(46.1,130.28)
  BOTTOM w0.102: NAND1.K5 42.55,158.24 42.77,158.01 v1(42.77,156.56)
EMIFD4: length 169.6
  TOP w0.102: U24.H39 84.82,63.12 v2(84.82,62.86)
  TOP w0.127: U65.6 45.98,130.93 46.05,130.86 v2(46.1,130.86)
  L5 w0.102: 84.45,61.59 84.45,61.67 84.67,61.89 84.82,62.03 v2(84.82,62.86)
  L5 w0.114: 84.45,61.59 84.45,57.93 82.12,55.59 57.14,55.59 51.33,61.4 39.87,61.4 37.01,64.27 37.01,70.45 35.46,72 35.46,73.29 31.2,77.55 31.2,88.33 31.99,89.13 31.99,90.42 32.65,91.08 32.65,105.53 32.24,105.94 32.24,113.14 37.64,118.54 37.64,121.79 37.48,121.95 37.48,127.1 37.74,127.35 37.74,130.74 40.1,133.1 41.82,133.1 v2(41.91,133.18)
  L10 w0.114: v2(41.91,133.18) 41.75,133.18 41.59,133.34 41.59,137.43 43.54,139.39 43.54,142.82 42.72,143.65 41.51,143.65 41.03,144.13 41.03,144.14 40.17,144.99 40.17,149.55 40.11,149.61 40.11,150.83 40.74,151.46 40.74,152.95 40.44,153.26 40.44,153.83 40.2,154.08 40.2,154.49 40.56,154.85 40.56,156.7 v2(40.92,157.05)
  BOTTOM w0.102: NAND1.K6 41,157.05 v2(40.92,157.05)
  BOTTOM w0.127: v2(41.91,133.18) 42.96,132.13 44.12,132.13 45.38,130.86 v2(46.1,130.86)
EMIFD5: length 164.7
  TOP w0.102: U24.J38 84,63.94 v2(84,63.91)
  TOP w0.127: v2(46.35,131.69) 46.1,131.43 U65.7
  L5 w0.102: 83.26,61.59 83.57,61.9 83.57,63.47 v2(84,63.91)
  L5 w0.114: v1(39.72,130.89) 39.68,130.86 38.79,130.86 38.22,130.3 38.22,127.15 37.97,126.9 37.97,122.15 38.49,121.62 38.49,116.58 33.85,111.94 33.85,106.81 36.22,104.44 36.22,101.94 35.18,100.9 35.18,92.58 32.72,90.12 32.72,87.53 32,86.82 32,77.77 36.23,73.53 36.23,72.25 37.73,70.75 37.73,64.9 40.5,62.13 51.63,62.13 57.05,56.71 67.66,56.71 67.9,56.95 72.83,56.95 73.04,57.16 78.83,57.16 83.26,61.59
  L8 w0.114: v2(46.35,131.69) 46,131.69 45.44,131.12 40.41,131.12 40.2,130.91 39.75,130.91 39.74,130.89 v1(39.72,130.89)
  L10 w0.114: v1(39.72,130.89) 40.3,131.48 40.3,143.63 38.75,145.18 38.75,150.5 38.86,150.6 38.86,150.88 v1(39.82,151.84)
  BOTTOM w0.102: NAND1.J7 40.58,156.39 40.99,155.99 40.99,153.01 40.57,152.59
  BOTTOM w0.127: 40.57,152.59 v1(39.82,151.84)
EMIFD6: length 158.3
  TOP w0.102: v2(83.03,64.95) 82.56,65.42 U24.K37
  TOP w0.127: v2(44.96,132.97) 45.48,132.97 46.01,132.44 46.01,132.09 45.85,131.93 U65.8
  L5 w0.114: v2(83.03,64.95) 82.88,64.95 82.24,64.31 81.86,64.31 81.36,63.82 81.36,61.74 78.08,58.46 74.47,58.46 72.43,60.5 71.74,60.5 69.55,62.69 68.29,62.69 63.28,57.68 57.65,57.68 52.18,63.15 49.79,63.15 46.53,66.41 46.53,66.84 41.11,72.26 39.44,72.26 39.03,72.67 39.03,73.36 37.41,74.98 37.41,76.76 35.56,78.61 35.56,78.65 34.99,79.22 34.99,81.35 35.4,81.76 35.4,89.43 36.25,90.28 36.25,100.6 37.24,101.59 37.24,113.96 39.46,116.18 39.46,125.39 39.68,125.61 39.68,126.31 38.99,127 38.99,129.33 39.63,129.97 40.52,129.97 42.83,132.29 43.59,132.29 44.27,132.97 v2(44.96,132.97)
  L10 w0.114: v2(41.82,153.87) 41.47,153.52 41.47,151.16 40.89,150.59 40.89,145.68 41.53,145.05 41.53,144.88 42.04,144.37 44.02,144.37 44.45,143.95 44.78,143.95 46.11,142.62 46.2,142.53 46.2,138.86 44.85,137.51 44.85,135.4 44.3,134.84 44.3,134.27 44.41,134.15 44.41,133.52 v2(44.96,132.97)
  BOTTOM w0.102: NAND1.K7 41.82,156.2 v2(41.82,153.87)
EMIFD7: length 162.6
  TOP w0.102: U24.J39 84.05,62.89 v2(84.05,62.87)
  TOP w0.127: v2(43.11,133.82) 44.13,133.82 44.51,133.44 44.51,132.69 44.77,132.43 U65.9
  L5 w0.102: 83.61,61.59 84.05,62.04 v2(84.05,62.87)
  L5 w0.114: 83.61,61.59 78.09,56.08 57.34,56.08 51.53,61.89 40.07,61.89 37.49,64.47 37.49,70.65 35.99,72.15 35.99,73.43 31.68,77.75 31.68,86.83 32.47,87.63 32.47,90.22 34.92,92.67 34.92,100.99 35.93,101.99 35.93,104.38 33.48,106.84 33.48,111.91 38.25,116.68 38.25,121.52 37.73,122.05 37.73,127 37.98,127.25 37.98,130.64 40.06,132.72 42.04,132.72 43.11,133.79 v2(43.11,133.82)
  L10 w0.114: v2(40.61,154.32) 40.68,154.24 40.68,153.36 40.99,153.05 40.99,151.36 40.41,150.79 40.41,145.09 41.27,144.24 41.27,144.23 41.61,143.89 42.82,143.89 43.78,142.92 43.78,139.29 42.5,138 42.5,135.2 43.11,134.59 v2(43.11,133.82)
  BOTTOM w0.102: v2(40.61,154.32) 40.61,155.24 40.58,155.26 NAND1.J8
EMIFD8: length 130.2
  TOP w0.102: v2(83.06,62.87) 83.06,62.87 83.06,62.88 U24.K39
  TOP w0.127: U68.2 45.06,135.03 44.71,134.68 v2(44.71,134.44)
  L5 w0.102: v2(83.06,62.87) 83.06,62.36
  L5 w0.114: v2(44.71,134.44) 44.2,133.92 44.2,133.58 43.39,132.78 42.57,132.78 40.25,130.46 39.43,130.46 38.46,129.49 38.46,127.05 38.21,126.8 38.21,122.25 38.73,121.72 38.73,116.48 34.09,111.84 34.09,106.91 36.46,104.54 36.46,101.84 35.52,100.9 35.52,92.34 33.43,90.24 33.43,89.21 33.64,89 33.64,87.7 32.24,86.31 32.24,77.87 36.48,73.63 36.48,73.43 38.41,71.5 40.24,71.5 42.29,69.45 42.29,68.04 46.4,63.93 47.37,63.93 48.88,62.43 51.68,62.43 57.15,56.95 67.4,56.95 67.64,57.19 72.55,57.19 72.76,57.4 78.36,57.4 83.06,62.11 83.06,62.36
EMIFD9: length 128.5
  TOP w0.102: U24.K38 82.52,64.42 83.03,63.91 v2(83.03,63.91)
  TOP w0.127: v2(45.29,134.41) 45.4,134.41 45.88,134.89 45.88,135.35 45.7,135.53 U68.3
  L5 w0.102: v2(83.03,63.91) 83.03,63.74 82.57,63.28 82.57,62.26 81.9,61.59
  L5 w0.114: 81.9,61.59 78.28,57.98 74.01,57.98 73.56,58.43 73.03,58.43 72.85,58.25 68.35,58.25 67.3,57.19 57.25,57.19 51.78,62.67 48.98,62.67 47.47,64.17 46.5,64.17 42.55,68.13 42.55,69.54 40.33,71.75 39.26,71.75 38.55,72.47 38.55,73.16 36.93,74.78 36.93,75.09 34.51,77.52 34.51,80.77 33.71,81.57 33.71,82.16 33.88,82.33 33.88,89.1 33.67,89.31 33.67,90.14 35.76,92.24 35.76,100.8 36.75,101.79 36.75,114.16 38.98,116.38 38.98,122.59 38.45,123.12 38.45,126.7 38.7,126.95 38.7,129.39 39.53,130.22 40.35,130.22 42.67,132.53 43.49,132.53 44.55,133.6 44.55,133.66 v2(45.29,134.41)
EMIFD10: length 120
  TOP w0.102: v2(83.06,65.96) 82.98,65.96 U24.K36
  TOP w0.127: v2(46.39,135.16) 46.27,135.28 46.27,135.4 45.64,136.03 U68.4
  L5 w0.102: v2(83.06,65.96) 82.6,65.96 82.15,65.51 81.78,65.51 81.43,65.17 81.43,64.77 80.64,63.98 80.64,63.76 80.2,63.31 79.44,63.31 78.87,62.74
  L5 w0.114: 78.87,62.74 78.67,62.55 75,62.55 74.68,62.86 74.03,62.86 73.53,62.37 70.86,62.37 69.88,63.34 65.75,63.34 65.73,63.32 53.77,63.32 45.77,71.31 45.77,72.56 42.49,75.84 39.99,75.84 38.61,77.23 38.61,78.92 36.13,81.4 36.13,89.13 36.97,89.98 36.97,100.3 37.96,101.29 37.96,113.66 40.18,115.88 40.18,125.09 40.41,125.31 40.41,128.3 42.35,130.24 43.13,130.24 43.43,130.55 43.43,130.94 43.73,131.23 44.64,131.23 45.95,132.55 45.95,134.75 46.36,135.16 v2(46.39,135.16)
EMIFD11: length 117.9
  TOP w0.102: U24.L36 81.95,65.99 v2(82.02,65.99)
  TOP w0.127: v2(46.36,135.9) 45.74,136.53 U68.5
  L5 w0.102: v2(82.02,65.99) 81.87,65.99 81.18,65.3 80.86,65.3 80.64,65.08 80.64,64.49 80.39,64.24 80.39,63.79 80.14,63.54 79.06,63.54 78.84,63.32 78.13,63.32
  L5 w0.114: 78.13,63.32 70.23,63.32 69.99,63.56 65.59,63.56 65.57,63.54 53.86,63.54 52.06,65.34 52.06,65.37 46.02,71.41 46.02,72.66 41.7,76.98 41.01,76.98 37.21,80.77 37.21,83.05 36.37,83.89 36.37,89.03 37.21,89.88 37.21,100.2 38.2,101.19 38.2,113.56 40.42,115.78 40.42,124.99 40.65,125.21 40.65,128.2 41.69,129.24 43.15,129.24 43.38,129.47 43.38,129.87 43.69,130.18 44.2,130.18 44.61,130.59 44.61,130.87 46.08,132.34 46.2,132.34 46.83,132.98 46.83,135.43 v2(46.36,135.9)
EMIFD12: length 123.8
  TOP w0.102: U24.L35 81.52,67.42 v2(81.99,66.95)
  TOP w0.127: U68.6 45.64,137.03 46.41,137.79 47.55,137.79 47.72,137.96 47.72,138.82 47.34,139.19 46.54,139.19 45.91,139.83 45.91,139.91 45.47,140.35 45.1,140.35 44.7,139.95 v1(44.7,139.57)
  L5 w0.102: v2(81.99,66.95) 81.61,67.34 79.89,67.34 79.64,67.08 79.64,67 79.05,66.42 78.98,66.42 78.4,65.84 78.4,65.77 78.18,65.54 66.81,65.54 66.57,65.79
  L5 w0.114: v1(44.14,122.25) 44.14,122.1 42.65,120.6 42.65,115.54 40.95,113.84 40.95,96.4 41.75,95.6 41.75,90.67 38.96,87.88 38.96,85.19 38.75,84.98 38.75,81.84 39.23,81.36 39.23,81.15 42.2,78.18 42.2,78.18 47.22,73.16 47.22,72.19 52.53,66.88 55.31,66.88 55.88,66.31 66.18,66.31 66.57,65.92 66.57,65.79
  L10 w0.114: v1(44.7,139.57) 43.5,138.37 43.5,134.01 43.69,133.81 43.69,132.55 44.37,131.86 44.37,129.5 44.12,129.24 44.03,129.24 42.53,127.74 42.53,127.59 42.06,127.12 42.06,125.43 42.93,124.56 42.98,124.56 43.81,123.73 43.81,122.58 v1(44.14,122.25)
EMIFD13: length 117.4
  TOP w0.102: U24.M34 81,67.94 v2(81.03,67.94)
  TOP w0.127: v1(47.27,138.63) 46.79,138.63 45.69,137.53 U68.7
  L5 w0.102: v2(81.03,67.94) 80.67,68.3 79.86,68.3 79.64,68.08 79.64,68 79.18,67.54 78.46,67.54 78.23,67.3 77.86,67.3 77.64,67.08 77.64,67 77.18,66.54 66.86,66.54 66.4,67 66.4,67.08 66.17,67.31 52.78,67.31 51.82,68.28
  L5 w0.114: 51.82,68.28 48.13,71.96 48.13,74.07 45.19,77.01 45.19,85.43 42.24,88.38 42.24,95.79 41.43,96.6 41.43,113.64 43.13,115.34 43.13,117.11 44.35,118.34 44.62,118.34 45.27,118.99 45.27,121.86 45.01,122.12 44.94,122.12 43.38,123.68 43.38,125.99 42.85,126.52 41.41,126.52 41.13,126.8 41.13,128 41.89,128.76 43.97,128.76 45.1,129.88 45.1,130.44 45.93,131.27 46.54,131.27 47.31,132.05 47.31,138.59 v1(47.27,138.63)
EMIFD14: length 121.3
  TOP w0.102: U24.M36 81.03,65.91 v2(81.03,65.89)
  TOP w0.127: U68.8 45.83,138.03 45.97,138.18 45.97,139.22 v1(45.29,139.9)
  L5 w0.102: 78.18,63.54 78.57,63.93 79.3,63.93 79.81,64.44 80.07,64.44 80.4,64.77 80.4,65.26 v2(81.03,65.89)
  L5 w0.114: 78.18,63.54 70.55,63.54 69.98,64.1 65.97,64.1 65.61,64.47 64.44,64.47 64.3,64.32 53.7,64.32 46.26,71.76 46.26,72.76 41.8,77.22 41.73,77.22 38.26,80.68 38.26,80.96 37.6,81.62 37.6,84.44 36.61,85.44 36.61,88.93 37.59,89.92 37.59,95.23 39.98,97.62 39.98,101.46 38.44,103 38.44,113.46 40.67,115.68 40.67,122.02 41.98,123.33 41.98,125.1 v1(42.49,125.62)
  L10 w0.114: v1(42.49,125.62) 43.61,126.73 43.61,128.19 44.61,129.2 44.61,131.96 43.93,132.65 43.93,133.91 43.74,134.11 43.74,134.96 44.37,135.6 44.37,137.71 45.72,139.06 45.72,139.42 45.29,139.86 v1(45.29,139.9)
EMIFD15: length 118.4
  TOP w0.102: U24.M35 80.99,66.95 v2(81.03,66.95)
  TOP w0.127: U68.9 45.18,139.15 v1(45.28,139.24)
  L5 w0.102: 77.22,65.31 78.94,65.31 79.43,65.8 79.43,66.17 79.78,66.51 80.14,66.51 80.59,66.95 v2(81.03,66.95)
  L5 w0.114: v1(45.28,139.24) 45.28,138.87 47.07,137.08 47.07,132.88 46.3,132.1 46.18,132.1 44.85,130.77 44.85,129.98 43.87,129 41.79,129 40.89,128.1 40.89,126.68 41.4,126.16 42.7,126.16 42.93,125.93 42.93,124.97 42.3,124.34 42.3,120.59 42.08,120.37 42.08,117.98 41.15,117.05 41.15,114.38 40.71,113.94 40.71,97.32 38.32,94.94 38.32,90.84 38.91,90.24 38.91,88.64 38.65,88.38 38.65,85.47 38.51,85.34 38.51,81.74 38.99,81.26 38.99,81.05 42.1,77.94 42.1,77.94 46.98,73.06 46.98,72.09 52.43,66.64 55.25,66.64 56.36,65.53 66.27,65.53 66.48,65.31 77.22,65.31
EMIFOEZ: length 264.4
  TOP w0.102: 89.81,61.59 88.14,63.27 88.14,64.8 U24.E37
  TOP w0.127: 89.81,61.59 90.06,61.34 v2(91.57,61.34)
  L5 w0.114: v2(91.57,61.34) 91.57,61.15 92.49,60.22 92.49,57.78 84.99,50.29 48.63,50.29 47.83,49.48 41.89,49.48 40.16,47.76 15.87,47.76 12.29,51.33 12.29,59.31 11.11,60.5 11.11,74.83 13.98,77.7 15.38,77.7 17.1,79.42 17.1,84.73 14.93,86.9 14.93,88.29 13.33,89.89 13.33,105.4 20.46,112.53 24.36,112.53 26.67,114.84 26.67,138.49 32.51,144.32 v1(36.47,144.32) 37.13,144.32 38.81,146 38.81,148.1 v1(39.72,149.01)
  L8 w0.114: v1(46.28,128.33) 47.25,129.3 47.25,129.88 47.8,130.42 47.8,136.92 46.09,138.63 46.09,140.1 45.52,140.67 45.52,143.21 44.86,143.87 41.73,143.87 40.56,145.04 37.53,145.04 36.82,144.32 v1(36.47,144.32)
  BOTTOM w0.102: NAND1.D4 36.72,159.04 36.93,158.83 36.93,157.75 36.91,157.73 36.91,155.58 36.09,154.76 36.09,152.59
  BOTTOM w0.127: R811.2 46.28,127.34 v1(46.28,128.33) ; v1(39.72,149.01) 39.73,149.02 U64.27 41.45,149.02 41.69,148.78 41.69,148.55 41.97,148.27 43.14,148.27 43.27,148.4 43.28,148.4 43.54,148.66 43.54,148.67 43.56,148.69 43.56,150.09 42.9,150.75 38.34,150.75 36.97,152.12 36.81,152.28 36.4,152.28 36.09,152.59
EMIFRNW: length 125.3
  TOP w0.102: U24.F33 86.95,68.99 v2(87.07,68.99)
  L5 w0.102: v2(87.07,68.99) 86.7,69.36 86.03,69.36 84.4,70.99 84.4,71.08 84.17,71.3 82.1,71.3 81.1,72.3 61.87,72.3 60.75,73.43 57.75,73.43 57.66,73.33 51.95,73.33 51.92,73.29 51.82,73.29
  L5 w0.114: v1(44.4,148.72) 44.4,148.54 43.69,147.83 43.69,147.38 46.94,144.13 46.94,142.54 48.26,141.22 48.26,140.21 49.23,139.24 49.23,138.81 49.86,138.18 49.86,136.98 50.21,136.63 50.21,126.87 47.73,124.38 47.73,123.01 47.55,122.83 47.55,114.25 49.62,112.18 49.62,100.89 47.45,98.73 47.45,78.02 50.42,75.06 50.42,74.02 51.14,73.29 51.82,73.29
  BOTTOM w0.127: v1(44.4,148.72) 43.95,148.72 43.79,148.56 43.79,148.56 43.38,148.15 43.38,148.15 43.25,148.02 41.87,148.02 41.86,148.02 U64.29
EMIFWAIT0: length 240.4
  TOP w0.102: 88.39,61.59 87.9,62.09 87.9,63.58 87.52,63.96 U24.E38
  TOP w0.127: v2(92.98,60.73) 92.9,60.82 89.17,60.82 88.39,61.59 ; R25.2 43.18,162.69 v2(42.8,162.31)
  L5 w0.114: v2(92.98,60.73) 92.98,57.6 85.19,49.8 48.83,49.8 48.03,49 42.27,49 40.55,47.28 15.62,47.28 11.81,51.09 11.81,59.11 10.24,60.68 10.24,75.32 13.16,78.23 13.16,79.58 15.5,81.92 15.5,85.64 14.45,86.7 14.45,88.09 12.21,90.32 12.21,93.21 12.72,93.72 12.72,106.69 14.2,108.18 15.43,108.18 20.26,113.01 24.16,113.01 26.19,115.04 26.19,138.8 26.98,139.59 26.98,145.8 29.82,148.64 29.82,152.12 v1(30.45,152.75)
  L10 w0.114: v2(42.8,162.31) 42.72,162.23 37.61,162.23 34.85,159.46 34.85,158.77 34.28,158.2 33.95,158.2 30.42,154.67 30.42,153.67 30.45,153.64 v1(30.45,152.75)
  BOTTOM w0.102: 32.08,153.24 32.44,153.59 32.44,154.46 33.38,155.4 35.34,155.4 NAND1.C8
  BOTTOM w0.127: v1(30.45,152.75) 30.46,152.73 31.57,152.73 32.08,153.24
EMIFWAIT1: length 221.2
  TOP w0.102: U24.D39 90.14,61.8 91.84,61.8 92.04,61.59
  TOP w0.127: v2(92.2,61.34) 92.2,61.44 92.04,61.59 ; v1(38.06,146.61) 38.46,146.61 39.8,145.26 R69.2 40.49,145.75 40.29,145.95 U67.4
  L5 w0.114: v2(92.2,61.34) 92.2,60.85 92.73,60.32 92.73,57.68 85.09,50.04 48.73,50.04 47.93,49.24 41.99,49.24 40.26,47.52 39.86,47.52 39.86,47.52 15.72,47.52 12.05,51.19 12.05,59.21 10.48,60.78 10.48,75.22 13.4,78.13 13.4,79.48 15.74,81.82 15.74,85.74 14.69,86.8 14.69,88.19 13.09,89.79 13.09,93.21 12.96,93.34 12.96,106.59 14.3,107.94 15.53,107.94 20.36,112.77 24.26,112.77 26.43,114.94 26.43,138.7 27.22,139.49 27.22,145.7 30.06,148.54 30.06,149.19 30.48,149.61 v1(30.86,149.61)
  L8 w0.114: v1(30.86,149.61) 31.14,149.61 33.32,147.42 35.56,147.42 35.74,147.6 36.14,147.6 36.53,147.22 37.45,147.22 v1(38.06,146.61)
EMIFWEZ: length 216.4
  TOP w0.102: U24.F36 87,65.94 v2(87.02,65.94)
  L5 w0.102: v2(87.02,65.94) 87.02,65.52 88.56,63.98 88.56,62.17 88.76,61.98 88.76,61.59
  L5 w0.114: v1(43.03,149.48) 43.46,149.05 43.46,148.66 42.74,147.94 42.74,147.39 42.48,147.13 42.45,147.13 41,145.67 41,141.37 36.39,136.76 33.86,136.76 33.47,136.36 33.47,135.65 31.83,134.01 31.83,133.25 30.81,132.23 30.15,132.23 29.08,131.17 29.08,112.41 27.58,110.91 26.19,110.91 24.85,109.57 21.12,109.57 18.14,106.59 18.14,105.03 15.5,102.39 15.5,94.62 16.83,93.29 16.83,92.68 16.83,92.68 16.83,89.64 19.77,86.71 19.77,76.3 18.52,75.05 18.52,52.38 20.01,50.89 23.33,50.89 24.06,51.62 24.95,51.62 25.63,50.94 31.76,50.94 32.55,51.73 33.92,51.73 34.73,50.92 40.59,50.92 41.09,51.41 47.03,51.41 47.83,52.22 82.84,52.22 88.76,58.14 88.76,61.59
  BOTTOM w0.102: 35.76,152.59 35.76,155.14 36.2,155.57 36.2,156.34 35.9,156.64 NAND1.C7
  BOTTOM w0.127: 35.76,152.59 35.76,152.25 35.99,152.02 36.69,152.02 36.85,151.86 38.22,150.5 42.8,150.5 43.01,150.29 43.01,149.52 43.04,149.49 43.04,149.48 v1(43.03,149.48) 42.95,149.4 42.71,149.4 42.65,149.35 42.05,149.35 41.88,149.52 U64.26
EMU_EMU_00: length 60.7
  TOP w0.127: v1(88.52,153.52) 87.83,153.52 87.05,152.74 87.05,151.71 87.5,151.26 88.21,151.26 R61.2 R62.1
  L10 w0.114: v1(135.64,154.94) 134.98,154.28 112.8,154.28 107.41,159.67 93.64,159.67 88.54,154.57 88.54,153.54 v1(88.52,153.52)
  BOTTOM w0.127: v1(135.64,154.94) 135.87,154.71 U49.34
EMU_EMU_00_R: length 3.5
  TOP w0.127: R62.2 91.26,150.25 92.82,148.68 EMU1.19
EMU_EMU_01: length 57.1
  L10 w0.114: v1(135.43,152.59) 135.43,152.59 135.43,152.7 134.11,154.03 112.71,154.03 107.31,159.43 93.75,159.43 89.15,154.84 89.15,153.34 v1(89.13,153.32)
  BOTTOM w0.127: U49.29 135.81,152.21 v1(135.43,152.59) ; R516.2 R517.2 88.97,153.13 89.15,153.31 89.15,153.32 v1(89.13,153.32)
EMU_EMU_01_R: length 5.5
  TOP w0.127: v1(92.38,148.49) 92.69,148.18 EMU1.21
  BOTTOM w0.127: R516.1 92.38,150.77 v1(92.38,148.49)
EMU_TCK: length 80
  TOP w0.127: R37.1 R36.2 88.07,156.86 R32.2 87.18,157.48 86.95,157.71 86.95,158.7 87.67,159.42 94.32,159.42 95.25,158.5 v1(95.25,158.41)
  L3 w0.114: v1(95.25,158.41) 95.69,157.97 96.08,157.97 96.62,158.51 96.62,164.32 105.51,173.21 116.02,173.21 116.37,172.86 139.82,172.86 v1(140.39,173.43)
  BOTTOM w0.127: U45.11 145.9,174.88 144.6,173.58 U45.8 140.54,173.58 v1(140.39,173.43)
EMU_TCK_R: length 5
  TOP w0.127: R37.2 92.2,155.03 92.2,153.34 92.86,152.68 EMU1.3
EMU_TCKRTN: length 59.5
  TOP w0.127: v1(134.49,171.77) 134.39,171.87 R12.1 ; EMU1.7 95.42,151.68 95.89,152.15 95.89,156.64 96.34,157.1 99.54,157.1 v1(100.43,157.99)
  L3 w0.114: v1(100.43,157.99) 100.66,158.22 100.66,162.59 101.6,163.53 101.6,168.96 105.61,172.97 114.7,172.97 115.27,172.4 133.87,172.4 v1(134.49,171.77)
EMU_TDI: length 79.7
  TOP w0.127: R43.1 R42.2 88.42,154.01 87.64,154.01 86.7,154.96 86.7,158.81 87.57,159.68 94.63,159.68 v1(95.9,158.41)
  L3 w0.114: v1(95.9,158.41) 96.37,158.87 96.37,167.32 100.42,171.37 101.52,171.37 103.6,173.45 117.11,173.45 117.53,173.87 117.93,173.87 118.01,173.79 125.86,173.79 125.96,173.89 139.06,173.89 v1(139.6,173.36)
  BOTTOM w0.127: U45.2 143.19,169.68 143.08,169.8 143.07,169.8 143.04,169.83 143.04,169.84 141.22,171.65 140.59,171.65 139.6,172.64 v1(139.6,173.36)
EMU_TDI_R: length 4
  TOP w0.127: R43.2 91.82,154.02 91.82,153.29 92.93,152.18 EMU1.5
EMU_TDO: length 62.9
  TOP w0.127: R49.1 R50.2 104.9,153.16 105.45,152.62 105.99,152.62 107.96,154.58 v1(108.41,154.58)
  L3 w0.114: v1(138.05,156.48) 138.07,156.48 138.56,156.97 138.56,160.61 143.15,165.21 143.15,165.64 145.03,167.53 145.03,168.83 147.26,171.05 v1(147.26,171.39)
  L10 w0.114: v1(108.41,154.58) 109.22,153.77 132.11,153.77 133.73,152.14 135.61,152.14 137.64,154.18 137.64,156.04 138.05,156.45 v1(138.05,156.48)
  BOTTOM w0.127: U45.7 145.71,172.93 v1(147.26,171.39)
EMU_TDO_B: length 28.6
  L3 w0.114: v1(138.81,155.11) 138.81,157.78 142.8,161.77 143.94,161.77 145.34,163.17 146.15,163.17 150.77,167.79 150.77,171.85 151.79,172.87 v1(151.79,172.97)
  BOTTOM w0.127: U49.35 138.72,155.21 v1(138.81,155.11) ; v1(151.79,172.97) 151.18,173.58 U45.13
EMU_TDO_R: length 2.6
  TOP w0.127: EMU1.4 101.56,152.68 R49.2
EMU_TMS: length 62.4
  TOP w0.127: R44.1 R38.2 104.71,155.96 106.03,154.64 v1(106.32,154.64)
  L3 w0.114: v1(106.32,154.64) 106.04,154.92 106.04,158.68 104.95,159.77 104.95,165.25 106.94,167.24 106.94,167.25 106.93,167.26 106.93,170.43 108.76,172.26 108.76,172.4 109.08,172.73 113.16,172.73 114.04,171.85 124.66,171.85 125.57,170.94 134.28,170.94 135.81,172.47 v1(140.59,172.47)
  BOTTOM w0.127: U45.4 142.45,170.98 141.53,171.91 141.15,171.91 v1(140.59,172.47)
EMU_TMS_R: length 3.4
  TOP w0.127: R44.2 102.04,153.87 101.35,153.18 EMU1.2
EMU_TRST#: length 61.2
  TOP w0.127: R57.1 R58.2 106.74,152.64 107.54,153.44 108.01,153.44 v1(108.46,153.89)
  L3 w0.114: v1(141.63,172.43) 141.23,172.03 135.73,172.03 134.4,170.69 125.47,170.69 124.56,171.61 109.12,171.61 108.2,170.69 108.2,168.16 105.19,165.15 105.19,161.37 107.75,158.81 107.82,158.81 108.88,157.75 108.88,154.31 v1(108.46,153.89)
  BOTTOM w0.127: v1(141.63,172.43) 141.77,172.28 U45.6
EMU_TRST#_R: length 5.5
  TOP w0.127: EMU1.8 101.05,151.68 101.51,151.22 103.56,151.22 103.64,151.3 104.24,151.3 R57.2
EXP_SCL2_3V3: length 177
  TOP w0.127: v1(39.67,128.42) 39.39,128.7 CN3.7 37.22,128.7 36.86,129.07 36.86,129.95 v1(36.19,130.61)
  L3 w0.114: v1(22.73,107.57) 22.53,107.37 15.91,107.37 13.93,105.39 13.93,97.64 11.84,95.54 11.84,89.43 7.37,84.96 7.37,63.04 8.22,62.18 9.94,62.18 12.71,59.41 12.71,46.19 12.11,45.58 v1(11,45.58) ; v1(39.67,128.42) 39.67,128.15 40.13,127.69 40.13,127.36 42.9,124.59 43.25,124.59 43.38,124.46 45.53,124.46 45.53,124.45 47.73,124.45 48.14,124.05 51.35,124.05 52.3,123.1 56.89,123.1 56.94,123.06 58.08,121.92 58.54,121.92 59,121.46 59,117.27 v1(58.52,116.79)
  L5 w0.114: v1(36.19,130.61) 36.04,130.61 35.61,130.18 35.61,129.8 34.96,129.15 33.98,129.15 33.17,128.35 33.17,126.82 30.63,124.28 30.63,111.42 27.11,107.89 24.09,107.89 24,107.98 23.15,107.98 v1(22.73,107.57)
  L10 w0.114: v1(66.8,118.62) 65.76,119.66 62.1,119.66 59.23,116.79 v1(58.52,116.79)
  BOTTOM w0.127: v1(11,45.58) 11,41.71 12.13,40.57 12.13,39.31 11.75,38.93 11.7,38.93 R764.2 ; R569.1 66.31,119.06 66.74,118.62 v1(66.8,118.62) 66.8,118.59 67.97,117.42 70.76,117.42 71.27,117.93 72.47,117.93 74.47,119.94 77.63,119.94 78.69,121 U54.7 ; R536.2 22.73,107.63 v1(22.73,107.57)
EXP_SDA2_3V3: length 178.6
  TOP w0.127: v1(36.23,129.89) 36.6,129.51 36.6,128.82 37.22,128.2 CN3.5 39.16,128.2 39.53,127.84 39.53,127.67 v1(39.69,127.5)
  L3 w0.114: v1(10.91,46.21) 12.05,46.21 12.47,46.64 12.47,59.31 9.84,61.94 8.12,61.94 7.12,62.94 7.12,85.06 11.6,89.53 11.6,95.64 13.69,97.74 13.69,105.63 16.54,108.48 22.61,108.48 v1(23.55,107.54) ; v1(39.69,127.5) 39.69,127.45 42.86,124.29 43.21,124.29 43.28,124.22 45.43,124.22 45.43,124.21 47.6,124.21 48.01,123.81 51.25,123.81 52.27,122.79 56.87,122.79 58.04,121.62 58.5,121.62 58.76,121.36 58.76,118.45 58.52,118.21 v1(58.52,117.5)
  L5 w0.114: v1(23.55,107.54) 27.1,107.54 30.98,111.43 30.98,124.22 33.01,126.24 34.38,126.24 35.11,126.97 35.11,128.24 35.2,128.34 35.2,129.05 35.95,129.79 36.13,129.79 v1(36.23,129.89)
  L10 w0.114: v1(58.52,117.5) 59.03,117.5 61.54,120.02 67.46,120.02 v1(68.05,119.43)
  BOTTOM w0.127: U54.6 79.34,122.03 79.15,122.22 79.15,122.65 78.88,122.92 78.5,122.92 78.23,122.65 78.23,121.77 77.61,121.14 76.98,121.14 76.15,121.97 74.12,121.97 73.93,121.78 73.93,120.79 73.28,120.14 71.63,120.14 70.99,119.51 68.12,119.51 v1(68.05,119.43) 67.67,119.06 R571.1 ; v1(23.55,107.54) 23.52,107.54 22.99,107.01 22.56,107.01 20.9,108.66 19.81,108.66 19.56,108.92 R541.2 ; R759.2 11.37,40.95 10.56,41.77 10.56,45.86 v1(10.91,46.21)
EXP_TIMO0: length 177.6
  TOP w0.127: v1(106.99,58.55) 106.99,58.49 107.31,58.17 U30.2 ; v1(36.58,150.75) 37.12,150.2 CN3.73
  L3 w0.114: v1(50.65,158.7) 51.97,157.38 82.91,157.38 88.27,152.02 90.26,152.02 91.17,151.1 91.41,151.1 96.11,146.41 96.11,145.37 102.4,139.09 104.55,139.09 104.8,139.34 105.99,139.34 110.14,135.2 110.14,133.94 110.17,133.91 110.17,133.38 116.09,127.46 116.09,116.75 117.2,115.65 v1(117.2,114.36)
  L5 w0.114: v1(117.2,114.36) 116.33,113.5 116.33,112.26 114.06,109.99 114.06,66.81 110.97,63.72 110.97,61.88 107.64,58.55 v1(106.99,58.55)
  L8 w0.114: v1(36.58,150.75) 38.52,152.69 38.52,156.04 39.98,157.5 41.92,157.5 43.76,159.34 49.42,159.34 50.06,158.7 v1(50.65,158.7)
EXP_TIMO1: length 61.9
  TOP w0.127: CN3.77 39.3,151.2 40.01,150.5 42.8,150.5 v1(43.94,151.64) ; U17.2 76.3,122.55 75.87,122.12 v1(75.87,121.39)
  L3 w0.114: v1(75.87,121.39) 74.93,122.33 74.93,130.02 71.45,133.5 66.86,133.5 66.15,134.21 64.55,134.21 60.82,137.93 51.05,137.93 46.72,142.27 46.72,143.88 44.98,145.62 44.98,149.36 44.32,150.02 44.04,150.02 43.51,150.54 43.51,151.37 43.78,151.64 v1(43.94,151.64)
EXP_TP0: length 3.6
  TOP w0.127: TP8.1 29.71,153.97 31.44,155.7 CN3.96
EXP_TP1: length 3
  TOP w0.127: CN3.98 30.45,156.2 30.02,155.77 R41.1
EXP_TP2: length 2.5
  TOP w0.127: CN3.100 30.06,156.7 R35.1
EXP_UART1_RXD_3V3: length 132.9
  TOP w0.127: v1(50.19,159.59) 50.19,159.32 45.9,155.03 42.47,155.03 41.63,155.87 39.96,155.87 39.79,155.7 CN3.95
  L3 w0.114: v1(50.19,159.59) 50.21,159.59 50.66,159.14 81.53,159.14 88.33,152.34 90.29,152.34 91.22,151.4 92.11,151.4 98.53,144.98 98.53,144.18 101.8,140.91 102.09,140.62 103.13,139.58 v1(103.66,139.58)
  L8 w0.114: v1(153.42,142.88) 151.36,140.82 141.84,140.82 137.09,136.06 118.21,136.06 117.39,135.25 111,135.25 106.67,139.58 v1(103.66,139.58)
  BOTTOM w0.127: v1(153.42,142.88) 153.79,142.5 U52.12
EXP_UART1_TXD_3V3: length 140.7
  TOP w0.127: CN3.93 39.16,155.2 39.38,154.99 41.97,154.99 42.02,154.94 42.19,154.94 42.36,154.77 46.01,154.77 v1(50.83,159.59)
  L3 w0.114: v1(50.83,159.59) 50.88,159.53 82.71,159.53 88.27,153.97 v1(89.62,153.97)
  L10 w0.114: v1(160.91,148.72) 159.51,147.32 148.84,147.32 145.82,144.3 144.48,144.3 144.09,144.68 144.09,145.14 142.9,146.33 142.42,146.33 138.11,150.64 128.12,150.64 125.88,152.88 109.47,152.88 109.02,153.34 107.98,153.34 107.34,153.97 107.34,154.24 106.51,155.07 106.5,155.07 105.64,155.93 105.64,157.72 104.17,159.19 93.88,159.19 89.62,154.92 v1(89.62,153.97)
  BOTTOM w0.127: v1(160.91,148.72) 161.26,148.36 U51.7
EXP_UARTTXD: length 136.9
  TOP w0.127: U26.6 109,64.4 v1(109.09,64.31)
  L5 w0.114: v1(110.31,144.05) 110.74,143.61 110.74,138.43 115.66,133.52 115.66,126.3 116.35,125.61 116.35,115.96 114.8,114.4 114.8,112.51 112.83,110.54 112.83,69.58 109.09,65.85 v1(109.09,64.31)
  L8 w0.114: v1(110.31,144.05) 110.81,144.05 116.31,138.56 117.14,138.56 117.89,137.81 136.36,137.81 144.22,145.67 151.14,145.67 151.89,146.42 v1(151.89,146.43)
  BOTTOM w0.127: v1(151.89,146.43) 152.02,146.56 153.62,146.56 153.79,146.72 U52.9
EXT_EMU_DET: length 4.7
  TOP w0.127: R112.1 102.04,139.83 102.25,139.61 U11.1 101.47,138.57 100.86,139.18 EMU1.58
EXT_EMU_DET_C: length 52.9
  TOP w0.127: v1(105.33,140.97) 105.13,140.77 105.13,137.95 104.46,137.27 U11.4
  L5 w0.114: v1(105.33,140.97) 105.33,146.74 110.98,152.38 133.18,152.38 135.36,150.2 141.12,150.2 v1(141.6,149.71)
  BOTTOM w0.127: v1(141.6,149.71) 142.1,150.21 U49.24
EXT_PS#: length 110.9
  TOP w0.127: R35.2 R34.1 28.03,157.17 28.85,157.99 28.85,159.23 v1(29.24,159.61)
  L3 w0.114: v1(29.24,159.61) 29.24,161.15 31.46,163.37 33.34,163.37 35.94,165.98 84.49,165.98 93.12,157.35 v1(94.61,157.35)
  L5 w0.114: v1(99.57,130.68) 99.57,131.19 95.5,135.25 95.5,137.03 93.62,138.91 93.62,156.36 v1(94.61,157.35)
  BOTTOM w0.127: U53.23 100.62,127.93 99.82,128.73 99.82,130.43 v1(99.57,130.68)
EXT_TIMO1: length 3.2
  TOP w0.127: CN15.1 74.8,121.54 76.32,123.05 U17.1
EXTFRAMEEVENT: length 23.6
  TOP w0.254: v2(70.02,98.97) 70.02,98.92 69.52,98.42 U24.AC4
  BOTTOM w0.254: CN15.2 73.37,117.58 73.37,116.04 72.26,114.94 72.26,103.5 70.02,101.26 v2(70.02,98.97) 70.02,98.97 R623.2
FAN_PWM: length 211.4
  L3 w0.381: v1(65.39,135.65) 65.41,135.65 65.53,135.52 70.12,135.52 70.93,136.33 72.35,136.33 76.54,132.14 78.69,132.14 79.02,132.47 81.54,132.47 83.26,130.75 89.47,130.75 91.43,132.71 92.95,132.71 93.2,132.45 93.63,132.45 94.81,131.28 94.81,128.46 99.44,123.82 99.44,115.57 100.53,114.48 104.9,114.48 105.34,114.05 106.17,114.05 106.61,114.48 111.98,114.48 112.17,114.67 112.18,114.68 112.18,119.69 v1(113.57,121.08)
  L5 w0.508: v1(65.39,135.65) 68.14,135.65 69.45,134.33 69.45,121.96 69.29,121.8 69.29,118.72 66.55,115.98 v1(66.55,114.81)
  L8 w0.381: FAN1.4 15.94,60.78 15.94,70.65 19.61,74.32 23.87,74.32 25.52,75.97 29.47,75.97 31.64,78.14 31.64,80.35 32.44,81.16 32.64,81.16 36.7,85.21 37.89,85.21 38.73,86.05 38.73,87.75 39.41,88.43 39.41,89.66 38.19,90.89 38.19,94.47 52.15,108.43 58.14,108.43 60.5,110.79 60.5,112.09 64.24,115.82 65.53,115.82 v1(66.55,114.81)
  L10 w0.381: v1(132.82,122.02) 132.46,121.67 124.18,121.67 122.24,119.73 119.29,119.73 119.1,119.91 117.13,119.91 115.96,121.08 v1(113.57,121.08)
  BOTTOM w0.381: FAN1.4 13.86,60.28 C724.1 ; v1(132.82,122.02) 133.29,121.55 R574.1
FARM0_AVGG1: length 1.2
  BOTTOM w0.508: R550.2 57.61,141.41 v3(57.84,141.63)
FARM0_CSN1: length 2.4
  TOP w0.254: R134.1 52.52,140.59 53.21,140.59 53.5,140.88 U10.35
FARM0_CSN2: length 5.5
  TOP w0.254: v1(131.6,40.31) 131.6,40.28 131.31,39.99 U44.35
  BOTTOM w0.254: R766.1 135.31,41.21 134.01,39.9 132.18,39.9 131.78,40.31 v1(131.6,40.31)
FARM0_CSP1: length 1.7
  TOP w0.254: U10.36 54,140.74 R135.1
FARM0_CSP2: length 5
  TOP w0.254: v1(130.97,40.39) 130.97,40.35 130.81,40.19 U44.36
  BOTTOM w0.254: R767.1 133.99,40.7 133.67,40.39 132.41,40.39 131.98,40.82 131.39,40.82 131.09,40.52 131.09,40.51 v1(130.97,40.39)
FARM0_FF-1A: length 72.2
  TOP w0.254: v1(50.34,143.64) 50.69,143.64 50.79,143.73 U10.29 ; R223.1 101.47,123.76 101.28,123.76 v1(101.09,123.95) 101.63,124.49 101.63,126.3 101.24,126.68 101.24,127.18 101.04,127.38 v1(100.67,127.38)
  L10 w0.254: v1(50.34,143.64) 51,143.64 52.48,142.16 55.19,142.16 57.6,144.58 59.64,144.58 62.23,141.99 69.65,141.99 73.97,137.66 73.97,137.63 74.27,137.33 74.36,137.25 74.36,134.48 76.63,132.21 79.78,132.21 80.67,133.1 92.62,133.1 93.21,132.51 98.46,132.51 100.13,130.84 100.13,130.38 100.67,129.84 v1(100.67,127.38)
  BOTTOM w0.254: v1(101.09,123.95) 101.09,123.06 100.85,122.82 U62.1
FARM0_FF-1A_L: length 11.9
  TOP w0.254: U16.11 106.94,123.21 106.81,123.34 106.01,123.34 C119.1 105.61,122.57 105.31,122.28 103.85,122.28 R223.2 102.56,122.3 101.85,122.3 100.97,121.41 100.97,120.89 v1(100.72,120.65)
  BOTTOM w0.254: U62.4 98.82,121.52 99.69,120.65 v1(100.72,120.65)
FARM0_FF-2A: length 118.9
  TOP w0.254: v1(102.74,120.9) 102.29,121.35 R231.1 ; v1(133.58,45.72) 133.86,45.72 138.73,40.84 138.73,38.79 137.13,37.19 134.06,37.19 134.06,37.19 U44.29
  L8 w0.254: v1(133.58,45.72) 133.58,48.18 130.06,51.71 130.06,67.32 130.68,67.94 130.68,69.47 129.36,70.79 129.36,107.86 128.65,108.57 128.65,110.77 124.92,114.5 122.56,114.5 120.52,116.54 112.17,116.54 112.1,116.46 109.71,116.46 109.33,116.84 108.33,116.84 106.12,119.05 106.12,120.07 104.39,121.79 103.63,121.79 v1(102.74,120.9)
  BOTTOM w0.254: U62.2 100.97,122.17 101.09,122.3 101.98,122.3 102.29,121.99 R231.1 102.29,121.35 v1(102.74,120.9)
FARM0_FF-2A_L: length 6
  TOP w0.254: U16.13 106.05,122.21 105.61,121.77 C124.2 105.61,121.07 105.29,120.76 103.65,120.76 103.19,121.22 R231.2
FARM0_FF-3A: length 61.7
  TOP w0.254: R269.1 112.52,115.44 112.22,115.14 v1(111.34,115.14) ; v1(77.32,145.13) 77.62,145.13 77.64,145.11 77.8,145.11 78.13,144.79 U9.9
  L3 w0.254: v1(111.34,115.14) 111.34,115.86 109.4,117.8 109.4,118.83 107.22,121.01 106.18,121.01 104.39,122.8 104.39,124.71 104.19,124.91 104.19,129.24 103.25,130.18 v1(103.25,130.23)
  L10 w0.254: v1(77.32,145.13) 77.31,145.13 77.31,145.41 77.29,145.43 77.29,145.83 79.93,148.46 83.44,148.46 85.34,146.56 85.34,146.08 86.08,145.34 86.19,145.34 86.44,145.08 87.38,145.08 90.3,142.17 90.3,136.52 93.55,133.27 100.24,133.27 102.4,131.11 102.4,130.87 102.45,130.82 103.04,130.23 v1(103.25,130.23)
FARM0_FF-3A_L: length 4.5
  TOP w0.254: C145.1 R269.2 112.39,117.04 U16.25
FARM0_FF-4A: length 56.1
  TOP w0.254: U9.18 85.93,144.79 v1(85.98,144.83) ; v1(119.06,120.57) 119.45,120.18 R238.1
  L8 w0.254: v1(85.98,144.83) 88.6,144.83 91.36,142.06 98.93,142.06 102.13,138.86 v1(105.84,138.86)
  L10 w0.254: v1(119.06,120.57) 120.38,121.9 120.38,127.41 121.89,128.92 121.89,129.48 121.25,130.12 121.01,130.12 120.5,130.63 120.5,133.53 115.32,138.71 106.6,138.71 106.45,138.86 v1(105.84,138.86)
FARM0_FF-4A_L: length 3.3
  TOP w0.254: R238.2 C125.1 118.5,121.21 U16.34
FARM0_ILIM1: length 5.7
  TOP w0.254: U10.32 51.35,142.23 50.9,141.78 v1(50.9,141.64)
  BOTTOM w0.254: R128.2 49.32,144.27 48.83,143.78 48.83,142.87 R122.2 49.33,142.26 49.95,141.64 v1(50.9,141.64)
FARM0_ILIM2: length 6.2
  TOP w0.279: R461.2 137.1,39.24 136.3,39.24 135.41,40.13 R456.2 133.99,40.13 133.06,39.2 U44.32
FARM0_LSENES-1A: length 88.4
  TOP w0.254: v1(51.54,141.63) 51.68,141.48 U10.33 ; v1(107.49,134.49) 108.1,135.1 108.1,135.13 108.43,135.46 109.33,135.46 R146.1
  L3 w0.254: v1(51.54,141.63) 51.54,142.04 51.21,142.37 50.55,142.37 50.16,142.75 50.16,143.1 49.83,143.43 49.83,143.48 49.3,144.02 48.39,144.02 46.35,146.05 46.35,150.37 48.13,152.15 51.05,152.15 51.94,153.03 81.71,153.03 82.14,152.6 83.87,152.6 85.67,150.8 87.12,150.8 87.81,151.49 90.07,151.49 91.21,150.34 91.47,150.34 95.55,146.25 95.55,145.16 102.11,138.61 105.38,138.61 105.63,138.35 105.64,138.35 107.31,136.68 107.31,134.67 v1(107.49,134.49)
FARM0_LSENES-2A: length 112.1
  TOP w0.254: v1(102.45,124.07) 102.01,124.52 102.01,127.98 R201.1 ; v1(133.48,44.96) 133.48,43.18 132.31,42.01 U44.33
  L8 w0.254: v1(102.45,124.07) 102.11,123.72 102.11,120.78 102.49,120.4 103.86,120.4 105.36,118.9 105.36,118.68 107.96,116.08 109.02,116.08 109.4,115.7 112.57,115.7 112.65,115.77 118.08,115.77 120.24,113.61 124.21,113.61 125.68,112.14 125.68,110.46 128.6,107.54 128.6,51.79 132.31,48.08 132.31,46.13 v1(133.48,44.96)
FARM0_LSENES-3A: length 44.4
  TOP w0.254: v1(103.21,131.13) 102.7,130.63 R195.1 ; v1(76.55,145.1) 77.58,146.13 78.13,146.13 78.47,145.79 U9.7
  L10 w0.254: v1(103.21,131.13) 103.21,131.37 100.04,134.54 94.6,134.54 91.21,137.94 91.21,142.94 86.85,147.29 86.26,147.29 84.33,149.22 79.61,149.22 76.53,146.14 76.53,145.12 v1(76.55,145.1)
  BOTTOM w0.254: R544.1 75.9,144.44 v1(76.55,145.1)
FARM0_LSENES-4A: length 27
  TOP w0.254: v1(86.87,145.8) 86.12,145.8 86.1,145.78 85.54,145.78 85.53,145.79 U9.20 ; R170.1 103.07,132.66 v1(103.3,132.89)
  L3 w0.254: v1(86.87,145.8) 86.87,145.6 89.43,143.03 89.43,140.05 95.75,133.73 101.91,133.73 102.74,132.89 v1(103.3,132.89)
  BOTTOM w0.254: R540.1 v1(86.87,145.8)
FARM0_PWM-1A: length 72.6
  TOP w0.254: v1(55.56,140.25) 55.19,140.62 55.19,140.62 55,140.81 U10.38 ; U16.17 108.39,119.63 107.85,119.09 v1(106.93,119.09) 106.83,119.09 106.34,119.58 R807.2
  L3 w0.254: v1(55.56,140.25) 56.35,140.25 57.12,141.02 58.09,141.02 58.5,141.43 59.67,141.43 60.22,141.99 70.36,141.99 73.66,138.68 73.66,136.19 76.49,133.36 90.92,133.36 91.09,133.53 93.29,133.53 93.55,133.27 95.13,133.27 95.44,132.97 101.1,132.97 101.85,132.21 101.85,123.55 103.25,122.15 103.74,122.15 106.8,119.09 v1(106.93,119.09)
FARM0_PWM-2A: length 100.8
  TOP w0.254: v1(104.78,118.49) 104.78,118.97 R807.1 ; R808.1 109.63,117.5 108.84,116.71 108.84,116.59 108.46,116.21 108.46,115.82 107.95,115.32 v1(107.62,115.32) ; v1(127.51,42.49) 128.47,41.53 128.48,41.53 129.81,40.2 U44.38
  L3 w0.254: v1(107.62,115.32) 107.62,115.65 v1(104.78,118.49)
  L8 w0.254: v1(107.62,115.32) 107.62,114.43 108.51,113.54 118.6,113.54 121.03,111.11 121.03,110.36 122.59,108.81 123.55,108.81 125.96,106.4 125.96,55.74 126.21,55.48 126.21,54.85 125.96,54.6 125.96,44.04 v1(127.51,42.49)
FARM0_PWM-2A_L: length 1.6
  TOP w0.254: R808.2 109.63,118.51 109.39,118.75 U16.19
FARM0_PWM-3A: length 54.1
  TOP w0.254: U16.21 v1(110.39,119.08) ; U9.1 77.76,148.79 v1(77.7,148.84)
  L3 w0.254: v1(110.39,119.08) 110.39,119.11 107.18,122.33 106.19,122.33 105.71,122.8 105.71,124.52 105.31,124.93 105.31,129.54 104.19,130.66 104.19,134.01 103.76,134.44 103.76,134.45 103.28,134.92 99.13,134.92 95.01,139.04 94.87,139.04 91.54,142.37 91.54,144.25 90.63,145.16 90.14,145.16 89.12,146.19 89.12,146.49 88.77,146.84 88.51,146.84 88.49,146.86 85.26,146.86 83.28,148.84 v1(77.7,148.84)
FARM0_PWM-4A: length 48.3
  TOP w0.254: U9.26 85.63,148.79 v1(85.93,149.09) ; v1(111.35,119) 111.39,119.04 U16.23
  L3 w0.254: v1(111.35,119) 111.35,119.23 107.19,123.39 107.19,126.83 107.16,126.86 107.16,128.65 106.96,128.85 106.96,132.99 106.55,133.39 106.55,134.7 105.11,136.14 104.47,136.14 103.07,137.54 102.1,137.54 94.54,145.1 94.54,146.02 92.66,147.9 91.97,147.9 91.3,148.57 91.3,148.9 89.69,150.52 88.72,150.52 87.91,149.71 86.55,149.71 v1(85.93,149.09)
FARM0_RDLY1: length 3.7
  TOP w0.254: R136.2 57.84,139.95 57.53,140.26 56.27,140.26 55.77,140.75 55.69,140.75 55.5,140.93 U10.39
FARM0_RDLY2: length 2
  TOP w0.254: v1(128.91,40.39) 129.31,39.98 U44.39
  BOTTOM w0.254: R768.2 128.91,40.95 v1(128.91,40.39)
FARM0_SRE_A1: length 1.7
  TOP w0.254: U10.31 51.03,142.73 50.86,142.56 R121.1
FARM0_SRE_A2: length 2.1
  TOP w0.279: U44.31 133.61,38.19 134.03,38.61 134.83,38.61 R460.1
FARM0_SRE_A3: length 3
  TOP w0.254: R82.1 76.62,148.88 77.21,148.29 U9.2
FARM0_SRE_A4: length 2.6
  TOP w0.254: R81.1 87.15,149.03 86.41,148.29 U9.25
FARM0_SW_SHAPE1: length 5.3
  BOTTOM w0.508: R551.1 55.1,141.6 56.35,140.36 57.84,140.36 58.57,141.1
  vias: v3(59.94,148.72) v3(59.94,147.7)
FARM0_SW_SHAPE2:
  vias: v3(123.57,37.9) v3(127.05,33.86)
FARM0_UCD_EAN1: length 82.7
  TOP w0.254: U16.51 114.89,129.88 115.57,130.56 117.22,130.56 118.17,131.5 C84.2 R150.2 118.17,133.8 117.72,134.24 117.72,135.95 116.56,137.11 v1(115.24,137.11)
  L5 w0.254: v1(90.04,127.84) 90.04,127.89 92.52,130.38 92.52,133.3 92.58,133.36 92.58,136.28 93.29,137 v1(93.29,137.29)
  L10 w0.254: v1(115.24,137.11) 115.24,137.54 114.88,137.9 112.9,137.9 111.02,136.02 102.9,136.02 101.4,137.52 93.52,137.52 v1(93.29,137.29) ; v1(90.04,127.84) 90.04,127.66 89.95,127.57 80.67,127.57 76.27,123.16 73.98,123.16 73.4,122.58 72.09,122.58 71.58,122.07 71.58,121.3 72.52,120.37 72.52,117.64 72.12,117.24 v1(71.94,117.24)
  BOTTOM w0.254: R615.1 70,109.16 70.48,109.65 70.48,115.84 71.89,117.24 v1(71.94,117.24)
FARM0_UCD_EAN2: length 144.6
  TOP w0.254: U16.53 113.89,130.15 115.06,131.32 115.7,131.32 116.14,131.76 C83.2 R149.2 116.14,133.73 115.69,134.18 115.69,135.15 116.23,135.69 116.33,135.69 v1(116.41,135.76)
  L5 w0.254: v1(103.48,63.91) 103.3,63.73 103.3,61.8 102.49,60.99 102.49,59.01 104.99,56.52 105.9,56.52 108.2,54.21 108.2,53.18 113.05,48.34 120.44,48.34 121.41,49.31 121.41,56.1 122.43,57.12 122.43,79.47 124.82,81.86 124.82,85.45 125.6,86.23 125.6,111.41 123.98,113.03 120.78,113.03 119.13,114.68 119.13,116.81 122.43,120.11 122.43,122.08 120.4,124.11 120.4,125.6 118.9,127.1 118.9,135.13 117.76,136.27 116.92,136.27 v1(116.41,135.76)
  BOTTOM w0.254: v1(103.48,63.91) 103.76,64.19 103.76,66.81 103.09,67.49 102.29,67.49 102.23,67.54 99.69,67.54 R743.1
FARM0_UCD_EAN3: length 67.9
  TOP w0.254: U16.55 112.89,130.54 114.1,131.76 C82.2 R148.2 114.1,133.95 113.66,134.4 113.66,135.28 112.34,136.6 107.49,136.6 106.63,135.74 102.54,135.74 100.53,133.72 98.11,133.72 96.4,132.02 95.55,132.02 94.4,130.87 94.4,130.26 92.23,128.09 92.23,127.62 91.83,127.23 v1(91.83,127.05)
  L10 w0.254: v1(73.91,116.21) 74.42,116.71 74.42,117.98 73.91,118.49 73.91,121.38 74.43,121.9 76.67,121.9 81.19,126.42 91.21,126.42 v1(91.83,127.05)
  BOTTOM w0.254: v1(73.91,116.21) 73.91,115.81 73.66,115.56 73.66,114.82 74.17,114.31 74.17,109.47 73.86,109.16 R293.1
FARM0_UCD_EAN4: length 44.1
  TOP w0.254: v1(93.47,126.11) 93.56,126.11 95.38,127.93 95.38,130.51 95.93,131.06 96.68,131.06 98.57,132.96 100.69,132.96 101.01,132.96 103.03,134.98 106.7,134.98 107.02,134.98 107.88,135.84 111.02,135.84 111.63,135.23 111.63,134.4 112.07,133.95 R147.2 C81.2 112.07,131.44 111.89,131.26 U16.57
  BOTTOM w0.254: R605.1 95.94,117.93 95.5,118.36 95.5,119.13 97.33,120.95 97.33,123.39 96.77,123.95 93.46,123.95 93.01,124.41 93.01,125.87 93.25,126.11 v1(93.47,126.11)
FARM0_UCD_EAP1: length 74.1
  TOP w0.254: R140.1 118.17,136.27 116.8,137.64 114.94,137.64 v1(114.5,137.21)
  L5 w0.254: v1(90.58,127.48) 90.58,127.89 92.91,130.22 92.91,133.14 92.96,133.2 92.96,136.13 93.85,137.01 v1(94.08,137.01)
  L10 w0.254: v1(90.58,127.48) 90.41,127.48 90.11,127.18 80.83,127.18 76.43,122.78 74.14,122.78 73.56,122.2 72.24,122.2 71.96,121.91 71.96,121.46 72.9,120.52 72.9,117.49 v1(71.95,116.54) ; v1(94.08,137.01) 94.21,137.13 101.19,137.13 102.69,135.64 112.93,135.64 v1(114.5,137.21)
  BOTTOM w0.254: R614.1 70.87,109.67 70.87,115.68 71.72,116.54 v1(71.95,116.54)
FARM0_UCD_EAP2: length 135.2
  TOP w0.254: v1(117.14,135.76) 117.14,135.69 116.2,134.75 R139.1
  L5 w0.254: v1(117.14,135.76) 117.27,135.89 117.6,135.89 118.36,135.13 118.36,127.1 120.02,125.45 120.02,123.95 122.05,121.92 122.05,120.27 118.75,116.97 118.75,114.52 120.62,112.65 123.83,112.65 125.22,111.25 125.22,86.39 124.43,85.6 124.43,82.02 122.05,79.63 122.05,57.28 121.03,56.26 121.03,49.47 120.28,48.72 113.21,48.72 108.58,53.34 108.58,54.37 106.06,56.9 105.15,56.9 102.87,59.17 102.87,60.84 103.68,61.65 103.68,63.17 v1(103.81,63.3)
  BOTTOM w0.254: R741.1 99.54,67.92 102.39,67.92 102.44,67.87 103.24,67.87 104.14,66.97 104.14,63.83 103.81,63.5 v1(103.81,63.3)
FARM0_UCD_EAP3: length 62.6
  TOP w0.254: v1(91.18,127.11) 91.85,127.78 91.85,128.24 94.02,130.42 94.02,131.03 95.39,132.4 96.25,132.4 97.95,134.1 100.37,134.1 102.39,136.12 106.47,136.12 107.33,136.98 112.5,136.98 114.1,135.37 R138.1
  L10 w0.254: v1(91.18,127.11) 90.87,126.8 81.03,126.8 76.51,122.28 74.28,122.28 73.51,121.52 73.51,118.36 74.04,117.83 74.04,117.08 v1(73.88,116.92)
  BOTTOM w0.254: v1(73.88,116.92) 73.96,116.92 74.42,116.46 74.42,115.78 74.04,115.4 74.04,114.98 74.55,114.47 74.55,109.6 74.99,109.16 R294.1
FARM0_UCD_EAP4: length 38.7
  TOP w0.254: R137.1 112.07,135.32 111.18,136.22 107.72,136.22 106.86,135.36 102.87,135.36 100.85,133.34 98.41,133.34 96.52,131.44 95.77,131.44 95,130.67 95,128.09 93.65,126.75 v1(93.47,126.75)
  BOTTOM w0.254: v1(93.47,126.75) 93.34,126.75 92.63,126.03 92.63,124.25 93.31,123.57 96.61,123.57 96.95,123.23 96.95,121.11 95.12,119.28 R606.1
FARM0_UCD_TEMP1: length 58
  TOP w0.254: v1(106.43,126.34) 106.56,126.21 U16.5
  L3 w0.254: v1(106.43,126.34) 106.43,126.52 106.07,126.87 106.07,129.86 105.79,130.14 105.79,133.73 104.11,135.41 104.11,135.42 103.65,135.89 102.54,135.89 101.24,137.19 100.38,137.19 97.59,139.98 97.59,140.87 92.68,145.77 91.11,145.77 88.98,147.9 88.11,147.9 87.83,147.62 85.57,147.62 83.16,150.04 76.91,150.04 74.8,147.93 72.62,147.93 69.66,144.97 v1(69.66,144.22)
  BOTTOM w0.254: C453.2 105.61,127.69 106.43,126.88 v1(106.43,126.34)
  BOTTOM w0.406: Q17.3 69.25,144.63 v1(69.66,144.22)
FARM0_UCD_TEMP2: length 137.7
  TOP w0.254: U16.6 v1(106.43,125.71)
  L8 w0.254: v1(126.14,42.47) 126.14,42.61 125.15,43.6 125.15,54.86 v1(125.45,55.17)
  L10 w0.254: v1(126.14,42.47) 125.07,41.4 125.07,32.23 124,31.17 116.84,31.17 116.22,31.78 v1(116.22,31.98)
  BOTTOM w0.254: v1(116.22,31.98) 116.27,32.03 Q21.3 ; v1(125.45,55.17) 126.19,55.91 126.19,79.45 130.05,83.31 130.05,107.95 131.95,109.85 131.95,112.14 130.66,113.44 118.89,113.44 118.51,113.82 116.91,113.82 115.52,112.43 106.98,112.43 106.48,112.93 106.48,117.75 104.32,119.91 104.32,120.93 104.42,121.03 104.42,121.98 105.41,122.97 C458.2 106.28,125.66 106.33,125.71 v1(106.43,125.71)
FARM0_UCD_TEMP3: length 35.6
  TOP w0.254: 109.22,130.18 107.64,131.76 C79.2 107.13,131.76 106.5,132.38 106.5,132.61 105.59,133.53 v1(103.25,133.53) ; 109.22,130.18 109.39,130 U16.62 ; 109.22,130.18 109.15,130.18 108.89,129.92 U16.63 ; U9.19 85.72,145.29 85.77,145.34 86.19,145.34 86.3,145.23 C58.1 87.06,145.23 v1(87.63,145.8)
  L3 w0.254: v1(103.25,133.53) 102.95,133.53 102.36,134.11 97.89,134.11 93.87,138.14 92.37,138.14 90.09,140.41 90.09,143.33 v1(87.63,145.8)
FARM0_UCD_VIN: length 5.3
  TOP w0.254: R208.2 102.86,126.56 102.98,126.68 103.54,126.68 103.66,126.56 R209.1 104.46,126.56 104.47,126.57 104.93,126.57 104.94,126.56 C109.1 105.92,126.56 106.22,126.85 106.64,126.85 106.78,126.71 U16.4
FARM0_VGG1: length 1.1
  TOP w0.279: v1(57.86,143.18) 57.81,143.23 U10.3
  vias: v1(57.81,143.81)
FARM0_VGG2: length 1.3
  TOP w0.279: 126.72,37.69 U44.3
  vias: v3(125.63,37.44) v3(126.36,37.47)
FARM1_AVGG2: length 5.5
  TOP w0.279: 121.77,140.56 C62.2 121.27,140.56 120.73,141.1 120.73,141.63 120.6,141.76 U8.40
  TOP w0.381: 121.77,140.56 121.94,140.56 122.71,141.33 v1(122.71,141.71)
  BOTTOM w0.381: R537.2 122.6,141.82 v1(122.71,141.71)
FARM1_CSN2: length 3.8
  TOP w0.254: R114.1 116.81,141.82 117.89,141.82 118.1,142.02 U8.35
FARM1_CSP2: length 3.3
  TOP w0.254: R115.1 116.94,141 117.32,141.38 118.08,141.38 118.6,141.89 U8.36
FARM1_FF-1A: length 20.3
  TOP w0.254: R378.1 30.49,73.46 v1(30.49,72.61)
  TOP w0.279: v1(22.24,65.79) 22.24,65.8 22.61,66.17 U27.2
  L8 w0.254: v1(22.24,65.79) 20.95,65.79 20.45,66.29 20.45,70.61 21.2,71.37 25.72,71.37 27.84,73.48 30.12,73.48 30.48,73.13 30.48,72.62 v1(30.49,72.61)
FARM1_FF-1A_L: length 4
  TOP w0.254: R378.2 C283.1 28.89,74.55 28.89,75.5 28.55,75.84 U25.11
FARM1_FF-2A: length 257.5
  TOP w0.254: R380.1 33.91,73.46 v1(33.14,72.7) ; v1(115.09,144.88) 115.16,144.95 U8.29
  L3 w0.254: v1(115.09,144.88) 115.09,142.27 116.79,140.56 116.79,140.09 120.55,136.33 120.55,130.61 121.48,129.68 121.48,129.35 122.53,128.3 122.53,126.96 122.82,126.67 122.82,122.53 122.53,122.24 122.53,121.13 123.32,120.35 123.32,117.28 128.8,111.79 128.8,66.9 129.65,66.06 129.65,61.87 129.03,61.26 129.03,53.48 122.79,47.24 113.99,47.24 109.63,42.88 109.63,36.87 105.8,33.04 30.86,33.04 29.98,33.92 29.98,36.71 30.61,37.34 30.61,41.2 29.95,41.86 29.95,48.07 27.42,50.6 27.42,53.17 28.24,54 28.24,54.93 28.94,55.63 29.72,55.63 30.61,56.52 31.04,56.52 35.48,60.96 35.48,70.36 v1(33.14,72.7)
FARM1_FF-2A_L: length 6.1
  TOP w0.254: R380.2 C284.1 32.19,75.19 30.47,75.19 29.55,76.11 U25.13
FARM1_FF-3A: length 25.8
  TOP w0.254: R354.1 36.14,81.22 35.74,80.83 v1(35.74,80.82) ; U23.9 18.76,94.75 18.85,94.66 18.85,94.16 v1(18.47,93.78)
  L3 w0.254: v1(35.74,80.82) 35.69,80.88 35.69,81.79 28.83,88.65 27.81,88.65 25.96,90.5 21.89,90.5 18.61,93.78 v1(18.47,93.78)
FARM1_FF-3A_L: length 5.4
  TOP w0.254: U25.25 32.85,81.53 33.58,82.26 34.48,82.26 35.24,81.5 R354.2 C251.1
FARM1_FF-4A: length 25.9
  TOP w0.254: v1(31.04,89.26) 31.32,89.26 32.24,88.33 R338.1 ; v1(18.87,102.49) 18.76,102.39 U23.18
  L3 w0.254: v1(31.04,89.26) 30.9,89.39 30.9,89.4 30.54,89.76 28.57,89.76 27.46,90.88 22.1,90.88 19.91,93.07 19.91,95.09 20.32,95.5 20.32,101.04 v1(18.87,102.49)
FARM1_FF-4A_L: length 3.2
  TOP w0.254: R338.2 C231.1 31.24,87.38 30.55,86.69 U25.34
FARM1_FLTRST: length 3
  TOP w0.279: U27.12 21.7,69.83 21.24,70.28 21.05,70.28 21.03,70.28 20.01,71.3 R395.1
FARM1_ILIM2: length 5.1
  TOP w0.254: R93.2 112.14,142.93 112.64,142.43 R105.2 114.94,143.45 115.7,143.45 115.7,143.45 U8.32
FARM1_LSENES-1A: length 16.5
  TOP w0.254: v1(13.49,74.32) 14.35,75.18 R370.1
  TOP w0.279: C722.1 21.15,71.3 21.59,70.87 ; v1(21.59,70.86) 21.59,70.87 ; 21.59,70.87 21.84,70.61 22.38,70.61 22.61,70.38 U27.11
  BOTTOM w0.254: R370.1 14.35,75.18 v1(13.49,74.32) 13.34,74.17 13.34,73.41 15.39,71.35 21.1,71.35 v1(21.59,70.86)
FARM1_LSENES-2A: length 314.6
  TOP w0.254: v1(116.46,142.7) U8.33
  L3 w0.254: v1(116.46,142.7) 117.91,141.25 117.91,140.89 123.36,135.43 124.56,135.43 132.31,127.69 132.31,121.81 133.19,120.93 134.2,120.93 134.59,120.53 134.59,118.9 135.13,118.36 135.13,103.84 133.81,102.51 133.81,91.62 135.13,90.3 135.13,50.5 138.73,46.89 138.73,33.83 135.94,31.03 28.12,31.03 26.1,33.04 26.1,35.62 24.45,37.27 24.45,44.47 15.11,53.8 15.11,60.55 11.76,63.91 11.76,74.56 12.18,74.98 16.23,74.98 16.64,74.57 18.34,74.57 21.06,77.29 23.84,77.29 24.31,76.82 33.08,76.82 34.03,77.77 v1(34.03,78.77)
  BOTTOM w0.254: R693.1 30.42,77.41 32.26,79.25 33.18,79.25 33.26,79.17 33.26,79.17 33.65,78.77 v1(34.03,78.77)
FARM1_LSENES-3A: length 17.9
  TOP w0.254: v1(17.86,92.86) 17.74,92.98 17.74,94.78 17.76,94.8 U23.7
  BOTTOM w0.254: v1(17.86,92.86) 17.86,92.68 18.19,92.35 18.35,92.35 R639.1 18.9,91.8 18.9,91.71 19.21,91.4 19.21,87.5 24.71,82 R682.1
FARM1_LSENES-4A: length 28
  TOP w0.254: U23.20 17.76,102.45 v1(17.81,102.49)
  BOTTOM w0.254: R612.1 17.81,103.33 v1(17.81,102.49) 19.53,100.76 19.53,96.21 18.6,95.28 18.14,95.28 17.6,94.73 17.6,93.5 17.22,93.13 17.22,91.64 18.57,90.29 18.57,86.96 21.77,83.76 R683.1
FARM1_PWM-1A: length 52.3
  TOP w0.254: U25.17 33.03,77.53 33.41,77.91 v1(33.45,77.91)
  TOP w0.279: v1(24.64,66.04) 23.85,66.04 23.61,66.27 U27.4
  BOTTOM w0.254: v1(33.45,77.91) 33.4,77.86 31.83,77.86 29.2,75.23 24.25,75.23 23.94,75.54 21.92,75.54 21.39,76.07 18.27,76.07 17.98,76.35 12.95,76.35 11.07,74.47 11.07,65.76 12.34,64.49 19.05,64.49 21.36,66.8 23.88,66.8 v1(24.64,66.04)
