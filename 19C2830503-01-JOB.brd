# Allegro board 19C2830503-01-JOB.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
H27P35-MTH
  round 3.505 hole 2.692: 1(0,0)
H35P7-MTH
  round 7.01 hole 3.505: 1(0,0)
H107X17-NPTH
  oval 10.693x1.702 hole 10.693x1.702 unplated: (0,0)
HD_2X1P_79_H236_D
  rect 1.372x1.372 hole 0.965: 1(-1,0)
  round 1.372 hole 0.965: 2(1,0)
HD_3X1P_79_D
  rect 1.219x1.219 hole 0.813: 1(-2,0)
  round 1.219 hole 0.813: 2(0,0) 3(2,0)
HD_3X1P_100_H320_D
  rect 1.549x1.549 hole 1.143: 1(-2.54,0)
  round 1.549 hole 1.143: 2(0,0) 3(2.54,0)
HD_4X1P_79_H264
  oval 0.838x2.388 smd: 1(-3,-1.175) 2(-1,1.175) 3(1,-1.175) 4(3,1.175)
HD_4X2P_100_D
  rect 1.549x1.549 hole 1.143: 1(-3.81,-1.27)
  round 1.549 hole 1.143: 2(-3.81,1.27) 3(-1.27,-1.27) 4(-1.27,1.27) 5(1.27,-1.27) 6(1.27,1.27) 7(3.81,-1.27) 8(3.81,1.27)
HD_5X1P_100_D
  rect 1.549x1.549 hole 1.143: 1(-5.08,0)
  round 1.549 hole 1.143: 2(-2.54,0) 3(0,0) 4(2.54,0) 5(5.08,0)
HD_5X2P_50_H235
  oval 0.737x2.794 smd: 1(-2.54,-2.03) 2(-2.54,2.03) 3(-1.27,-2.03) 4(-1.27,2.03) 5(0,-2.03) 6(0,2.03) 7(1.27,-2.03) 8(1.27,2.03) 9(2.54,-2.03) 10(2.54,2.03)
HD_6X1P_79_D
  rect 1.372x1.372 hole 0.965: 1(-5,0)
  round 1.372 hole 0.965: 2(-3,0) 3(-1,0) 4(1,0) 5(3,0) 6(5,0)
HS_UFL-R-SMT-1
  rect 0.889x2.21 smd: 1(-1.5,0) 3(1.5,0)
  rect 0.813x0.838 smd: 2(0,1.525)
INDUCTOR_2P_183_205X193
  rect 2.159x1.803 smd: 1(-2.323,0) 2(2.323,0)
INDUCTOR_2P_267_270X265
  rect 2.667x3.175 smd: 1(-3.393,0) 2(3.393,0)
L0402
  oval 0.381x0.711 smd: 1(-0.45,0) 2(0.45,0)
L0603
  oval 1.016x0.889 smd: 1(0,0.826) 2(0,-0.826)
L0805
  oval 1.778x1.016 smd: 1(0,-1.016) 2(0,1.016)
L_3P_70_63X35
  rect 0.889x0.889 smd: 1(-0.89,0) 3(0.89,0)
  rect 0.406x1.702 smd: 2(0,0)
L_3P_87_79X53
  rect 1.016x1.245 smd: 1(-1.107,0) 3(1.107,0)
  rect 0.61x1.245 smd: 2(0,0)
LCD_17P_NHD-C12832A1Z
  round 1.067 hole 1.067 unplated: (-20.1,11.55) (-20.1,-11.55) (20.1,11.55) (20.1,-11.55)
  rect 1.321x1.067 hole 0.813x0.559: 1(-12,-11.55)
  oval 1.321x1.067 hole 0.813x0.559: 2(-10.5,-11.55) 3(-9,-11.55) 4(-7.5,-11.55) 5(-6,-11.55) 6(-4.5,-11.55) 7(-3,-11.55) 8(-1.5,-11.55) 9(0,-11.55) 10(1.5,-11.55) 11(3,-11.55) 12(4.5,-11.55) 13(6,-11.55) 14(7.5,-11.55) 15(9,-11.55) 16(10.5,-11.55) 17(12,-11.55)
  oval 2.921x1.981 hole 1.905x0.965: A(-17.3,-9.6) K(17.3,-9.6)
LED_2P_KPA-1606EC
  rect 0.889x0.61 smd: 1(-0.8,0) 2(0.8,0)
LED_2P_KPA-1606QBC-D
  rect 0.889x0.61 smd: 1(-0.8,0) 2(0.8,0)
LED_2P_KPBA-3010ESGC
  rect 1.143x1.016 smd: 1(-1.55,-0.064) 3(1.55,-0.064)
  rect 1.016x1.016 smd: 2(0,0.65)
LED_0603
  rect 0.813x0.813 smd: 1(-0.75,0) 2(0.75,0)
OEC-D
  oval 1.651x3.302 smd: 1(0,-2.794) 2(0,2.794)
OSC-4SD
  rect 1.829x2.032 smd: 1(-2.54,-2.1) 2(2.54,-2.1) 3(2.54,2.1) 4(-2.54,2.1)
OSC_4P_236X157_382X295_H161
  round 1.524 smd: 1(-3,-2) 2(3,-2) 3(3,2) 4(-3,2)
OSC_6P_50_203X132
  oval 0.635x1.651 smd: 1(-1.27,-1.319) 2(0,-1.319) 3(1.27,-1.319) 4(1.27,1.319) 5(0,1.319) 6(-1.27,1.319)
PJ_3P_2DC-0005
  oval 1.524x4.013 hole 1.016x3.505: 1(0,0)
  oval 1.321x3.505 hole 0.813x2.997: 2(6.25,0)
  oval 3.505x1.321 hole 2.997x0.813: 3(3,4.8)
POWERMODULE_2P_5223957-3
  round 3.175 hole 3.175 unplated: (0,-15)
  round 8.992 hole 3.175: 1(0,0)
QFN10P_20_118X118_TP94X65V5
  oval 0.279x0.991 smd: 1(-1,-1.5) 2(-0.5,-1.5) 3(0,-1.5) 4(0.5,-1.5) 5(1,-1.5) 6(1,1.5) 7(0.5,1.5) 8(0,1.5) 9(-0.5,1.5) 10(-1,1.5)
  custom 0.406x0.406 smd: 11(0,0)
  round 0.559 hole 0.305: 12(-0.75,-0.5) 13(0.75,-0.5) 14(-0.75,0.5) 15(0.75,0.5) 16(0,0)
QFN40P20_276X197T209X130V21
  oval 0.279x0.991 smd: 1(-2.75,-2.5) 2(-2.25,-2.5) 3(-1.75,-2.5) 4(-1.25,-2.5) 5(-0.75,-2.5) 6(-0.25,-2.5) 7(0.25,-2.5) 8(0.75,-2.5) 9(1.25,-2.5) 10(1.75,-2.5) 11(2.25,-2.5) 12(2.75,-2.5) 21(2.75,2.5) 22(2.25,2.5) 23(1.75,2.5) 24(1.25,2.5) 25(0.75,2.5) 26(0.25,2.5) 27(-0.25,2.5) 28(-0.75,2.5) 29(-1.25,2.5) 30(-1.75,2.5) 31(-2.25,2.5) 32(-2.75,2.5)
  oval 0.991x0.279 smd: 13(3.5,-1.75) 14(3.5,-1.25) 15(3.5,-0.75) 16(3.5,-0.25) 17(3.5,0.25) 18(3.5,0.75) 19(3.5,1.25) 20(3.5,1.75) 33(-3.5,1.75) 34(-3.5,1.25) 35(-3.5,0.75) 36(-3.5,0.25) 37(-3.5,-0.25) 38(-3.5,-0.75) 39(-3.5,-1.25) 40(-3.5,-1.75)
  rect 5.309x3.302 smd: 41(0,0)
  round 0.559 hole 0.305: 42(-2.25,-0.75) 43(-1.5,-0.75) 44(-0.75,-0.75) 45(0,-0.75) 46(0.75,-0.75) 47(1.5,-0.75) 48(2.25,-0.75) 49(-2.25,0) 50(-1.5,0) 51(-0.75,0) 52(0,0) 53(0.75,0) 54(1.5,0) 55(2.25,0) 56(-2.25,0.75) 57(-1.5,0.75) 58(-0.75,0.75) 59(0,0.75) 60(0.75,0.75) 61(1.5,0.75) 62(2.25,0.75)
QFN_8P_26_118X118
  oval 0.381x1.016 smd: 1(-0.975,-1.5) 2(-0.325,-1.5) 3(0.325,-1.5) 4(0.975,-1.5) 5(0.975,1.5) 6(0.325,1.5) 7(-0.325,1.5) 8(-0.975,1.5)
  custom 0.375x0.375 smd: 9(0,0)
QFN_13P_20_UCD74106
  oval 0.279x0.991 smd: 1(-1,-1.5) 2(-0.5,-1.5) 3(0,-1.5) 4(0.5,-1.5) 5(1,-1.5) 8(1,1.5) 9(0.5,1.5) 10(0,1.5) 11(-0.5,1.5) 12(-1,1.5)
  oval 4.013x0.279 smd: 6(0,-0.3)
  oval 2.21x0.279 smd: 7(0.902,0.3)
  oval 1.499x0.279 smd: 13(-1.258,0.3)
QFN_14P_20_138X138_TP79
  oval 1.016x0.279 smd: 1(-1.75,-0.75) 7(1.75,-0.75) 8(1.75,0.75) 14(-1.75,0.75)
  oval 0.279x1.016 smd: 2(-1,-1.75) 3(-0.5,-1.75) 4(0,-1.75) 5(0.5,-1.75) 6(1,-1.75) 9(1,1.75) 10(0.5,1.75) 11(0,1.75) 12(-0.5,1.75) 13(-1,1.75)
  custom 0.508x0.508 smd: 15(0,0)
QFN_16P_20_118X118_TP59
  oval 0.279x1.016 smd: 1(-0.75,-1.5) 2(-0.25,-1.5) 3(0.25,-1.5) 4(0.75,-1.5) 9(0.75,1.5) 10(0.25,1.5) 11(-0.25,1.5) 12(-0.75,1.5)
  oval 1.016x0.279 smd: 5(1.5,-0.75) 6(1.5,-0.25) 7(1.5,0.25) 8(1.5,0.75) 13(-1.5,0.75) 14(-1.5,0.25) 15(-1.5,-0.25) 16(-1.5,-0.75)
  rect 1.499x1.499 smd: 17(0,0)
QFN_20P_20_177X138_TP
  oval 1.016x0.279 smd: 1(-2.25,-0.75) 10(2.25,-0.75) 11(2.25,0.75) 20(-2.25,0.75)
  oval 0.279x1.016 smd: 2(-1.75,-1.75) 3(-1.25,-1.75) 4(-0.75,-1.75) 5(-0.25,-1.75) 6(0.25,-1.75) 7(0.75,-1.75) 8(1.25,-1.75) 9(1.75,-1.75) 12(1.75,1.75) 13(1.25,1.75) 14(0.75,1.75) 15(0.25,1.75) 16(-0.25,1.75) 17(-0.75,1.75) 18(-1.25,1.75) 19(-1.75,1.75)
  rect 2.997x2.007 smd: 21(0,0)
  round 0.508 hole 0.254: 22(-1,-0.5) 23(-1,0.5) 24(0,-0.5) 25(0,0.5) 26(1,-0.5) 27(1,0.5)
QFN_32P_20_236X236_UDC7242
  oval 0.279x0.991 smd: 1(-2,-3) 2(-1.5,-3) 3(-1,-3) 4(-0.5,-3) 5(0,-3) 6(0.5,-3) 7(1,-3) 8(1.5,-3) 9(2,-3) 18(2,3) 19(1.5,3) 20(1,3) 21(0.5,3) 22(0,3) 23(-0.5,3) 24(-1,3) 25(-1.5,3) 26(-2,3)
  rect 1.143x1.143 smd: 10(2.925,-2.925) 17(2.925,2.925) 27(-2.925,2.925) 32(-2.925,-2.925)
  oval 0.991x0.279 smd: 11(3,-2) 16(3,2) 28(-3,2) 31(-3,-2)
  oval 4.166x0.508 smd: 12(1.412,-1.2) 15(1.412,1.2)
  oval 6.985x0.508 smd: 13(0,-0.4) 14(0,0.4)
  oval 2.591x0.508 smd: 29(-2.2,1.2) 30(-2.2,-1.2)
QFN_48P_20_276X276_TP161V16
  oval 0.279x1.016 smd: 1(-2.75,-3.5) 2(-2.25,-3.5) 3(-1.75,-3.5) 4(-1.25,-3.5) 5(-0.75,-3.5) 6(-0.25,-3.5) 7(0.25,-3.5) 8(0.75,-3.5) 9(1.25,-3.5) 10(1.75,-3.5) 11(2.25,-3.5) 12(2.75,-3.5) 25(2.75,3.5) 26(2.25,3.5) 27(1.75,3.5) 28(1.25,3.5) 29(0.75,3.5) 30(0.25,3.5) 31(-0.25,3.5) 32(-0.75,3.5) 33(-1.25,3.5) 34(-1.75,3.5) 35(-2.25,3.5) 36(-2.75,3.5)
  oval 1.016x0.279 smd: 13(3.5,-2.75) 14(3.5,-2.25) 15(3.5,-1.75) 16(3.5,-1.25) 17(3.5,-0.75) 18(3.5,-0.25) 19(3.5,0.25) 20(3.5,0.75) 21(3.5,1.25) 22(3.5,1.75) 23(3.5,2.25) 24(3.5,2.75) 37(-3.5,2.75) 38(-3.5,2.25) 39(-3.5,1.75) 40(-3.5,1.25) 41(-3.5,0.75) 42(-3.5,0.25) 43(-3.5,-0.25) 44(-3.5,-0.75) 45(-3.5,-1.25) 46(-3.5,-1.75) 47(-3.5,-2.25) 48(-3.5,-2.75)
  rect 4.089x4.089 smd: 49(0,0)
  round 0.559 hole 0.305: 50(-1.499,-1.499) 51(-0.499,-1.499) 52(0.501,-1.499) 53(1.501,-1.499) 54(-1.499,-0.499) 55(-0.499,-0.499) 56(0.501,-0.499) 57(1.501,-0.499) 58(-1.499,0.501) 59(-0.499,0.501) 60(0.501,0.501) 61(1.501,0.501) 62(-1.499,1.501) 63(-0.499,1.501) 64(0.501,1.501) 65(1.501,1.501)
QFN_48P_20_276X276_TP202V25
  oval 0.279x0.991 smd: 1(-2.75,-3.5) 2(-2.25,-3.5) 3(-1.75,-3.5) 4(-1.25,-3.5) 5(-0.75,-3.5) 6(-0.25,-3.5) 7(0.25,-3.5) 8(0.75,-3.5) 9(1.25,-3.5) 10(1.75,-3.5) 11(2.25,-3.5) 12(2.75,-3.5) 25(2.75,3.5) 26(2.25,3.5) 27(1.75,3.5) 28(1.25,3.5) 29(0.75,3.5) 30(0.25,3.5) 31(-0.25,3.5) 32(-0.75,3.5) 33(-1.25,3.5) 34(-1.75,3.5) 35(-2.25,3.5) 36(-2.75,3.5)
  oval 0.991x0.279 smd: 13(3.5,-2.75) 14(3.5,-2.25) 15(3.5,-1.75) 16(3.5,-1.25) 17(3.5,-0.75) 18(3.5,-0.25) 19(3.5,0.25) 20(3.5,0.75) 21(3.5,1.25) 22(3.5,1.75) 23(3.5,2.25) 24(3.5,2.75) 37(-3.5,2.75) 38(-3.5,2.25) 39(-3.5,1.75) 40(-3.5,1.25) 41(-3.5,0.75) 42(-3.5,0.25) 43(-3.5,-0.25) 44(-3.5,-0.75) 45(-3.5,-1.25) 46(-3.5,-1.75) 47(-3.5,-2.25) 48(-3.5,-2.75)
  rect 5.131x5.131 smd: 49(0,0)
  round 0.559 hole 0.305: 50(-2,-2) 51(-1,-2) 52(0,-2) 53(1,-2) 54(2,-2) 55(-2,-1) 56(-1,-1) 57(0,-1) 58(1,-1) 59(2,-1) 60(-2,0) 61(-1,0) 62(0,0) 63(1,0) 64(2,0) 65(-2,1) 66(-1,1) 67(0,1) 68(1,1) 69(2,1) 70(-2,2) 71(-1,2) 72(0,2) 73(1,2) 74(2,2)
QFN_64P_20_354X354_TP167V25
  oval 0.279x0.991 smd: 1(-3.75,-4.5) 2(-3.25,-4.5) 3(-2.75,-4.5) 4(-2.25,-4.5) 5(-1.75,-4.5) 6(-1.25,-4.5) 7(-0.75,-4.5) 8(-0.25,-4.5) 9(0.25,-4.5) 10(0.75,-4.5) 11(1.25,-4.5) 12(1.75,-4.5) 13(2.25,-4.5) 14(2.75,-4.5) 15(3.25,-4.5) 16(3.75,-4.5) 33(3.75,4.5) 34(3.25,4.5) 35(2.75,4.5) 36(2.25,4.5) 37(1.75,4.5) 38(1.25,4.5) 39(0.75,4.5) 40(0.25,4.5) 41(-0.25,4.5) 42(-0.75,4.5) 43(-1.25,4.5) 44(-1.75,4.5) 45(-2.25,4.5) 46(-2.75,4.5) 47(-3.25,4.5) 48(-3.75,4.5)
  oval 0.991x0.279 smd: 17(4.5,-3.75) 18(4.5,-3.25) 19(4.5,-2.75) 20(4.5,-2.25) 21(4.5,-1.75) 22(4.5,-1.25) 23(4.5,-0.75) 24(4.5,-0.25) 25(4.5,0.25) 26(4.5,0.75) 27(4.5,1.25) 28(4.5,1.75) 29(4.5,2.25) 30(4.5,2.75) 31(4.5,3.25) 32(4.5,3.75) 49(-4.5,3.75) 50(-4.5,3.25) 51(-4.5,2.75) 52(-4.5,2.25) 53(-4.5,1.75) 54(-4.5,1.25) 55(-4.5,0.75) 56(-4.5,0.25) 57(-4.5,-0.25) 58(-4.5,-0.75) 59(-4.5,-1.25) 60(-4.5,-1.75) 61(-4.5,-2.25) 62(-4.5,-2.75) 63(-4.5,-3.25) 64(-4.5,-3.75)
  rect 4.242x4.242 smd: 65(0,0)
  round 0.559 hole 0.305: 66(-1.6,-1.6) 67(-0.8,-1.6) 68(0,-1.6) 69(0.8,-1.6) 70(1.6,-1.6) 71(-1.6,-0.8) 72(-0.8,-0.8) 73(0,-0.8) 74(0.8,-0.8) 75(1.6,-0.8) 76(-1.6,0) 77(-0.8,0) 78(0,0) 79(0.8,0) 80(1.6,0) 81(-1.6,0.8) 82(-0.8,0.8) 83(0,0.8) 84(0.8,0.8) 85(1.6,0.8) 86(-1.6,1.6) 87(-0.8,1.6) 88(0,1.6) 89(0.8,1.6) 90(1.6,1.6)
QFP_64P_20_472X472
  oval 0.279x1.372 smd: 1(-3.75,-5.827) 2(-3.25,-5.827) 3(-2.75,-5.827) 4(-2.25,-5.827) 5(-1.75,-5.827) 6(-1.25,-5.827) 7(-0.75,-5.827) 8(-0.25,-5.827) 9(0.25,-5.827) 10(0.75,-5.827) 11(1.25,-5.827) 12(1.75,-5.827) 13(2.25,-5.827) 14(2.75,-5.827) 15(3.25,-5.827) 16(3.75,-5.827) 33(3.75,5.827) 34(3.25,5.827) 35(2.75,5.827) 36(2.25,5.827) 37(1.75,5.827) 38(1.25,5.827) 39(0.75,5.827) 40(0.25,5.827) 41(-0.25,5.827) 42(-0.75,5.827) 43(-1.25,5.827) 44(-1.75,5.827) 45(-2.25,5.827) 46(-2.75,5.827) 47(-3.25,5.827) 48(-3.75,5.827)
  oval 1.372x0.279 smd: 17(5.827,-3.75) 18(5.827,-3.25) 19(5.827,-2.75) 20(5.827,-2.25) 21(5.827,-1.75) 22(5.827,-1.25) 23(5.827,-0.75) 24(5.827,-0.25) 25(5.827,0.25) 26(5.827,0.75) 27(5.827,1.25) 28(5.827,1.75) 29(5.827,2.25) 30(5.827,2.75) 31(5.827,3.25) 32(5.827,3.75) 49(-5.827,3.75) 50(-5.827,3.25) 51(-5.827,2.75) 52(-5.827,2.25) 53(-5.827,1.75) 54(-5.827,1.25) 55(-5.827,0.75) 56(-5.827,0.25) 57(-5.827,-0.25) 58(-5.827,-0.75) 59(-5.827,-1.25) 60(-5.827,-1.75) 61(-5.827,-2.25) 62(-5.827,-2.75) 63(-5.827,-3.25) 64(-5.827,-3.75)
QFP_100P_20_630X630
  oval 0.279x1.372 smd: 1(-6,-7.822) 2(-5.5,-7.822) 3(-5,-7.822) 4(-4.5,-7.822) 5(-4,-7.822) 6(-3.5,-7.822) 7(-3,-7.822) 8(-2.5,-7.822) 9(-2,-7.822) 10(-1.5,-7.822) 11(-1,-7.822) 12(-0.5,-7.822) 13(0,-7.822) 14(0.5,-7.822) 15(1,-7.822) 16(1.5,-7.822) 17(2,-7.822) 18(2.5,-7.822) 19(3,-7.822) 20(3.5,-7.822) 21(4,-7.822) 22(4.5,-7.822) 23(5,-7.822) 24(5.5,-7.822) 25(6,-7.822) 51(6,7.822) 52(5.5,7.822) 53(5,7.822) 54(4.5,7.822) 55(4,7.822) 56(3.5,7.822) 57(3,7.822) 58(2.5,7.822) 59(2,7.822) 60(1.5,7.822) 61(1,7.822) 62(0.5,7.822) 63(0,7.822) 64(-0.5,7.822) 65(-1,7.822) 66(-1.5,7.822) 67(-2,7.822) 68(-2.5,7.822) 69(-3,7.822) 70(-3.5,7.822) 71(-4,7.822) 72(-4.5,7.822) 73(-5,7.822) 74(-5.5,7.822) 75(-6,7.822)
  oval 1.372x0.279 smd: 26(7.822,-6) 27(7.822,-5.5) 28(7.822,-5) 29(7.822,-4.5) 30(7.822,-4) 31(7.822,-3.5) 32(7.822,-3) 33(7.822,-2.5) 34(7.822,-2) 35(7.822,-1.5) 36(7.822,-1) 37(7.822,-0.5) 38(7.822,0) 39(7.822,0.5) 40(7.822,1) 41(7.822,1.5) 42(7.822,2) 43(7.822,2.5) 44(7.822,3) 45(7.822,3.5) 46(7.822,4) 47(7.822,4.5) 48(7.822,5) 49(7.822,5.5) 50(7.822,6) 76(-7.822,6) 77(-7.822,5.5) 78(-7.822,5) 79(-7.822,4.5) 80(-7.822,4) 81(-7.822,3.5) 82(-7.822,3) 83(-7.822,2.5) 84(-7.822,2) 85(-7.822,1.5) 86(-7.822,1) 87(-7.822,0.5) 88(-7.822,0) 89(-7.822,-0.5) 90(-7.822,-1) 91(-7.822,-1.5) 92(-7.822,-2) 93(-7.822,-2.5) 94(-7.822,-3) 95(-7.822,-3.5) 96(-7.822,-4) 97(-7.822,-4.5) 98(-7.822,-5) 99(-7.822,-5.5) 100(-7.822,-6)
R0402
  oval 0.381x0.711 smd: 1(-0.45,0) 2(0.45,0)
R0603
  oval 1.016x0.889 smd: 1(0,0.826) 2(0,-0.826)
R0805
  oval 1.651x1.016 smd: 1(0,-1.016) 2(0,1.016)
R1206
  oval 2.286x1.778 smd: 1(0,1.524) 2(0,-1.524)
RF-SMAC037
  rect 2.286x2.286 hole 1.524: 1(0,0)
  round 2.54 hole 1.778: 2(2.54,2.54) 3(-2.54,2.54) 4(-2.54,-2.54) 5(2.54,-2.54)
RJ45_28P_RTB-19GB9J1A
  round 3.251 hole 3.251 unplated: (-13.335,0) (13.335,0)
  rect 1.295x1.295 hole 0.889: A1(-1.27,6.35)
  round 1.295 hole 0.889: A2(-2.54,8.89) A3(-3.81,6.35) A4(-5.08,8.89) A5(-6.35,6.35) A6(-7.62,8.89) A7(-8.89,6.35) A8(-10.16,8.89) A9(-11.43,6.35) A10(-12.7,8.89) B1(12.7,6.35) B2(11.43,8.89) B3(10.16,6.35) B4(8.89,8.89) B5(7.62,6.35) B6(6.35,8.89) B7(5.08,6.35) B8(3.81,8.89) B9(2.54,6.35) B10(1.27,8.89)
  round 1.448 hole 1.041: A11(-1.52,13.68) A12(-4.06,13.68) A13(-9.91,13.68) A14(-12.45,13.68) B11(12.45,13.68) B12(9.91,13.68) B13(4.06,13.68) B14(1.52,13.68)
  round 2.362 hole 1.6: H3(-15.26,3.05) H4(15.26,3.05)
SC70_5P
  oval 0.356x1.118 smd: 1(-0.65,-0.997) 2(0,-0.997) 3(0.65,-0.997) 4(0.65,0.997) 5(-0.65,0.997)
SC-70_5P
  oval 0.356x1.118 smd: 1(-0.65,-0.997) 2(0,-0.997) 3(0.65,-0.997) 4(0.65,0.997) 5(-0.65,0.997)
SC-70_6P
  oval 0.356x1.118 smd: 1(-0.65,-0.997) 2(0,-0.997) 3(0.65,-0.997) 4(0.65,0.997) 5(0,0.997) 6(-0.65,0.997)
SIM_8P_FMS006Z-2001-1
  rect 0.991x2.311 smd: C1(2.98,20.7) C2(0.44,20.7) C3(-2.1,20.7) C5(1.71,20.7) C6(-0.83,20.7) C7(-3.37,20.7) SW1(-4.64,20.7) SW2(-5.91,20.7)
  rect 2.311x2.946 smd: H1(-10.675,0) H2(10.675,0)
SOIC_8P_20_79X122
  oval 0.279x1.041 smd: 1(-0.75,-1.539) 2(-0.25,-1.539) 3(0.25,-1.539) 4(0.75,-1.539) 5(0.75,1.539) 6(0.25,1.539) 7(-0.25,1.539) 8(-0.75,1.539)
SOIC_8P_26_118X193
  oval 0.356x1.321 smd: 1(-0.975,-2.298) 2(-0.325,-2.298) 3(0.325,-2.298) 4(0.975,-2.298) 5(0.975,2.298) 6(0.325,2.298) 7(-0.325,2.298) 8(-0.975,2.298)
SOIC_8P_50_193X236
  oval 0.533x1.397 smd: 1(-1.905,-2.809) 2(-0.635,-2.809) 3(0.635,-2.809) 4(1.905,-2.809) 5(1.905,2.809) 6(0.635,2.809) 7(-0.635,2.809) 8(-1.905,2.809)
SOIC_16P_26_197X252
  oval 0.356x1.372 smd: 1(-2.275,-3.022) 2(-1.625,-3.022) 3(-0.975,-3.022) 4(-0.325,-3.022) 5(0.325,-3.022) 6(0.975,-3.022) 7(1.625,-3.022) 8(2.275,-3.022) 9(2.275,3.022) 10(1.625,3.022) 11(0.975,3.022) 12(0.325,3.022) 13(-0.325,3.022) 14(-0.975,3.022) 15(-1.625,3.022) 16(-2.275,3.022)
SOIC_16P_50_406X406
  oval 0.533x2.032 smd: 1(-4.445,-4.655) 2(-3.175,-4.655) 3(-1.905,-4.655) 4(-0.635,-4.655) 5(0.635,-4.655) 6(1.905,-4.655) 7(3.175,-4.655) 8(4.445,-4.655) 9(4.445,4.655) 10(3.175,4.655) 11(1.905,4.655) 12(0.635,4.655) 13(-0.635,4.655) 14(-1.905,4.655) 15(-3.175,4.655) 16(-4.445,4.655)
SOIC_20P_26_256X252
  oval 0.356x1.397 smd: 1(-2.925,-3.014) 2(-2.275,-3.014) 3(-1.625,-3.014) 4(-0.975,-3.014) 5(-0.325,-3.014) 6(0.325,-3.014) 7(0.975,-3.014) 8(1.625,-3.014) 9(2.275,-3.014) 10(2.925,-3.014) 11(2.925,3.014) 12(2.275,3.014) 13(1.625,3.014) 14(0.975,3.014) 15(0.325,3.014) 16(-0.325,3.014) 17(-0.975,3.014) 18(-1.625,3.014) 19(-2.275,3.014) 20(-2.925,3.014)
SOIC_28P_26_402X307
  oval 0.356x1.651 smd: 1(-4.225,-3.577) 2(-3.575,-3.577) 3(-2.925,-3.577) 4(-2.275,-3.577) 5(-1.625,-3.577) 6(-0.975,-3.577) 7(-0.325,-3.577) 8(0.325,-3.577) 9(0.975,-3.577) 10(1.625,-3.577) 11(2.275,-3.577) 12(2.925,-3.577) 13(3.575,-3.577) 14(4.225,-3.577) 15(4.225,3.577) 16(3.575,3.577) 17(2.925,3.577) 18(2.275,3.577) 19(1.625,3.577) 20(0.975,3.577) 21(0.325,3.577) 22(-0.325,3.577) 23(-0.975,3.577) 24(-1.625,3.577) 25(-2.275,3.577) 26(-2.925,3.577) 27(-3.575,3.577) 28(-4.225,3.577)
SOIC_48P_20_492X319
  oval 0.279x1.397 smd: 1(-5.75,-3.865) 2(-5.25,-3.865) 3(-4.75,-3.865) 4(-4.25,-3.865) 5(-3.75,-3.865) 6(-3.25,-3.865) 7(-2.75,-3.865) 8(-2.25,-3.865) 9(-1.75,-3.865) 10(-1.25,-3.865) 11(-0.75,-3.865) 12(-0.25,-3.865) 13(0.25,-3.865) 14(0.75,-3.865) 15(1.25,-3.865) 16(1.75,-3.865) 17(2.25,-3.865) 18(2.75,-3.865) 19(3.25,-3.865) 20(3.75,-3.865) 21(4.25,-3.865) 22(4.75,-3.865) 23(5.25,-3.865) 24(5.75,-3.865) 25(5.75,3.865) 26(5.25,3.865) 27(4.75,3.865) 28(4.25,3.865) 29(3.75,3.865) 30(3.25,3.865) 31(2.75,3.865) 32(2.25,3.865) 33(1.75,3.865) 34(1.25,3.865) 35(0.75,3.865) 36(0.25,3.865) 37(-0.25,3.865) 38(-0.75,3.865) 39(-1.25,3.865) 40(-1.75,3.865) 41(-2.25,3.865) 42(-2.75,3.865) 43(-3.25,3.865) 44(-3.75,3.865) 45(-4.25,3.865) 46(-4.75,3.865) 47(-5.25,3.865) 48(-5.75,3.865)
SON_6P_20_59X39
  rect 0.305x0.559 smd: 1(-0.5,-0.377) 2(0,-0.377) 3(0.5,-0.377) 4(0.5,0.377) 5(0,0.377) 6(-0.5,0.377)
SOT-23
  oval 1.219x0.508 smd: 1(-1.302,0.95) 2(-1.302,-0.95) 3(1.302,0)
SOT-23_5P
  oval 0.533x1.118 smd: 1(-0.95,-1.352) 2(0,-1.352) 3(0.95,-1.352) 4(0.95,1.352) 5(-0.95,1.352)
SOT-223
  oval 0.864x1.651 smd: 1(-2.3,-3.177) 2(0,-3.177) 3(2.3,-3.177)
  rect 2.997x1.651 smd: 4(0,3.177)
SOT_TPD2EUSB30DRTR
  oval 0.203x0.737 smd: 1(-0.35,-0.625) 2(0.35,-0.625) 3(0,0.625)
SW_2P_388_236X138
  rect 2.794x1.194 smd: 1(-5.2,0) 2(5.2,0)
SW_2P_DTSA-63K-V_D
  rect 1.422x1.422 hole 1.016: 1(-2.25,0)
  round 1.422 hole 1.016: 2(2.25,0) 3(-3.5,2.5) 4(3.5,2.5)
SW_4X2P_100_398X378
  oval 1.143x3.302 smd: 1(-3.81,-3.95) 2(-1.27,-3.95) 3(1.27,-3.95) 4(3.81,-3.95) 5(3.81,3.95) 6(1.27,3.95) 7(-1.27,3.95) 8(-3.81,3.95)
TI_SOC_K2H_SOCKET
  round 0.66 hole 0.66 unplated: (-24.385,-24.385) (24.385,24.385)
  round 5.994 hole 2.362: H1(-27.305,-27.305) H2(27.305,-27.305) H3(-27.305,27.305) H4(27.305,27.305)
TP28
  round 0.711 smd: 1(0,0)
TP-S40
  round 1.016 smd: 1(0,0)
USB-UH51543
  round 0.94 hole 0.94 unplated: (-2.2,-0.5) (2.2,-0.5)
  rect 0.508x2.311 smd: 1(-1.6,2.075) 2(-0.8,2.075) 3(0,2.075) 4(0.8,2.075) 5(1.6,2.075)
  rect 2.007x2.489 smd: 6(-4.45,1.975) 7(4.45,1.975) 8(-4.45,-3.525) 9(4.45,-3.525)
USB_9P_UEA1112C-4HK1-4H
  rect 1.118x1.118 hole 0.711: 1(-3.5,2)
  round 1.118 hole 0.711: 2(-1,2) 3(1,2) 4(3.5,2) 5(4,3.5) 6(2,3.5) 7(0,3.5) 8(-2,3.5) 9(-4,3.5)
  round 3.073 hole 2.311: H1(-6.57,0) H2(6.57,0)
WF_4P_79_BOX_D_721-81-04TW0
  rect 1.372x1.372 hole 0.965: 1(3,0)
  round 1.372 hole 0.965: 2(1,0) 3(-1,0) 4(-3,0)
WF_4P_100_D_744-81-04TW20
  round 1.092 hole 1.092 unplated: (-3.81,-2.23)
  rect 1.422x1.422 hole 1.016: 1(3.81,0)
  round 1.422 hole 1.016: 2(1.27,0) 3(-1.27,0) 4(-3.81,0)
XTAL_2P_152_197X126
  rect 1.753x2.007 smd: 1(-1.923,0) 2(1.923,0)
XTAL_2P_161_205X134_H59
  rect 1.702x2.007 smd: 1(-2.049,0) 2(2.049,0)

## Nets
AVCC2V5A: B33.1 C271.1 C278.1 C296.1 PHY1.B7(AVDD_6) PHY1.M3(AVDD_1) PHY1.M4(AVDD_2) PHY1.M7(AVDD_3) PHY1.M8(AVDD_4) PHY1.N5(AVDD_5)
AVCC2V5B: B27.1 C194.1 C202.1 C211.1 PHY2.B7(AVDD_6) PHY2.M3(AVDD_1) PHY2.M4(AVDD_2) PHY2.M7(AVDD_3) PHY2.M8(AVDD_4) PHY2.N5(AVDD_5)
AVDDA1: B45.1 C171.1 C816.1 U24.AF11(AVDDA1)
AVDDA2: B16.1 C152.1 C817.1 U24.N20(AVDDA2)
AVDDA3: B32.1 C259.1 C818.1 U24.N28(AVDDA3)
AVDDA4: B41.1 C316.1 C819.1 U24.AH29(AVDDA4)
AVDDA5: B38.1 C303.1 C820.1 U24.AG26(AVDDA5)
AVDDAHV: B43.1 C553.1 C566.1 C580.1 C599.1 C616.1 C626.1 C637.1 C655.1 C664.1 C699.1 U24.AK11(VDDAHV_01) U24.AK13(VDDAHV_02) U24.AK15(VDDAHV_03) U24.AK17(VDDAHV_04) U24.AK19(VDDAHV_05) U24.AK21(VDDAHV_06) U24.AK23(VDDAHV_07) U24.AK25(VDDAHV_08) U24.AL10(VDDAHV_09) U24.AL12(VDDAHV_10) U24.AL14(VDDAHV_11) U24.AL16(VDDAHV_12) U24.AL18(VDDAHV_13) U24.AL20(VDDAHV_14) U24.AL22(VDDAHV_15) U24.AL24(VDDAHV_16)
AVDDALV: B46.2 C564.1 C573.1 C574.1 C588.1 C594.1 C598.1 C601.1 C613.1 C624.1 C627.1 C628.1 C629.1 C636.1 C643.1 U24.AF13(VDDALV_01) U24.AF15(VDDALV_02) U24.AF17(VDDALV_03) U24.AF19(VDDALV_04) U24.AF21(VDDALV_05) U24.AF23(VDDALV_06) U24.AG12(VDDALV_07) U24.AG14(VDDALV_08) U24.AG16(VDDALV_09) U24.AG18(VDDALV_10) U24.AG20(VDDALV_11) U24.AG22(VDDALV_12) U24.AH11(VDDALV_13) U24.AH13(VDDALV_14) U24.AH15(VDDALV_15) U24.AH17(VDDALV_16) U24.AH19(VDDALV_17) U24.AH21(VDDALV_18) U24.AH23(VDDALV_19) U24.AH25(VDDALV_20) U24.AJ12(VDDALV_21) U24.AJ14(VDDALV_22) U24.AJ16(VDDALV_23) U24.AJ18(VDDALV_24) U24.AJ20(VDDALV_25) U24.AJ22(VDDALV_26) U24.AJ24(VDDALV_27)
