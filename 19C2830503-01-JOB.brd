# Allegro board 19C2830503-01-JOB.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SOC_DDR3A_EA15: length 60.1
  TOP w0.102: U24.D10 88.52,92.42 89.03,91.91 89.03,91.82 v2(89.02,91.82)
  TOP w0.127: v1(120.29,81.85) DIMM1.88
  L8 w0.114: v1(120.29,81.85) 119.04,81.85 118.92,81.96 118.92,82.33 119.04,82.45 120.72,82.45 120.84,82.56 120.84,88.08 118.02,90.89 111.17,90.89 111.05,90.78 111.05,90.13 110.94,90.02 110.71,90.02 110.6,90.13 110.6,90.78 110.48,90.89 110.25,90.89 110.14,90.78 110.14,89.93 110.03,89.81 109.8,89.81 109.68,89.93 109.68,90.78 109.57,90.89 109.34,90.89 109.23,90.78 109.23,89.93 109.11,89.81 108.88,89.81 108.77,89.93 108.77,90.78 108.65,90.89 108.43,90.89 108.31,90.78 108.31,89.93 108.2,89.81 107.97,89.81 107.85,89.93 107.85,90.78 107.74,90.89 107.51,90.89 107.4,90.78 107.4,89.93 107.28,89.81 107.05,89.81 106.94,89.93 106.94,90.78 106.83,90.89 106.6,90.89 106.48,90.78 106.48,89.93 106.37,89.81 106.14,89.81 106.03,89.93 106.03,90.78 105.91,90.89 105.68,90.89 105.57,90.78 105.57,89.93 105.45,89.81 105.23,89.81 105.11,89.93 105.11,90.78 105,90.89 104.77,90.89 104.65,90.78 104.65,90.13 104.54,90.02 104.31,90.02 104.2,90.13 104.2,90.78 104.08,90.89 103.63,90.89 101.64,92.89 93.12,92.89 92.66,92.43 89.52,92.43 89.03,91.93 89.03,91.82 v2(89.02,91.82)
SOC_DDR3A_EBA_0: length 59.9
  TOP w0.102: v2(91.02,90.92) 90.52,91.42 U24.B11
  TOP w0.127: v1(116.32,73.8) 116.32,73.34 115.53,72.55 DIMM1.119
  L3 w0.114: v2(91.02,90.92) 91.02,90.77 91.48,90.31 92.19,90.31 92.72,89.78 92.72,89.6 95.19,87.13 107.91,87.13 110.49,84.55 110.49,83.3 113.86,79.93 114.66,79.93 114.83,79.76 114.83,77.63 114.95,77.52 115.63,77.52 115.75,77.4 115.75,77.17 115.63,77.06 114.85,77.06 114.73,76.94 114.73,76.72 114.85,76.6 115.79,76.6 115.9,76.49 115.9,76.26 115.79,76.14 114.8,76.14 114.68,76.03 114.68,75.68 114.8,75.56 115.23,75.56 115.34,75.45 115.34,74.63 115.47,74.5 115.71,74.5 115.82,74.61 115.82,75.35 115.94,75.46 116.17,75.46 116.28,75.35 116.28,74.49 116.39,74.37 116.62,74.37 116.74,74.49 116.74,75.25 116.85,75.36 117.08,75.36 117.19,75.25 117.19,74.61 117.31,74.5 117.54,74.5 117.65,74.61 117.65,75.3 117.77,75.41 117.99,75.41 118.11,75.3 118.11,74.61 118.22,74.5 118.45,74.5 118.57,74.61 118.57,75.17 118.68,75.29 118.85,75.29 119.02,75.11 119.02,74.61 119.14,74.5 119.34,74.5 119.46,74.38 119.46,74.15 119.27,73.96 118.88,73.96 118.77,73.85 118.77,73.46 118.63,73.33 118.42,73.33 118.31,73.44 118.31,73.85 118.19,73.96 117.97,73.96 117.85,73.85 117.85,73.04 117.74,72.92 117.51,72.92 117.39,73.04 117.39,73.85 117.28,73.96 116.43,73.96 116.32,73.85 v1(116.32,73.8)
SOC_DDR3A_EBA_1: length 60.1
  TOP w0.102: U24.C11 89.52,91.42 v2(90.02,90.92)
  TOP w0.127: DIMM1.108 119.63,75.85 v1(119.06,76.41)
  L3 w0.102: v2(90.02,90.92) 90.43,91.34 91.29,91.34 91.54,91.08 91.54,90.75 91.72,90.58 92.33,90.58
  L3 w0.114: v1(119.06,76.41) 119.55,75.92 121.1,75.92 121.22,76.03 121.22,76.49 121.33,76.61 121.56,76.61 121.67,76.49 121.67,76.03 121.79,75.92 122.02,75.92 122.13,76.03 122.13,77.38 122.25,77.5 122.47,77.5 122.59,77.38 122.59,75.55 122.47,75.44 122.34,75.44 122.23,75.32 122.23,73.93 122.11,73.81 121.88,73.81 121.77,73.93 121.77,75.32 121.65,75.44 121.43,75.44 121.31,75.32 121.31,73.93 121.2,73.81 120.97,73.81 120.85,73.93 120.85,75.32 120.74,75.44 119.26,75.44 118.3,76.39 117.75,76.39 117.64,76.51 117.64,76.77 117.53,76.89 117.3,76.89 117.18,76.77 117.18,76.51 117.07,76.39 116.84,76.39 116.72,76.51 116.72,76.77 116.61,76.89 116.51,76.89 116.15,77.25 116.15,77.98 115.49,78.64 115.49,80.06 115.18,80.38 114.01,80.38 110.9,83.49 110.9,84.71 108.08,87.53 95.38,87.53 92.33,90.58
SOC_DDR3A_EBA_2: length 59.8
  TOP w0.102: U24.G11 85.52,91.42 v2(86.02,90.92)
  TOP w0.127: v1(115.06,80.95) DIMM1.91
  L8 w0.102: 92.41,93.7 92.25,93.55 86.94,93.55 86.67,93.28 86.67,91.93 86.02,91.27 v2(86.02,90.92)
  L8 w0.114: v1(115.06,80.95) 115.53,80.48 115.96,80.48 116.29,80.81 117.5,80.81 117.61,80.69 117.61,80.28 117.73,80.16 117.95,80.16 118.07,80.28 118.07,80.69 118.18,80.81 118.41,80.81 118.53,80.69 118.53,80.28 118.64,80.16 118.87,80.16 118.98,80.28 118.98,80.69 119.1,80.81 121.25,80.81 121.93,81.49 121.93,89.88 120.04,91.77 104.37,91.77 102.44,93.7 92.41,93.7
SOC_DDR3A_ECAS#: length 60.4
  TOP w0.102: U24.C13 89.52,89.42 v2(90.02,88.92)
  TOP w0.127: v1(116.9,73.09) 116.9,72.25 115.4,70.75 DIMM1.125
  L3 w0.114: v2(90.02,88.92) 90.42,88.52 92.56,88.52 95.38,85.7 96.25,85.7 96.36,85.59 96.36,85 96.48,84.89 96.7,84.89 96.82,85 96.82,85.59 96.93,85.7 97.16,85.7 97.28,85.59 97.28,85 97.39,84.89 97.62,84.89 97.73,85 97.73,85.59 97.85,85.7 98.08,85.7 98.19,85.59 98.19,85 98.3,84.89 98.53,84.89 98.65,85 98.65,85.59 98.76,85.7 98.99,85.7 99.1,85.59 99.1,85 99.22,84.89 99.45,84.89 99.56,85 99.56,85.59 99.68,85.7 99.91,85.7 100.02,85.59 100.02,85 100.13,84.89 100.36,84.89 100.48,85 100.48,85.59 100.59,85.7 100.82,85.7 100.93,85.59 100.93,85 101.05,84.89 101.28,84.89 101.39,85 101.39,85.59 101.51,85.7 101.73,85.7 101.85,85.59 101.85,85 101.96,84.89 102.19,84.89 102.31,85 102.31,85.59 102.42,85.7 102.65,85.7 102.76,85.59 102.76,85 102.88,84.89 103.11,84.89 103.22,85 103.22,85.59 103.33,85.7 103.56,85.7 103.68,85.59 103.68,85 103.79,84.89 104.02,84.89 104.13,85 104.13,85.59 104.25,85.7 104.48,85.7 104.59,85.59 104.59,85 104.71,84.89 104.93,84.89 105.05,85 105.05,85.59 105.16,85.7 105.39,85.7 105.51,85.59 105.51,85 105.62,84.89 105.85,84.89 105.96,85 105.96,85.59 106.08,85.7 106.34,85.7 106.45,85.59 106.45,85 106.57,84.89 106.79,84.89 106.91,85 106.91,85.53 107.02,85.65 107.25,85.65 107.37,85.53 107.37,85 107.48,84.89 107.77,84.89 108.76,83.9 108.76,83.45 109.28,82.93 109.73,82.93 113.85,78.81 113.85,74.99 113.85,74.99 113.85,74.49 113.85,74.49 113.85,74.13 113.96,74.02 114.5,74.02 114.63,73.88 114.63,73.67 114.52,73.56 113.96,73.56 113.85,73.44 113.85,73.22 113.99,73.09 v1(116.9,73.09)
SOC_DDR3A_ECC0: length 47.4
  TOP w0.102: v2(92.48,86.82) 92.09,86.42 U24.A16
  TOP w0.127: DIMM1.69 114.62,89.95 116.52,88.05 v1(116.52,87.84)
  L8 w0.114: v2(92.48,86.82) 92.91,87.25 98.93,87.25 102.1,84.07 102.73,84.07 104.35,82.45 105.42,82.45 105.54,82.34 105.54,81.46 105.77,81.23 106.45,81.23 106.56,81.11 106.56,81.09 106.68,80.98 106.9,80.98 107.02,81.09 107.02,81.23 107.13,81.34 107.36,81.34 107.48,81.23 107.48,81.06 107.59,80.95 107.91,80.95 108.03,81.06 108.03,81.7 108.14,81.81 108.37,81.81 108.48,81.7 108.48,81.01 108.6,80.9 108.83,80.9 108.94,81.01 108.94,81.77 109.06,81.89 109.29,81.89 109.4,81.78 109.4,81.04 109.52,80.92 109.74,80.92 109.86,81.04 109.86,81.78 109.97,81.89 110.2,81.89 110.32,81.78 110.32,81.06 110.43,80.95 110.66,80.95 110.77,81.06 110.77,81.93 110.89,82.04 111.12,82.04 111.23,81.93 111.23,81.17 111.32,81.08 111.4,81.08 111.43,81.05 111.57,81.05 111.69,81.17 111.69,81.78 111.8,81.89 112.41,81.89 113.08,82.56 113.08,85.3 113.59,85.81 117.6,85.81 117.75,85.96 117.75,86.84 116.75,87.84 v1(116.52,87.84)
SOC_DDR3A_ECC1: length 47.6
  TOP w0.102: U24.C15 89.52,87.42 v2(90.02,86.92)
  TOP w0.127: DIMM1.71 114.59,89.35 115.86,88.08 v1(115.86,87.84)
  L8 w0.114: v1(115.86,87.84) 115.68,88.02 112.86,88.02 112.62,87.78 112.62,86.91 111.7,85.99 111.7,84.95 111.58,84.84 110.76,84.84 110.64,84.95 110.64,85.57 110.53,85.68 110.3,85.68 110.19,85.57 110.19,84.62 110.07,84.51 109.79,84.51 109.68,84.62 109.68,85.48 109.56,85.6 109.33,85.6 109.22,85.48 109.22,84.09 109.11,83.97 108.88,83.97 108.76,84.09 108.76,85.48 108.65,85.6 108.42,85.6 108.31,85.48 108.31,84.24 108.19,84.12 107.96,84.12 107.85,84.24 107.85,85.48 107.73,85.6 107.5,85.6 107.39,85.48 107.39,84.44 107.28,84.33 107.05,84.33 106.93,84.44 106.93,85.48 106.82,85.6 106.59,85.6 106.48,85.48 106.48,84.45 106.37,84.35 105.83,84.35 100.98,89.19 93.13,89.19 92.33,88.39 90.64,88.39 90.53,88.28 90.53,87.04 90.41,86.92 v2(90.02,86.92)
SOC_DDR3A_ECC2: length 47.4
  TOP w0.102: v2(91.02,85.92) 90.57,86.37 90.52,86.42 U24.B16
  TOP w0.127: v1(115.02,84.34) 114.63,83.95 DIMM1.81
  L8 w0.114: v2(91.02,85.92) 91.06,85.88 93.18,85.88 93.19,85.88 98.36,85.88 101.53,82.7 102.16,82.7 105.44,79.43 107.91,79.43 109.21,78.13 113.36,78.13 114.38,77.11 115.58,77.11 115.7,77.23 115.7,77.46 115.58,77.57 115.04,77.57 114.84,77.76 114.84,78.28 115.24,78.67 115.24,79.42 115.35,79.53 116.4,79.53 116.51,79.65 116.51,79.88 116.4,79.99 113.96,79.99 113.84,80.1 113.84,80.33 113.96,80.45 114.49,80.45 114.6,80.56 114.6,80.79 114.49,80.9 113.96,80.9 113.84,81.02 113.84,81.25 113.96,81.36 114.49,81.36 114.6,81.48 114.6,82.2 114.72,82.31 115.18,82.31 115.24,82.37 115.3,82.43 115.3,82.64 115.18,82.77 114.57,82.77 114.45,82.88 114.45,83.11 114.57,83.22 115.18,83.22 115.29,83.34 115.29,83.57 115.18,83.68 114.59,83.68 114.48,83.8 114.48,84.22 114.59,84.34 v1(115.02,84.34)
SOC_DDR3A_ECC3: length 47.4
  TOP w0.102: U24.F15 86.52,87.42 v2(87.02,86.92)
  TOP w0.127: v1(115.73,84.36) 115.73,84.24 114.84,83.35 DIMM1.83
  L8 w0.102: 93.18,86.33 93,86.33 92.77,86.11 92.43,86.11 91.69,86.11 91.49,86.31 87.63,86.31 87.02,86.92 v2(87.02,86.92)
  L8 w0.114: v1(115.73,84.36) 115.73,84.71 115.6,84.85 114.16,84.85 114,84.68 114,82.56 114,82.18 113.29,81.48 113.29,79.74 113.17,79.63 112.99,79.63 112.88,79.51 112.88,79.21 112.99,79.1 114.57,79.1 114.68,78.98 114.68,78.76 114.56,78.64 112.48,78.64 112.36,78.75 112.36,79.54 112.25,79.65 112.02,79.65 111.9,79.54 111.9,78.7 111.79,78.59 111.56,78.59 111.45,78.7 111.45,79.39 111.33,79.5 110.26,79.5 109.78,79.98 105.53,79.98 102.35,83.16 102.1,83.16 102.1,83.16 101.72,83.16 98.55,86.34 93.47,86.34 93.47,86.33 93.18,86.33
SOC_DDR3A_ECC4: length 47.4
  TOP w0.102: v2(89.02,86.92) 88.52,87.42 U24.D15
  TOP w0.127: DIMM1.72 120.62,89.05 118.86,87.29 v1(118.86,87.16)
  L8 w0.102: 92.23,89.53 89.08,89.53 88.62,89.08 88.62,87.32 v2(89.02,86.92)
  L8 w0.114: v1(118.86,87.16) 116.98,89.04 112.5,89.04 111.71,88.24 111.71,87.54 111.59,87.43 111.14,87.43 111.03,87.54 111.03,87.8 110.92,87.91 110.69,87.91 110.57,87.8 110.57,87.24 110.45,87.12 110.23,87.12 110.12,87.24 110.12,87.8 110,87.91 109.77,87.91 109.66,87.8 109.66,87.26 109.54,87.15 109.32,87.15 109.2,87.26 109.2,87.8 109.09,87.91 108.86,87.91 108.74,87.8 108.74,87.26 108.63,87.15 108.4,87.15 108.29,87.26 108.29,87.8 108.17,87.91 107.94,87.91 107.83,87.8 107.83,87.26 107.72,87.15 107.49,87.15 107.37,87.26 107.37,87.8 107.26,87.91 107.03,87.91 106.91,87.8 106.91,87.29 106.8,87.17 106.57,87.17 106.46,87.29 106.46,87.82 106.34,87.93 106.07,87.93 105.99,87.85 105.99,87.54 105.87,87.43 105.63,87.43 105.63,87.43 105.58,87.43 104.09,87.43 101.41,90.11 93.03,90.11 92.46,89.53 92.23,89.53
SOC_DDR3A_ECC5: length 47.4
  TOP w0.102: U24.F14 v2(87.02,87.92)
  TOP w0.127: v1(119.8,86.05) DIMM1.74
  L8 w0.102: 92.93,91.1 92.35,90.53 87.63,90.53 87.4,90.3 87.4,87.99 87.34,87.92 v2(87.02,87.92)
  L8 w0.114: v1(119.8,86.05) 119.8,87.66 117.48,89.98 112.15,89.98 111.07,88.9 104.09,88.9 101.08,91.91 98.32,91.91 98.21,91.8 98.21,91.15 98.12,91.06 97.84,91.06 97.75,91.15 97.75,91.8 97.64,91.91 97.41,91.91 97.29,91.8 97.29,91.17 97.18,91.06 96.95,91.06 96.84,91.17 96.84,91.8 96.72,91.91 96.49,91.91 96.38,91.8 96.38,91.15 96.29,91.06 96.01,91.06 95.92,91.15 95.92,91.8 95.81,91.91 95.58,91.91 95.46,91.8 95.46,91.21 95.35,91.1 92.93,91.1
SOC_DDR3A_ECC6: length 47.4
  TOP w0.102: U24.D14 88.52,88.42 v2(89.02,87.92)
  TOP w0.127: v1(119.47,84.25) DIMM1.80
  L8 w0.102: v2(89.02,87.92) 89.51,88.42 89.51,89.15 89.66,89.31 92.66,89.31
  L8 w0.114: 92.66,89.31 93,89.65 101.22,89.65 103.9,86.97 104.35,86.97 104.46,86.86 104.46,86.4 104.58,86.28 104.8,86.28 104.92,86.4 104.92,86.86 105.03,86.97 105.26,86.97 105.38,86.86 105.38,85.46 105.49,85.34 105.72,85.34 105.83,85.46 105.83,86.75 105.95,86.87 106.21,86.87 106.32,86.75 106.32,86.17 106.44,86.06 106.67,86.06 106.78,86.17 106.78,86.6 106.9,86.72 107.12,86.72 107.24,86.6 107.24,86.22 107.35,86.11 107.58,86.11 107.7,86.22 107.7,86.5 107.81,86.61 108.04,86.61 108.15,86.5 108.15,86.19 108.27,86.08 108.5,86.08 108.61,86.19 108.61,86.55 108.72,86.66 108.95,86.66 109.07,86.55 109.07,86.17 109.18,86.06 109.41,86.06 109.52,86.17 109.52,86.55 109.64,86.66 110.49,86.66 110.64,86.66 110.95,86.97 111.78,86.97 112.17,87.35 112.17,88.05 112.69,88.58 116.67,88.58 118.27,86.98 118.27,85.44 v1(119.47,84.25)
SOC_DDR3A_ECC7: length 47.5
  TOP w0.102: v2(86.02,86.92) 85.52,87.42 U24.G15
  TOP w0.127: DIMM1.82 119.39,83.65 v1(118.83,84.21)
  L8 w0.102: 93.18,86.79 93,86.79 92.51,86.31 91.92,86.31 91.69,86.54 88.85,86.54 88.52,86.87 88.52,87.07 88.16,87.43 86.52,87.43 v2(86.02,86.92)
  L8 w0.114: 93.18,86.79 98.74,86.79 101.64,83.88 101.91,83.62 102.54,83.62 105.72,80.43 109.97,80.43 110.45,79.96 110.76,79.96 110.87,80.07 110.87,80.51 110.99,80.62 111.21,80.62 111.33,80.51 111.33,80.07 111.44,79.96 111.67,79.96 111.79,80.07 111.79,80.58 111.9,80.7 112.13,80.7 112.24,80.58 112.24,80.28 112.36,80.16 112.62,80.16 112.74,80.28 112.74,81.57 113.54,82.37 113.54,85.11 113.75,85.33 117.72,85.33 118.83,84.22 v1(118.83,84.21)
SOC_DDR3A_ECKE_0: length 60.4
  TOP w0.102: U24.G12 85.52,90.42 v2(86.02,89.92)
  TOP w0.127: DIMM1.87 115.23,82.15 v1(115.76,81.62)
  L8 w0.114: v2(86.02,89.92) 86.46,90.37 86.46,90.98 86.91,91.43 90.27,91.43 90.5,91.67 93.94,91.67 94.05,91.78 94.05,92.37 94.17,92.48 94.39,92.48 94.51,92.37 94.51,91.78 94.62,91.67 94.85,91.67 94.97,91.78 94.97,92.25 95.08,92.37 101.37,92.37 104.33,89.41 110.9,89.41 111.92,90.43 117.67,90.43 120.38,87.72 120.38,85.54 120.27,85.43 119.49,85.43 119.38,85.31 119.38,85.08 119.49,84.97 120.27,84.97 120.38,84.85 120.38,83.53 120.27,83.41 117.87,83.41 117.76,83.53 117.76,84.57 117.64,84.68 117.42,84.68 117.3,84.57 117.3,83.53 117.19,83.41 116.96,83.41 116.84,83.53 116.84,84.72 116.73,84.84 116.5,84.84 116.39,84.72 116.39,83.53 116.27,83.41 116.01,83.41 115.76,83.16 v1(115.76,81.62)
SOC_DDR3A_ECKE_1: length 59.9
  TOP w0.102: v2(92.08,90.96) 91.98,90.96 U24.A11
  TOP w0.127: DIMM1.89 115,81.55 v1(115.1,81.65)
  L3 w0.114: v2(92.08,90.96) 92.41,90.96 92.94,90.42 93.31,90.42 94.79,88.94 95.27,88.94 95.39,88.83 95.39,88.53 95.5,88.42 95.73,88.42 95.84,88.53 95.84,88.83 95.96,88.94 96.19,88.94 96.3,88.83 96.3,88.02 96.4,87.93 96.66,87.93 96.76,88.02 96.76,88.83 96.87,88.94 97.1,88.94 97.21,88.83 97.21,88.02 97.31,87.93 97.58,87.93 97.67,88.02 97.67,88.83 97.79,88.94 98.02,88.94 98.13,88.83 98.13,88.02 98.22,87.93 98.49,87.93 98.59,88.02 98.59,88.83 98.7,88.94 98.93,88.94 99.04,88.83 99.04,88.02 99.14,87.93 99.41,87.93 99.5,88.02 99.5,88.83 99.62,88.94 100.47,88.94 100.59,88.83 100.59,88.07 100.7,87.96 100.93,87.96 101.04,88.07 101.04,88.84 101.16,88.95 101.39,88.95 101.5,88.84 101.5,88.07 101.62,87.96 101.84,87.96 101.96,88.07 101.96,88.84 102.07,88.95 102.3,88.95 102.42,88.84 102.42,88.07 102.53,87.96 102.76,87.96 102.87,88.07 102.87,88.84 102.99,88.95 103.22,88.95 103.33,88.84 103.33,88.07 103.44,87.96 103.67,87.96 103.79,88.07 103.79,88.83 103.9,88.94 104.13,88.94 104.24,88.83 104.24,88.07 104.36,87.96 104.59,87.96 104.7,88.07 104.7,88.83 104.82,88.94 105.04,88.94 105.16,88.83 105.16,88.07 105.27,87.96 105.5,87.96 105.62,88.07 105.62,88.83 105.73,88.94 105.96,88.94 106.07,88.83 106.07,88.07 106.19,87.96 106.42,87.96 106.53,88.07 106.53,88.83 106.64,88.94 107.34,88.94 110.86,85.43 111.42,85.43 111.51,85.34 111.51,84.39 111.62,84.28 111.91,84.28 112.03,84.39 112.03,84.82 112.14,84.94 112.51,84.94 112.62,84.82 112.62,84.3 112.74,84.18 113.2,84.18 113.31,84.07 113.31,83.84 113.2,83.73 112.03,83.73 111.91,83.61 111.91,83.35 112.03,83.24 114.13,83.24 114.25,83.12 114.25,82.89 114.13,82.78 112.76,82.78 112.65,82.66 112.65,82.44 112.76,82.32 113.95,82.32 114.06,82.21 114.06,80.96 114.18,80.85 114.41,80.85 114.52,80.96 114.52,81.95 114.63,82.07 114.98,82.07 115.1,81.95 v1(115.1,81.65)
SOC_DDR3A_ECKN_0: length 60.2
  TOP w0.102: v2(91.02,89.92) 90.52,90.42 U24.B12
  TOP w0.127: DIMM1.113 114.48,74.35 114.66,74.53 116.99,74.53 117.35,74.89 117.35,75.58 v1(117.62,75.85)
  L10 w0.102: 92.9,89.31 91.82,89.31 91.55,89.58 91.55,89.79 91.41,89.92 v2(91.02,89.92)
  L10 w0.114: v1(117.62,75.85) 117.56,75.85 117.37,75.67 117.37,75.5 117.6,75.27 118.76,75.27 119.35,75.87 120.28,75.87 120.84,76.43 120.84,76.89 121.09,77.14 122.4,77.14 122.52,77.26 122.52,77.6 122.4,77.71 121.09,77.71 120.84,77.97 120.84,78.51 121.09,78.77 122.52,78.77 122.63,78.88 122.63,79.23 122.52,79.34 121.09,79.34 120.84,79.6 120.84,88.8 120.46,89.18 109.77,89.18 108.52,90.44 94.03,90.44 92.9,89.31
SOC_DDR3A_ECKN_1: length 60.2
  TOP w0.102: v2(91.02,88.92) 90.52,89.42 U24.B13
  TOP w0.127: DIMM1.114 120.72,74.05 120.57,74.2 120.36,74.2 v1(120.16,74)
  L10 w0.102: 93.18,88.28 93.17,88.28 93.16,88.29 91.51,88.29 91.24,88.56 91.24,88.87 91.19,88.92 v2(91.02,88.92)
  L10 w0.114: v1(120.16,74) 119.97,74.19 116.62,74.19 115.57,75.25 115.57,77.73 119.21,81.38 119.21,82.35 118.92,82.64 117.32,82.64 117.06,82.89 117.06,83.44 116.95,83.55 116.61,83.55 116.49,83.44 116.49,82.89 116.24,82.64 113.79,82.64 113.53,82.89 113.53,83.37 114.23,84.07 114.23,84.23 113.99,84.47 113.83,84.47 113.13,83.77 112.76,83.77 112.17,84.37 112.17,84.73 113.69,86.25 113.69,86.41 113.45,86.66 113.28,86.66 111.76,85.13 111.4,85.13 110.19,86.34 110.19,86.7 111.34,87.85 111.34,88.01 111.1,88.26 110.94,88.26 109.79,87.11 109.42,87.11 106.99,89.55 94.61,89.55 93.35,88.28 93.18,88.28
SOC_DDR3A_ECKP_0: length 60.2
  TOP w0.102: U24.A12 91.52,90.42 v2(92.02,89.92)
  TOP w0.127: DIMM1.111 114.53,74.95 114.69,74.79 116.88,74.79 117.09,75 117.09,75.72 v1(116.96,75.85)
  L10 w0.102: v2(92.02,89.92) 91.93,89.92 91.78,89.77 91.78,89.68 91.92,89.53 92.79,89.53
  L10 w0.114: v1(116.96,75.85) 117.01,75.85 117.09,75.77 117.13,75.73 117.13,75.4 117.5,75.03 118.86,75.03 119.45,75.63 120.38,75.63 121.08,76.33 121.08,76.79 121.19,76.9 122.5,76.9 122.76,77.16 122.76,77.7 122.5,77.96 121.19,77.96 121.08,78.07 121.08,78.41 121.19,78.53 122.62,78.53 122.87,78.78 122.87,79.33 122.62,79.58 121.19,79.58 121.08,79.7 121.08,88.9 120.56,89.42 109.87,89.42 108.62,90.68 93.93,90.68 92.79,89.53
SOC_DDR3A_ECKP_1: length 60.2
  TOP w0.102: v2(92.02,88.92) 91.52,89.42 U24.A13
  TOP w0.127: v1(120.16,74.65) 120.35,74.46 120.48,74.46 120.67,74.65 DIMM1.112
  L10 w0.102: v2(92.02,88.92) 91.52,88.92 91.47,88.87 91.47,88.66 91.6,88.52 93.15,88.52 93.16,88.53 93.18,88.53
  L10 w0.114: 93.18,88.53 93.25,88.53 94.51,89.79 107.09,89.79 109.53,87.35 109.69,87.35 110.83,88.5 111.2,88.5 111.58,88.11 111.58,87.75 110.43,86.6 110.43,86.44 111.5,85.38 111.66,85.38 113.18,86.9 113.55,86.9 113.93,86.51 113.93,86.15 112.41,84.63 112.41,84.47 112.86,84.01 113.03,84.01 113.73,84.72 114.09,84.72 114.48,84.33 114.48,83.97 113.77,83.27 113.77,82.99 113.89,82.88 116.14,82.88 116.25,82.99 116.25,83.54 116.51,83.79 117.05,83.79 117.31,83.54 117.31,82.99 117.42,82.88 119.02,82.88 119.46,82.45 119.46,81.28 115.81,77.63 115.81,75.35 116.72,74.43 119.98,74.43 120.16,74.62 v1(120.16,74.65)
SOC_DDR3A_ECS_0#: length 59.8
  TOP w0.102: v2(89.03,90.97) 88.98,90.97 88.53,91.42 U24.D11
  TOP w0.127: v1(117.26,71.84) 115.56,70.15 DIMM1.127
  L3 w0.114: v1(117.26,71.84) 116.81,71.84 116.4,72.25 116.39,72.25 116.38,72.26 113.13,72.26 113.01,72.38 113.01,78.52 109.4,82.13 107.71,82.13 106.26,83.58 105.68,83.58 105.57,83.69 105.57,83.93 105.45,84.05 105.22,84.05 105.11,83.93 105.11,83.25 104.99,83.13 104.77,83.13 104.65,83.25 104.65,83.93 104.54,84.05 104.31,84.05 104.19,83.93 104.19,83.25 104.08,83.13 103.85,83.13 103.74,83.25 103.74,83.93 103.62,84.05 103.39,84.05 103.28,83.93 103.28,83.22 103.18,83.12 102.92,83.12 102.82,83.22 102.82,83.93 102.71,84.05 102.48,84.05 102.37,83.93 102.37,83.25 102.25,83.13 102.02,83.13 101.91,83.25 101.91,83.93 101.79,84.05 101.57,84.05 101.45,83.93 101.45,83.25 101.34,83.13 101.11,83.13 100.99,83.25 100.99,83.93 100.88,84.05 100.65,84.05 100.54,83.93 100.54,83.25 100.42,83.13 100.19,83.13 100.08,83.25 100.08,83.93 99.97,84.05 99.74,84.05 99.62,83.93 99.62,83.45 99.51,83.34 99.3,83.34 99.16,83.48 99.16,83.93 99.05,84.05 98.82,84.05 98.71,83.93 98.71,83.68 98.61,83.58 98.35,83.58 98.25,83.68 98.25,83.93 98.14,84.05 97.91,84.05 97.79,83.93 97.79,83.73 97.68,83.62 97.45,83.62 97.34,83.73 97.34,83.93 97.22,84.05 96.99,84.05 96.88,83.93 96.88,83.73 96.76,83.62 96.54,83.62 96.42,83.73 96.42,83.93 96.31,84.05 95.86,84.05 92.53,87.38 89.69,87.38 89.46,87.6 89.46,89.13 89.08,89.51 88.85,89.51 88.52,89.84 88.52,90.46 v2(89.03,90.97)
SOC_DDR3A_ECS_1#: length 60.1
  TOP w0.102: U24.F11 86.63,91.42 v2(87.05,91.01)
  TOP w0.127: v1(116.72,70.49) 115.78,69.55 DIMM1.129
  L3 w0.114: v1(116.72,70.49) 112.16,70.49 111.76,70.9 111.76,78.07 111.62,78.21 111.41,78.21 111.3,78.09 111.3,76.06 111.19,75.95 110.96,75.95 110.84,76.06 110.84,77.97 110.73,78.08 109.3,78.08 106.15,81.22 105.63,81.22 105.51,81.34 105.51,81.81 105.4,81.92 105.09,81.92 104.98,81.81 104.98,81.39 104.86,81.28 104.64,81.28 104.52,81.39 104.52,81.81 104.41,81.92 104.18,81.92 104.06,81.81 104.06,81.39 103.95,81.28 103.72,81.28 103.61,81.39 103.61,81.81 103.49,81.92 103.26,81.92 103.15,81.81 103.15,81.39 103.03,81.28 102.81,81.28 102.69,81.39 102.69,81.81 102.58,81.92 102.35,81.92 102.23,81.81 102.23,81.39 102.12,81.28 101.89,81.28 101.78,81.39 101.78,81.81 101.66,81.92 100.61,81.92 99.92,81.23 95.38,81.23 92.08,84.53 86.84,84.53 86.61,84.76 86.61,90.58 v2(87.05,91.01)
SOC_DDR3A_EDM_0: length 47.4
  TOP w0.102: U24.C2 v2(90.02,100.92)
  TOP w0.127: DIMM1.11 117.01,107.35 v1(117.98,106.38)
  L8 w0.114: v1(117.98,106.38) 117.98,106.49 118.09,106.6 118.38,106.6 118.49,106.49 118.49,105.96 118.61,105.84 119.49,105.84 119.61,105.73 119.61,105.45 119.49,105.33 118.57,105.33 118.45,105.22 118.45,104.15 118.34,104.04 118.11,104.04 118,104.15 118,105.78 117.88,105.89 117.65,105.89 117.54,105.78 117.54,104.03 117.45,103.94 117.17,103.94 117.08,104.03 117.08,105.78 116.97,105.89 116.74,105.89 116.62,105.78 116.62,104.43 116.51,104.32 110.11,104.32 107.29,101.5 90.59,101.5 v2(90.02,100.92)
SOC_DDR3A_EDM_1: length 47.3
  TOP w0.102: U24.F3 v2(86.02,99.92)
  TOP w0.127: DIMM1.28 119.39,102.25 v1(118.97,102.68)
  L10 w0.114: v1(118.97,102.68) 118.97,103.51 114.07,108.41 107.96,108.41 107.85,108.52 107.85,108.88 107.73,108.99 107.51,108.99 107.39,108.88 107.39,108.52 107.28,108.41 107.05,108.41 106.93,108.52 106.93,108.88 106.82,108.99 106.59,108.99 106.48,108.88 106.48,108.52 106.36,108.41 106.13,108.41 106.02,108.52 106.02,108.88 105.91,108.99 105.68,108.99 105.56,108.88 105.56,108.52 105.45,108.41 105.03,108.41 101.9,105.28 89.31,105.28 88.39,104.37 88.39,102.34 87.48,101.42 86.77,101.42 86.56,101.22 86.56,100.76 86.02,100.22 v2(86.02,99.92)
SOC_DDR3A_EDM_2: length 47.4
  TOP w0.127: DIMM1.44 120.37,97.45 v1(119.4,96.48) ; U24.A6 94.24,96.42 v2(94.31,96.49)
  L8 w0.114: v1(119.4,96.48) 119.4,96.79 119.51,96.9 121.5,96.9 121.62,97.02 121.62,101.64 121.53,101.73 121.25,101.73 121.16,101.64 121.16,97.64 121.06,97.54 119.11,97.54 119,97.42 119,96.7 118.74,96.44 118.46,96.44 118.29,96.27 118,96.27 117.83,96.44 117.55,96.44 117.37,96.27 117.09,96.27 116.92,96.44 116.62,96.44 116.18,96 115.67,96 115.51,95.83 115.21,95.83 115.05,96 114.75,96 114.59,95.83 114.3,95.83 114.13,96 113.84,96 113.68,95.83 113.38,95.83 113.22,96 112.92,96 112.76,95.83 112.47,95.83 112.31,96 111.98,96 111.86,95.88 111.86,95.68 111.75,95.56 110.63,95.56 110.52,95.68 110.52,96.12 110.4,96.23 110.17,96.23 110.06,96.12 110.06,96 109.94,95.88 109.75,95.88 109.4,96.23 106.54,96.23 106.27,96.49 v2(94.31,96.49)
SOC_DDR3A_EDM_3: length 47.5
  TOP w0.102: U24.E6 v2(87.02,96.92)
  TOP w0.127: v1(115.08,92.44) 114.57,92.95 DIMM1.59
  L10 w0.102: 92.81,93.12 92.23,92.53 91.26,92.53 90.25,93.55 89.71,93.55 89.53,93.73 89.53,95.17 89.29,95.42 88.84,95.42 88.66,95.59 88.66,96.35 88.58,96.43 86.5,96.43 86.39,96.55 86.39,96.81 86.5,96.92 v2(87.02,96.92)
  L10 w0.114: 92.81,93.12 95.75,93.12 95.86,93.23 95.86,93.87 95.98,93.98 96.22,93.98 96.32,93.88 96.32,93.23 96.44,93.12 96.68,93.12 96.78,93.22 96.78,93.87 96.89,93.98 97.13,93.98 97.24,93.88 97.24,93.23 97.35,93.12 97.59,93.12 97.69,93.22 97.69,93.87 97.81,93.98 98.05,93.98 98.15,93.88 98.15,93.23 98.26,93.12 98.51,93.12 98.61,93.22 98.61,93.87 98.72,93.98 98.96,93.98 99.07,93.88 99.07,93.23 99.18,93.12 99.42,93.12 99.52,93.22 99.52,93.87 99.64,93.98 99.94,93.98 100.06,93.87 100.06,93.23 100.17,93.12 100.41,93.12 100.51,93.22 100.51,93.87 100.63,93.98 100.88,93.98 100.99,93.87 100.99,93.23 101.1,93.12 101.38,93.12 101.5,93.23 101.5,93.87 101.61,93.98 106.72,93.98 106.83,93.87 106.83,93.21 106.92,93.12 107.18,93.12 107.29,93.23 107.29,93.71 107.4,93.83 107.63,93.83 107.75,93.71 107.75,93.23 107.86,93.12 109.04,93.12 109.7,92.46 110.95,92.46 111.42,92.93 112.81,92.93 113.3,92.44 v1(115.08,92.44)
SOC_DDR3A_EDM_4: length 53.8
  TOP w0.102: U24.C17 v2(90.02,84.92)
  TOP w0.127: DIMM1.140 120.07,66.25 v1(119.42,65.59)
  L10 w0.102: 92.61,84.05 92.33,84.33 90.61,84.33 v2(90.02,84.92)
  L10 w0.114: v1(119.42,65.59) 119.46,65.63 119.46,66.34 119.57,66.45 119.93,66.45 120.04,66.57 120.04,66.8 119.93,66.91 119.57,66.91 119.46,67.02 119.46,67.25 119.57,67.37 119.93,67.37 120.04,67.48 120.04,67.71 119.93,67.82 119.57,67.82 119.46,67.94 119.46,68.11 119.34,68.22 119.05,68.22 118.93,68.11 118.93,65.11 118.68,64.86 114.58,64.86 112.91,66.52 111.88,66.52 111.42,66.99 111.42,75.9 105.37,81.94 104.14,81.94 102.03,84.05 92.61,84.05
SOC_DDR3A_EDM_5: length 53.3
  TOP w0.102: U24.A18 v2(92.02,83.92)
  TOP w0.127: DIMM1.157 114.59,61.15 114.97,61.53 v1(114.97,61.88)
  L8 w0.114: v2(92.02,83.92) 92.48,83.92 93.12,83.29 96.62,83.29 100.03,79.88 100.63,79.88 102.74,77.77 102.74,77.65 104.7,75.69 105.83,75.69 106.21,75.69 106.21,75.69 106.61,75.69 106.72,75.58 106.72,75.18 106.85,75.06 107.07,75.06 107.18,75.17 107.18,75.58 107.3,75.69 107.52,75.69 107.64,75.58 107.64,74.92 107.75,74.8 107.98,74.8 108.1,74.92 108.1,75.58 108.21,75.69 108.44,75.69 108.55,75.58 108.55,74.89 108.67,74.78 108.9,74.78 109.01,74.89 109.01,75.58 109.12,75.69 109.35,75.69 109.47,75.58 109.47,74.94 109.58,74.83 109.81,74.83 109.92,74.94 109.92,75.58 110.04,75.69 110.66,75.69 113.97,72.38 113.97,64.93 115.1,63.81 115.84,63.81 115.95,63.92 115.95,64.63 116.07,64.74 116.27,64.74 116.38,64.63 116.38,63.46 116.27,63.35 115.09,63.35 114.97,63.24 114.97,63.01 115.09,62.89 116.5,62.89 116.61,62.78 116.61,62.55 116.5,62.44 115.09,62.44 114.97,62.32 v1(114.97,61.88)
SOC_DDR3A_EDM_6: length 55.9
  TOP w0.102: U24.D21 v2(89.02,80.92)
  TOP w0.127: v1(119.64,57.82) 119.64,57.65 120.64,56.65 DIMM1.172
  L10 w0.102: 92.71,78.82 92.2,79.32 90.68,79.32 90.42,79.58 90.42,80.14 90.14,80.42 89.53,80.42 89.03,80.92 v2(89.02,80.92)
  L10 w0.114: 92.71,78.82 95.42,78.82 98.42,75.81 98.42,68.24 98.79,67.87 101.13,67.87 101.6,67.4 101.6,62.8 104.18,60.22 104.52,60.22 107.68,57.06 112.66,57.06 114.26,55.46 117.98,55.46 118.61,56.08 118.61,57.14 118.72,57.25 119.06,57.25 119.18,57.14 119.18,56.69 119.29,56.58 119.48,56.58 119.48,56.58 120.05,56.58 120.14,56.67 120.14,57.05 120.04,57.15 119.76,57.15 119.64,57.26 v1(119.64,57.82)
SOC_DDR3A_EDM_7: length 54.3
  TOP w0.102: U24.A22 v2(92.02,79.92)
  TOP w0.127: v1(115.73,52.54) 114.74,51.55 DIMM1.189
  L8 w0.102: 92.33,78.36 91.04,78.36 90.64,78.77 90.64,79.08 91.03,79.48 91.26,79.48 91.71,79.92 v2(92.02,79.92)
  L8 w0.114: v1(115.73,52.54) 115.73,53.5 114.09,55.14 112.03,55.14 109.41,57.76 109.41,57.82 109.41,57.82 109.41,58.2 109.41,59.44 107.89,60.96 106.65,60.96 106.25,61.36 106.25,62.6 104.21,64.64 102.49,64.64 102.18,64.95 100.25,64.95 99.56,65.65 99.56,67.39 99.07,67.88 98.75,68.2 93.85,68.2 93.6,68.45 93.57,68.45 93.57,69.21 93.69,69.32 94.68,69.32 94.79,69.44 94.79,69.67 94.68,69.78 93.56,69.78 93.45,69.9 93.45,70.13 93.56,70.24 94.68,70.24 94.79,70.35 94.79,70.58 94.68,70.7 93.81,70.7 93.7,70.81 93.7,76.99 92.33,78.36
SOC_DDR3A_EDM_8: length 47.4
  TOP w0.102: v2(88.02,87.92) 87.52,88.42 U24.E14
  TOP w0.127: DIMM1.76 119.53,85.45 119.04,85.94 v1(119.04,86.04)
  L8 w0.102: 92.71,90.32 87.83,90.32 87.6,90.09 87.6,88.34 v2(88.02,87.92)
  L8 w0.114: v1(119.04,86.04) 119.34,86.34 119.34,87.36 117.18,89.52 112.34,89.52 111.21,88.39 105.64,88.39 105.53,88.28 105.53,87.97 105.44,87.88 105.16,87.88 105.07,87.97 105.07,88.28 104.96,88.39 104.73,88.39 104.61,88.28 104.61,88.07 104.5,87.96 104.27,87.96 104.16,88.07 104.16,88.28 104.04,88.39 103.89,88.39 101.68,90.6 101.09,90.6 100.97,90.72 100.97,91.33 100.86,91.44 100.63,91.44 100.52,91.33 100.52,90.69 100.4,90.58 100.17,90.58 100.06,90.69 100.06,91.35 99.96,91.45 99.7,91.45 99.6,91.35 99.6,90.72 99.49,90.6 99.27,90.6 99.16,90.72 99.16,91.33 99.04,91.44 98.81,91.44 98.7,91.33 98.7,90.72 98.58,90.6 92.99,90.6 92.71,90.32
SOC_DDR3A_EDQ0: length 47.4
  TOP w0.102: U24.G1 v2(86.02,101.92)
  TOP w0.127: DIMM1.5 115.25,109.15 115.72,109.61 v1(115.72,109.76)
  L8 w0.114: v2(86.02,101.92) 86.02,103.49 87.5,104.98 102.74,104.98 103.35,105.58 103.35,105.74 103.15,105.94 103.15,106.1 103.31,106.26 103.47,106.26 103.67,106.07 103.83,106.07 103.99,106.23 103.99,106.39 103.8,106.58 103.8,106.74 103.96,106.91 104.12,106.91 104.32,106.71 104.48,106.71 104.64,106.87 104.64,107.04 104.44,107.23 104.44,107.39 104.61,107.55 104.77,107.55 104.96,107.36 105.15,107.36 106.53,108.74 106.53,109.32 106.41,109.43 105.78,109.43 105.66,109.55 105.66,109.78 105.78,109.89 106.41,109.89 106.53,110.01 106.53,110.23 106.41,110.35 105.73,110.35 105.61,110.46 105.61,110.69 105.73,110.81 106.41,110.81 106.53,110.92 106.53,111.15 106.65,111.28 114.36,111.28 114.48,111.16 114.48,110.63 114.59,110.52 114.82,110.52 114.94,110.63 114.94,111.16 115.05,111.28 115.24,111.28 115.38,111.14 115.38,110.71 115.49,110.59 115.89,110.59 116,110.48 116,110.36 115.72,110.08 v1(115.72,109.76)
SOC_DDR3A_EDQ1: length 47.3
  TOP w0.102: U24.H2 84.52,100.44 v2(85.06,100.99)
  TOP w0.127: DIMM1.7 115.39,108.55 116.4,109.56 v1(116.4,109.74)
  L8 w0.114: v1(116.4,109.74) 116.34,109.74 116.23,109.62 116.23,109.33 116.34,109.22 117.11,109.22 117.45,109.56 117.45,110.13 117.29,110.29 116.71,110.29 116.6,110.4 116.6,110.58 115.32,111.86 105.61,111.86 104.44,110.69 104.44,108.18 101.7,105.44 87.27,105.44 85.55,103.71 85.55,101.47 v2(85.06,100.99)
SOC_DDR3A_EDQ2: length 47.3
  TOP w0.102: U24.F1 v2(87.02,101.92)
  TOP w0.127: v1(115.64,106.16) 115.05,106.75 DIMM1.13
  L8 w0.114: v2(87.02,101.92) 87.21,101.73 87.88,101.73 89.29,103.14 103.62,103.14 106.93,106.45 107.81,106.45 107.93,106.57 107.93,107.4 108.04,107.52 108.27,107.52 108.38,107.4 108.38,106.79 108.5,106.68 108.73,106.68 108.84,106.79 108.84,107.4 108.96,107.52 109.18,107.52 109.3,107.4 109.3,106.79 109.41,106.68 109.64,106.68 109.76,106.79 109.76,108.01 109.87,108.13 110.1,108.13 110.21,108.01 110.21,106.82 110.33,106.71 110.56,106.71 110.67,106.82 110.67,107.99 110.78,108.1 111.01,108.1 111.13,107.99 111.13,106.9 111.24,106.78 111.47,106.78 111.58,106.9 111.58,107.89 111.7,108 111.93,108 112.04,107.89 112.04,107 112.16,106.88 112.38,106.88 112.5,107 112.5,107.89 112.61,108 112.84,108 112.96,107.89 112.96,107.05 113.07,106.93 113.3,106.93 113.41,107.05 113.41,107.4 113.53,107.52 113.79,107.52 113.96,107.35 113.96,106.95 114.31,106.6 115.54,106.6 115.64,106.5 v1(115.64,106.16)
SOC_DDR3A_EDQ3: length 47.4
  TOP w0.102: U24.G2 v2(86.02,100.92)
  TOP w0.127: DIMM1.15 v1(115,106.15)
  L8 w0.114: v1(115,106.15) 114.84,105.99 114.04,105.99 113.93,106.11 113.93,106.34 113.81,106.45 113.58,106.45 113.47,106.34 113.47,106.11 113.35,105.99 113.12,105.99 113.01,106.11 113.01,106.39 112.9,106.5 112.67,106.5 112.55,106.39 112.55,106.11 112.44,105.99 112.21,105.99 112.1,106.11 112.1,106.34 111.98,106.45 111.79,106.45 111.66,106.32 111.66,106.32 111.64,106.31 111.64,106.11 111.52,105.99 109.61,105.99 109.41,106.2 108.72,106.2 108.61,106.08 108.61,105.18 108.5,105.07 108.19,105.07 107.31,105.94 107.19,105.94 106.9,105.66 106.9,105.5 107.8,104.6 107.8,104.44 107.63,104.28 107.47,104.28 106.58,105.17 106.42,105.17 106.26,105.01 106.26,104.85 107.15,103.96 107.15,103.8 106.99,103.63 106.83,103.63 105.93,104.53 105.77,104.53 105.61,104.37 105.61,104.2 106.5,103.31 106.5,103.15 106.34,102.99 106.18,102.99 105.29,103.88 105.12,103.88 104.96,103.72 104.96,103.56 105.61,102.91 105.61,102.74 105.45,102.58 105.29,102.58 104.64,103.23 104.48,103.23 103.91,102.67 89.33,102.67 87.07,100.41 86.53,100.41 v2(86.02,100.92)
SOC_DDR3A_EDQ4: length 47.4
  TOP w0.102: U24.H1 v2(85.02,101.92)
  TOP w0.127: v1(119.42,110.12) 119.42,109.99 119.96,109.45 DIMM1.4
  L8 w0.114: v1(119.42,110.12) 119.47,110.12 119.58,110.23 119.58,110.91 119.47,111.02 118.29,111.02 118.18,110.91 118.18,110.5 118.06,110.39 117.83,110.39 117.72,110.5 117.72,110.73 117.61,110.85 117.02,110.85 115.37,112.5 105.46,112.5 103.89,110.92 103.89,108.31 101.47,105.89 87.05,105.89 85.02,103.86 v2(85.02,101.92)
SOC_DDR3A_EDQ5: length 47.3
  TOP w0.102: U24.E2 v2(87.02,100.92)
  TOP w0.127: DIMM1.6 119.8,108.85 118.65,109.99 v1(118.65,110.12)
  L8 w0.114: v1(118.65,110.12) 118.65,109.77 118.54,109.65 118.05,109.65 117.93,109.54 117.93,109.31 118.05,109.19 118.5,109.19 118.62,109.08 118.62,108.85 118.5,108.74 114.55,108.74 114.3,108.99 114.3,110.16 113.69,110.77 107.2,110.77 107.09,110.66 107.09,108.57 103.04,104.52 87.71,104.52 86.61,103.43 86.61,101.33 v2(87.02,100.92)
SOC_DDR3A_EDQ6: length 47.3
  TOP w0.102: U24.F2 v2(87.02,99.92)
  TOP w0.127: DIMM1.16 120.16,105.85 v1(120.09,105.77)
  L8 w0.114: v2(87.02,99.92) 87.6,100.51 91.34,100.51 91.87,101.04 107.48,101.04 110.3,103.86 116.26,103.86 116.64,103.48 118.64,103.48 118.95,103.78 118.95,104.64 119.06,104.75 121.96,104.75 122.07,104.86 122.07,105.66 122.07,105.66 122.07,106.79 121.96,106.91 121.73,106.91 121.61,106.79 121.61,105.89 121.5,105.77 121.27,105.77 121.16,105.89 121.16,106.82 121.04,106.93 120.81,106.93 120.7,106.82 120.7,105.89 120.59,105.77 v1(120.09,105.77)
SOC_DDR3A_EDQ7: length 47.3
  TOP w0.102: U24.D2 v2(89.02,100.92)
  TOP w0.127: DIMM1.18 118.35,105.25 v1(117.21,106.38)
  L8 w0.114: v2(89.02,100.92) 89.54,101.45 90.04,101.45 90.7,102.11 106.2,102.11 106.65,102.56 106.81,102.56 107.17,102.2 107.33,102.2 107.49,102.36 107.49,102.53 107.11,102.91 107.11,103.07 107.27,103.23 107.43,103.23 107.82,102.85 107.98,102.85 108.14,103.01 108.14,103.17 107.74,103.57 107.74,103.73 107.91,103.89 108.07,103.89 108.46,103.5 108.63,103.5 108.79,103.66 108.79,103.82 108.3,104.3 108.3,104.47 108.45,104.61 108.64,104.61 109.11,104.14 109.27,104.14 109.43,104.3 109.43,104.47 109.08,104.82 109.08,105.4 109.19,105.51 109.67,105.51 109.78,105.4 109.78,104.91 109.9,104.8 110.13,104.8 110.24,104.91 110.24,105.42 110.35,105.54 110.58,105.54 110.7,105.42 110.7,104.91 110.81,104.8 111.04,104.8 111.15,104.91 111.15,105.42 111.27,105.54 112.58,105.54 112.69,105.42 112.69,104.89 112.81,104.78 113.03,104.78 113.15,104.89 113.15,105.42 113.26,105.54 113.49,105.54 113.61,105.42 113.61,104.89 113.72,104.78 113.95,104.78 114.06,104.89 114.06,105.42 114.18,105.54 116.05,105.54 116.15,105.64 116.15,106.5 116.27,106.61 116.99,106.61 v1(117.21,106.38)
SOC_DDR3A_EDQ8: length 47.4
  TOP w0.102: U24.E4 v2(88.02,98.92)
  TOP w0.127: DIMM1.19 v1(115.03,104.95)
  L10 w0.114: v2(88.02,98.92) 87.5,99.44 87.5,100.15 90.91,103.56 90.92,103.56 91.23,103.86 91.23,103.88 91.72,104.37 102.46,104.37 104.52,106.43 106.45,106.43 106.56,106.54 106.56,107.15 106.68,107.26 106.91,107.26 107.02,107.15 107.02,106.49 107.14,106.38 107.37,106.38 107.48,106.49 107.48,107.15 107.59,107.26 107.82,107.26 107.94,107.15 107.94,106.44 108.03,106.35 108.3,106.35 108.39,106.44 108.39,107.23 108.48,107.31 108.76,107.31 108.85,107.23 108.85,106.46 108.97,106.35 109.19,106.35 109.31,106.46 109.31,107.18 109.42,107.29 109.65,107.29 109.77,107.18 109.77,106.49 109.88,106.38 110.11,106.38 110.22,106.49 110.22,107.23 110.31,107.31 110.59,107.31 110.68,107.23 110.68,106.44 110.77,106.35 111.05,106.35 111.14,106.44 111.14,107.15 111.15,107.16 111.15,107.2 111.26,107.31 111.48,107.31 111.59,107.2 111.59,106.46 111.71,106.35 111.94,106.35 112.05,106.46 112.05,107.2 112.17,107.31 112.39,107.31 112.51,107.2 112.51,106.46 112.62,106.35 112.85,106.35 112.97,106.46 112.97,107.15 113.08,107.26 113.31,107.26 113.42,107.15 113.42,106.26 114.74,104.95 v1(115.03,104.95)
SOC_DDR3A_EDQ9: length 47.3
  TOP w0.102: U24.F4 v2(87.02,98.92)
  TOP w0.127: v1(115.72,104.94) 115.13,104.35 DIMM1.21
  L10 w0.114: v2(87.02,98.92) 86.56,99.38 86.56,100.08 86.82,100.33 87.05,100.33 89.48,102.76 89.48,102.92 88.84,103.56 88.84,103.72 89,103.88 89.16,103.88 89.8,103.25 89.96,103.25 90.12,103.41 90.12,103.57 89.31,104.39 89.31,104.55 89.47,104.71 89.63,104.71 90.45,103.89 90.61,103.89 90.77,104.05 90.77,104.22 90.5,104.48 90.5,104.64 90.67,104.81 90.83,104.81 91.09,104.54 91.23,104.54 91.52,104.83 102.21,104.83 105.16,107.77 114,107.77 114.44,107.33 114.44,105.98 114.76,105.66 116.17,105.66 116.28,105.55 116.28,105.35 116.4,105.23 116.6,105.23 116.74,105.09 116.74,104.89 116.62,104.78 116.4,104.78 116.28,104.66 116.28,104.51 116.17,104.39 115.83,104.39 115.72,104.51 v1(115.72,104.94)
SOC_DDR3A_EDQ10: length 47.3
  TOP w0.102: U24.G3 v2(86.02,98.92)
  TOP w0.127: v1(116.15,100.26) 116.15,100.59 115.39,101.35 DIMM1.31
  L10 w0.114: v1(116.15,100.26) 116.68,100.26 116.79,100.15 116.79,99.28 116.91,99.16 117.13,99.16 117.25,99.28 117.25,100.15 117.36,100.26 117.59,100.26 117.71,100.15 117.71,98.84 117.82,98.73 118.05,98.73 118.16,98.84 118.16,100.15 118.28,100.26 119.37,100.26 119.48,100.38 119.48,100.76 119.37,100.87 95.08,100.87 92.74,98.53 92,98.53 91.79,98.32 86.62,98.32 v2(86.02,98.92)
SOC_DDR3A_EDQ11: length 47.4
  TOP w0.102: v2(92.08,97.99) 91.64,98.42 U24.A4
  TOP w0.127: DIMM1.33 115,100.75 v1(115.5,100.24)
  L10 w0.114: v1(115.5,100.24) 115.5,100.29 115.39,100.41 114.78,100.41 114.66,100.29 114.66,99.05 114.55,98.93 114.32,98.93 114.2,99.05 114.2,100.32 114.11,100.41 113.85,100.41 113.75,100.32 113.75,99.05 113.63,98.93 113.4,98.93 113.29,99.05 113.29,100.32 113.19,100.41 112.8,100.41 112.7,100.32 112.7,99.76 112.59,99.64 111.59,99.64 111.48,99.76 111.48,100.24 111.37,100.36 100.47,100.36 100.35,100.24 100.35,99.07 100.24,98.96 100.01,98.96 99.89,99.07 99.89,100.24 99.78,100.36 99.55,100.36 99.44,100.24 99.44,99.07 99.32,98.96 99.09,98.96 98.98,99.07 98.98,100.24 98.86,100.36 98.64,100.36 98.52,100.24 98.52,99.07 98.41,98.96 98.18,98.96 98.06,99.07 98.06,100.24 97.95,100.36 97.72,100.36 97.61,100.24 97.61,99.07 97.49,98.96 97.26,98.96 97.15,99.07 97.15,100.24 97.04,100.36 96.81,100.36 96.69,100.24 96.69,99.07 96.58,98.96 96.35,98.96 96.24,99.07 96.24,100.19 96.12,100.3 95.89,100.3 95.78,100.19 95.78,99.02 95.67,98.92 93.81,98.92 92.88,97.99 v2(92.08,97.99)
SOC_DDR3A_EDQ12: length 47.3
  TOP w0.102: U24.B4 91,98.91 v2(91.03,98.91)
  TOP w0.127: v1(119.53,103.44) 120.14,104.05 DIMM1.22
  L10 w0.114: v2(91.03,98.91) 91.39,99.26 91.97,99.26 92.57,99.86 92.57,100.02 92.3,100.29 92.3,100.46 92.46,100.62 92.63,100.62 92.9,100.35 93.06,100.35 93.22,100.51 93.22,100.67 92.95,100.94 92.95,101.1 93.11,101.26 93.27,101.26 93.54,100.99 93.7,100.99 93.87,101.16 93.87,101.32 93.6,101.59 93.6,101.75 93.76,101.91 93.92,101.91 94.19,101.64 94.35,101.64 94.55,101.84 119.12,101.84 119.64,102.36 120.87,102.36 121.17,102.65 121.17,102.85 121.28,102.96 121.83,102.96 121.95,103.08 121.95,103.31 121.83,103.42 121.28,103.42 121.17,103.54 121.17,103.76 121.28,103.88 121.83,103.88 121.95,103.99 121.95,104.22 121.83,104.34 121.28,104.34 121.17,104.45 121.17,105.14 121.05,105.26 120.82,105.26 120.71,105.14 120.71,102.93 120.6,102.81 119.64,102.81 119.53,102.93 v1(119.53,103.44)
SOC_DDR3A_EDQ13: length 47.4
  TOP w0.102: U24.H3 84.52,99.53 v2(84.91,99.92)
  TOP w0.127: v1(120.21,103.45) DIMM1.24
  L10 w0.114: v2(84.91,99.92) 85.34,99.92 85.57,100.15 85.57,102.34 88.98,105.74 101.22,105.74 105.13,109.65 114,109.65 115.09,108.56 118.58,108.56 118.69,108.45 118.69,105.69 120.21,104.17 v1(120.21,103.45)
SOC_DDR3A_EDQ14: length 47.3
  TOP w0.102: v2(89.05,99.97) 88.52,99.44 U24.D3
  TOP w0.127: v1(118.26,102.68) 118.26,102.62 120.43,100.45 DIMM1.34
  L10 w0.114: v2(89.05,99.97) 89.47,99.97 89.59,100.09 89.59,101.38 89.7,101.5 90.16,101.5 90.27,101.61 90.27,101.79 90.39,101.9 90.66,101.9 91.16,101.4 91.32,101.4 91.48,101.56 91.48,101.72 90.59,102.62 90.59,102.78 90.75,102.94 90.91,102.94 91.84,102.01 92,102.01 92.16,102.17 92.16,102.33 91.3,103.2 91.3,103.36 91.46,103.52 91.62,103.52 92.4,102.74 92.56,102.74 92.72,102.91 92.72,103.07 92.27,103.52 92.27,103.68 92.41,103.81 102.57,103.81 104.65,105.89 112.81,105.89 112.93,105.78 112.93,104.03 113.04,103.91 117.75,103.91 118.26,103.41 v1(118.26,102.68)
SOC_DDR3A_EDQ15: length 47.3
  TOP w0.102: U24.D4 89,98.91 v2(89.03,98.91)
  TOP w0.127: DIMM1.36 120.08,99.85 v1(120.06,99.83)
  L10 w0.102: 91.67,98.91 91.29,98.53 89.41,98.53 v2(89.03,98.91)
  L10 w0.114: v1(120.06,99.83) 120.98,99.83 121.09,99.94 121.09,100.5 121.21,100.61 121.43,100.61 121.55,100.5 121.55,98.64 121.66,98.53 121.89,98.53 122.01,98.64 122.01,102.3 121.89,102.41 121.65,102.41 121.54,102.3 121.54,101.28 121.42,101.17 121.21,101.17 121.09,101.28 121.09,101.77 120.98,101.88 120.75,101.88 120.63,101.77 120.63,101.28 120.52,101.17 119.77,101.17 119.56,101.38 94.78,101.38 92.3,98.91 91.67,98.91
SOC_DDR3A_EDQ16: length 47.3
  TOP w0.102: U24.G4 v2(86.02,97.92)
  TOP w0.127: v1(116.05,98.92) 115.41,99.55 DIMM1.37
  L8 w0.102: 91.7,99.03 91.19,98.53 86.62,98.53 v2(86.02,97.92)
  L8 w0.114: v1(116.05,98.92) 116.51,98.92 116.62,99.03 116.62,99.1 116.74,99.21 116.97,99.21 117.08,99.1 117.08,99.03 117.2,98.92 117.42,98.92 117.54,99.03 117.54,99.66 117.65,99.77 117.88,99.77 118,99.66 118,99.03 118.11,98.92 118.86,98.92 118.97,99.03 118.97,99.38 118.86,99.49 118.58,99.49 118.47,99.61 118.47,99.81 118.58,99.92 118.83,99.92 118.95,100.04 118.95,101.23 118.83,101.35 114.9,101.35 114.22,102.02 114.22,102.71 113.98,102.95 110.68,102.95 107.73,100 93.18,100 92.22,99.03 91.7,99.03
SOC_DDR3A_EDQ17: length 47.3
  TOP w0.102: U24.H5 84.73,97.42 v2(85.14,97.01)
  TOP w0.127: DIMM1.39 v1(115.26,98.95)
  L8 w0.102: 91.8,98.73 91.39,98.32 86.82,98.32 86.44,97.94 86.44,97.79 86.03,97.38 85.51,97.38 v2(85.14,97.01)
  L8 w0.114: 91.8,98.73 92.72,98.73 93.54,99.54 107.92,99.54 110.37,102 110.63,102 110.74,102.11 110.74,102.36 110.87,102.49 111.1,102.49 111.22,102.37 111.22,102.04 111.33,101.93 111.56,101.93 111.68,102.04 111.68,102.37 111.79,102.49 112.02,102.49 112.13,102.37 112.13,101.99 112.25,101.88 112.42,101.88 112.59,102.04 112.59,102.37 112.7,102.49 113.65,102.49 113.77,102.37 113.77,101.83 114.71,100.89 118.4,100.89 118.49,100.8 118.49,100.55 118.38,100.43 117.62,100.43 117.5,100.32 117.5,100.27 117.39,100.15 117.16,100.15 117.05,100.27 117.05,100.32 116.93,100.43 116.78,100.43 116.66,100.32 116.66,99.91 116.55,99.8 116.16,99.8 116.04,99.68 116.04,99.48 115.93,99.36 115.7,99.36 115.58,99.48 115.58,99.68 115.47,99.8 115.15,99.8 115.04,99.68 115.04,99.06 115.15,98.95 v1(115.26,98.95)
SOC_DDR3A_EDQ18: length 47.3
  TOP w0.102: v2(88.01,96.9) 88.01,96.92 U24.D5
  TOP w0.127: DIMM1.49 116.35,95.95 v1(117.21,95.08)
  L8 w0.114: v1(117.21,95.08) 119.44,95.08 119.56,95.2 119.56,95.69 119.44,95.81 116.64,95.81 116.2,95.38 112.85,95.38 112.58,95.11 109.87,95.11 109.21,95.76 106.27,95.76 106.07,95.96 90.65,95.96 90.09,96.52 88.72,96.52 88.6,96.64 88.6,97.26 88.87,97.54 89.45,97.54 89.56,97.65 89.56,97.9 89.45,98.02 88.48,98.02 88.37,97.91 88.37,97.73 88.08,97.43 87.57,97.43 87.45,97.32 87.45,95.97 87.57,95.86 88.05,95.86 88.16,95.97 88.16,96.79 88.05,96.9 v2(88.01,96.9)
SOC_DDR3A_EDQ19: length 47.4
  TOP w0.102: U24.F5 v2(87.02,97.92)
  TOP w0.127: v1(116.52,95.03) 116.52,95.03 116.2,95.35 DIMM1.51
  L8 w0.114: v1(116.52,95.03) 116.41,94.92 113.95,94.92 113.84,94.81 113.84,94.48 113.67,94.31 113.49,94.31 113.38,94.42 113.38,94.81 113.27,94.92 113.04,94.92 112.92,94.81 112.92,94.48 112.81,94.36 112.44,94.36 112.33,94.48 112.33,94.53 112.21,94.64 111.31,94.64 111.2,94.53 111.2,94.4 111.12,94.31 110.83,94.31 110.74,94.4 110.74,94.53 110.63,94.64 110.4,94.64 110.29,94.53 110.29,94.48 110.17,94.36 109.38,94.36 109.26,94.48 109.26,95.03 109.15,95.15 108.92,95.15 108.81,95.03 108.81,94.45 108.69,94.34 108.46,94.34 108.35,94.45 108.35,95.14 108.24,95.25 108.01,95.25 107.89,95.14 107.89,94.4 107.81,94.31 107.52,94.31 107.44,94.4 107.44,95.14 107.32,95.25 107.09,95.25 106.98,95.14 106.98,94.45 106.86,94.34 106.64,94.34 106.52,94.45 106.52,95.16 106.41,95.28 106.18,95.28 106.06,95.16 106.06,94.42 105.95,94.31 105.72,94.31 105.61,94.42 105.61,95.31 105.49,95.43 105.26,95.43 105.15,95.31 105.15,94.5 105.04,94.39 104.81,94.39 104.67,94.53 104.67,95.34 104.56,95.45 86.73,95.45 86.61,95.57 86.61,97.52 v2(87.02,97.92)
SOC_DDR3A_EDQ20: length 47.3
  TOP w0.102: U24.G5 85.52,97.54 v2(85.14,97.92)
  TOP w0.127: v1(120.21,98.65) DIMM1.40
  L8 w0.114: v1(120.21,98.65) 120.21,98.66 119.48,99.39 119.48,100.45 119.6,100.56 119.98,100.56 120.09,100.68 120.09,100.9 119.98,101.02 119.6,101.02 119.48,101.13 119.48,101.42 119.1,101.8 118.22,101.8 118.11,101.92 118.11,102.15 117.99,102.26 117.77,102.26 117.65,102.15 117.65,101.92 117.54,101.8 117.31,101.8 117.19,101.92 117.19,102.88 117.08,103 116.85,103 116.74,102.88 116.74,101.92 116.62,101.8 115.09,101.8 114.68,102.21 114.68,102.9 114.17,103.4 110.49,103.4 107.59,100.51 93.19,100.51 92.08,99.39 85.65,99.39 85.14,98.88 v2(85.14,97.92)
SOC_DDR3A_EDQ21: length 47.3
  TOP w0.102: v2(89.02,96.93) U24.D6
  TOP w0.127: DIMM1.42 120.06,98.05 v1(119.42,98.69)
  L8 w0.114: v2(89.02,96.93) 89.33,96.93 89.94,97.53 90.2,97.53 90.21,97.54 90.93,97.54 91.77,98.37 93.01,98.37 93.73,99.09 108.11,99.09 109.33,100.3 110.4,100.3 110.52,100.43 110.52,101.41 110.64,101.52 110.87,101.52 110.98,101.41 110.98,100.04 111.09,99.92 111.32,99.92 111.44,100.04 111.44,101.36 111.55,101.47 111.78,101.47 111.89,101.36 111.89,100.75 112.01,100.64 112.21,100.64 112.21,100.63 112.71,100.63 112.83,100.75 112.83,101.64 112.97,101.78 113.2,101.78 113.31,101.66 113.31,100.77 113.42,100.66 114.15,100.66 114.58,100.23 114.58,98.57 114.69,98.46 116.53,98.46 116.64,98.34 116.64,97.52 116.75,97.41 116.98,97.41 117.1,97.52 117.1,98.34 117.21,98.46 117.44,98.46 117.55,98.34 117.55,97.52 117.67,97.41 117.9,97.41 118.01,97.52 118.01,98.34 118.13,98.46 119.19,98.46 v1(119.42,98.69)
SOC_DDR3A_EDQ22: length 47.5
  TOP w0.102: v2(90.02,96.92) 89.52,97.42 U24.C5
  TOP w0.127: v1(120.14,96.4) 120.29,96.25 DIMM1.48
  L8 w0.114: v1(120.14,96.4) 121.65,96.4 122.07,96.83 122.07,102.07 121.96,102.18 120.82,102.18 120.7,102.07 120.7,98.43 120.28,98 118.62,98 118.49,97.87 118.49,97.01 118.38,96.9 116.43,96.9 115.99,96.45 111.86,96.45 111.62,96.69 106.77,96.69 106.49,96.98 93.93,96.98 93.37,96.42 90.78,96.42 90.27,96.92 v2(90.02,96.92)
SOC_DDR3A_EDQ23: length 47.3
  TOP w0.127: v1(120.19,95.51) 120.32,95.65 DIMM1.50 ; v2(92.63,94.92) 91.59,95.96 90.98,95.96 U24.B6
  L8 w0.114: v2(92.63,94.92) 92.71,95 103.56,95 104.7,93.86 113.86,93.86 114.45,94.44 119.11,94.44 119.19,94.53 120.87,94.53 121.14,94.26 121.14,93.81 121.25,93.7 121.48,93.7 121.6,93.81 121.6,94.43 121.71,94.55 121.94,94.55 122.05,94.43 122.05,93.1 122.17,92.99 122.49,92.99 122.61,93.1 122.61,93.88 122.72,94 123.58,94 123.7,94.11 123.7,94.34 123.58,94.46 122.72,94.46 122.61,94.57 122.61,95.47 122.49,95.58 122.26,95.58 122.15,95.47 122.15,95.21 122.03,95.1 121.81,95.1 121.69,95.21 121.69,95.77 121.58,95.88 121.35,95.88 121.23,95.77 121.23,95.14 121.2,95.1 120.89,95.1 120.78,95.21 120.78,95.8 120.66,95.91 120.3,95.91 120.19,95.8 v1(120.19,95.51)
SOC_DDR3A_EDQ24: length 47.3
  TOP w0.102: U24.C7 89.52,95.37 v2(89.97,94.92)
  TOP w0.127: DIMM1.55 115.09,94.15 115.56,93.69 v1(115.56,93.51)
  L10 w0.102: 92.3,93.32 90.78,93.32 90.4,93.7 90.4,94.13 89.97,94.56 v2(89.97,94.92)
  L10 w0.114: v1(115.56,93.51) 115.14,93.09 113.34,93.09 112.85,93.57 111.49,93.57 111.38,93.69 111.38,94.04 111.26,94.16 111.03,94.16 110.92,94.04 110.92,93.08 110.78,92.94 110.58,92.94 110.46,93.05 110.46,94.04 110.35,94.16 110.12,94.16 110.01,94.04 110.01,93.41 109.89,93.29 109.54,93.29 109.43,93.41 109.43,94.16 109.05,94.54 109.05,95.08 108.94,95.2 108.71,95.2 108.6,95.08 108.6,94.09 108.48,93.98 108.25,93.98 108.14,94.09 108.14,95.08 108.02,95.2 107.8,95.2 107.68,95.08 107.68,94.48 107.57,94.36 107.34,94.36 107.22,94.48 107.22,95.08 107.11,95.2 106.88,95.2 106.77,95.08 106.77,94.58 106.65,94.46 106.42,94.46 106.31,94.58 106.31,95.08 106.2,95.2 105.97,95.2 105.85,95.08 105.85,94.58 105.74,94.46 105.51,94.46 105.4,94.58 105.4,95.08 105.28,95.2 105.05,95.2 104.94,95.08 104.94,94.58 104.82,94.46 104.6,94.46 104.48,94.58 104.48,95.08 104.37,95.2 104.14,95.2 104.02,95.08 104.02,94.58 103.91,94.46 103.68,94.46 103.57,94.58 103.57,95.08 103.45,95.2 103.22,95.2 103.11,95.08 103.11,94.58 103,94.46 102.77,94.46 102.65,94.58 102.65,95.08 102.54,95.2 102.31,95.2 102.2,95.08 102.2,94.58 102.08,94.46 101.85,94.46 101.74,94.58 101.74,95.08 101.62,95.2 101.4,95.2 101.28,95.08 101.28,94.58 101.17,94.46 95.49,94.46 95.33,94.3 95.33,93.69 95.21,93.57 92.56,93.57 92.3,93.32
SOC_DDR3A_EDQ25: length 47.4
  TOP w0.102: v2(89.04,95.94) 89.03,95.92 87.02,95.92 U24.F7
  TOP w0.127: DIMM1.57 v1(114.92,93.55)
  L10 w0.102: 92.14,93.59 92.08,93.52 90.88,93.52 90.6,93.8 90.6,94.31 90.37,94.54 90.37,95.22 90.07,95.53 89.79,95.53 89.38,95.94 v2(89.04,95.94)
  L10 w0.114: v1(114.92,93.55) 114.95,93.55 115.34,93.94 115.34,94.43 115.15,94.62 114.92,94.62 114.8,94.5 114.8,94.04 114.69,93.93 114.46,93.93 114.34,94.04 114.34,94.5 114.23,94.62 114,94.62 113.89,94.5 113.89,93.66 113.77,93.55 113.54,93.55 113.43,93.66 113.43,94.5 113.32,94.62 113.09,94.62 112.97,94.5 112.97,94.15 112.86,94.03 112.63,94.03 112.52,94.15 112.52,94.5 112.4,94.62 110.51,94.62 110.4,94.73 110.4,95.29 110.29,95.4 110.06,95.4 109.94,95.29 109.94,94.73 109.83,94.62 109.62,94.62 109.51,94.73 109.51,95.5 109.36,95.66 100.88,95.66 100.68,95.45 100.68,95.03 100.56,94.92 100.34,94.92 100.22,95.03 100.22,95.67 100.11,95.78 99.88,95.78 99.76,95.67 99.76,95.08 99.65,94.97 99.42,94.97 99.31,95.08 99.31,95.67 99.19,95.78 98.96,95.78 98.85,95.67 98.85,95.08 98.74,94.97 98.51,94.97 98.39,95.08 98.39,95.67 98.28,95.78 98.05,95.78 97.94,95.67 97.94,95.08 97.82,94.97 97.59,94.97 97.48,95.08 97.48,95.67 97.36,95.78 97.14,95.78 97.02,95.67 97.02,95.08 96.91,94.97 96.68,94.97 96.56,95.08 96.56,95.67 96.45,95.78 96.13,95.78 95.99,95.64 95.99,95.03 95.87,94.92 95.3,94.92 94.44,94.06 92.61,94.06 92.14,93.59
