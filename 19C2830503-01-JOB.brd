# Allegro board 19C2830503-01-JOB.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
HYPERLINK1_RXP1: length 49.2
  BOTTOM w0.102: J1.E6 18.23,128.31 arc(18.4,128.24) 18.47,128.08 18.47,127.48 arc(18.51,127.25) 18.64,127.05 arc(18.84,126.92) 19.07,126.87 25.06,126.87 arc(25.25,126.84) 25.42,126.73 25.5,126.64 arc(25.62,126.47) 25.65,126.28 25.65,125.56 arc(25.73,125.17) 25.95,124.84 27.6,123.2 arc(27.71,123.04) 27.74,122.84 27.74,117 arc(27.82,116.61) 28.04,116.28 28.49,115.83 arc(28.58,115.62) 28.49,115.4 28.47,115.38 arc(28.3,114.98) 28.47,114.59 28.55,114.51 arc(28.86,114.38) 29.18,114.51 29.28,114.61 arc(29.49,114.7) 29.71,114.61 30.99,113.33 arc(31.32,113.11) 31.71,113.03 32.11,113.03 arc(32.3,112.99) 32.46,112.88 33.44,111.91 arc(33.69,111.74) 33.98,111.68 34.62,111.68 arc(34.97,111.61) 35.27,111.41 35.53,111.15 36.7,109.98 arc(36.75,109.93) 36.78,109.87 arc(36.82,109.78) 36.83,109.68 36.83,107.16 arc(36.96,106.5) 37.34,105.94 42.85,100.42 arc(42.94,100.29) 42.98,100.13 42.98,99.52 arc(43.15,99.09) 43.58,98.91 45.63,98.91 arc(45.71,98.9) 45.77,98.85 45.85,98.77 arc(46,98.68) 46.16,98.64 arc(46.38,98.53) C513.1
HYPERLINK1_RXP1_C: length 13.7
  TOP w0.102: v2(54.02,95.92) 54.37,95.92 54.52,95.77 U24.AV7
  BOTTOM w0.102: C513.2 47.31,98.56 arc(47.39,98.75) 47.58,98.83 48.3,98.83 arc(48.47,98.86) 48.61,98.96 arc(48.7,99.09) 48.73,99.26 48.73,99.69 arc(49.04,100) 49.34,99.69 49.34,99.27 arc(49.36,99.11) 49.42,98.95 49.49,98.82 arc(49.57,98.7) 49.68,98.61 49.95,98.44 arc(50.14,98.36) 50.35,98.33 50.76,98.33 arc(50.95,98.29) 51.12,98.18 51.36,97.94 arc(51.47,97.77) 51.51,97.58 51.51,97.11 arc(51.53,96.94) 51.61,96.79 arc(51.7,96.68) 51.82,96.61 arc(51.94,96.56) 52.07,96.55 arc(52.43,96.7) 52.58,97.06 arc(52.61,97.2) 52.69,97.32 52.73,97.35 arc(52.76,97.38) 52.8,97.38 54.05,97.38 arc(54.14,97.36) 54.23,97.31 arc(54.29,97.22) 54.31,97.12 54.31,96.85 arc(54.31,96.77) 54.34,96.69 54.42,96.49 arc(54.45,96.4) 54.46,96.3 54.46,96.03 arc(54.45,95.99) 54.43,95.95 arc(54.39,95.93) 54.35,95.92 v2(54.02,95.92)
HYPERLINK1_RXP2: length 50.3
  BOTTOM w0.102: C510.1 44.25,100.48 arc(44.24,100.57) 44.19,100.64 arc(44.11,100.69) 44.03,100.71 arc(43.93,100.73) 43.85,100.78 38.05,106.58 arc(37.82,106.92) 37.74,107.32 37.74,109.91 arc(37.69,110.17) 37.55,110.39 35.23,112.71 arc(34.98,112.87) 34.69,112.93 34.05,112.93 arc(33.76,112.99) 33.51,113.15 32.09,114.57 arc(31.91,114.69) 31.7,114.73 31.48,114.73 arc(31.09,114.81) 30.76,115.03 29,116.79 arc(28.78,117.12) 28.7,117.51 28.7,123.31 arc(28.66,123.5) 28.55,123.67 26.97,125.25 arc(26.75,125.58) 26.67,125.97 26.67,128.69 arc(26.57,128.93) 26.33,129.03 25.73,129.03 arc(25.61,129.05) 25.5,129.1 arc(25.28,129.24) 25.2,129.49 25.2,129.72 arc(25.32,130.02) 25.62,130.15 25.8,130.15 arc(25.93,130.2) 25.98,130.34 25.98,131.4 arc(25.84,131.76) 25.48,131.9 19.03,131.9 arc(18.81,131.95) 18.63,132.07 18.58,132.12 arc(18.54,132.17) 18.51,132.23 18.48,132.29 arc(18.47,132.33) 18.47,132.37 18.47,132.84 arc(18.33,133.17) J1.E8
HYPERLINK1_RXP2_C: length 13.2
  TOP w0.102: U24.AU5 55.52,97.67 55.27,97.92 v2(54.97,97.92)
  BOTTOM w0.102: v2(54.97,97.92) 55.29,97.92 arc(55.34,97.93) 55.39,97.96 arc(55.42,98) 55.43,98.06 55.43,98.13 arc(55.41,98.21) 55.34,98.27 55.29,98.29 arc(55.23,98.32) 55.17,98.32 52.61,98.32 arc(52.32,98.38) 52.08,98.55 49.88,100.74 arc(49.63,100.91) 49.34,100.97 45.93,100.97 arc(45.64,100.91) 45.4,100.74 45.21,100.56 arc(45.17,100.49) 45.15,100.42 C510.2
HYPERLINK1_RXP3: length 39.9
  BOTTOM w0.102: C506.1 39.03,113.02 39.25,113.24 39.25,113.39 arc(39.24,113.42) 39.22,113.46 37.35,115.32 arc(37.11,115.49) 36.82,115.54 34.37,115.54 arc(34.08,115.6) 33.83,115.77 30.78,118.82 arc(30.56,119.15) 30.48,119.54 30.48,124.14 arc(30.44,124.34) 30.33,124.5 28.87,125.96 arc(28.65,126.29) 28.57,126.68 28.57,130.11 arc(28.54,130.31) 28.43,130.47 arc(28.24,130.76) 28.17,131.09 28.17,133.82 arc(28.11,134.11) 27.95,134.36 25.7,136.61 arc(25.45,136.77) 25.16,136.83 19.2,136.83 arc(18.92,136.89) 18.68,137.05 18.65,137.08 arc(18.51,137.28) 18.47,137.52 18.47,138.08 arc(18.45,138.17) 18.4,138.24 arc(18.32,138.29) 18.24,138.31 J1.E10
HYPERLINK1_RXP3_C: length 25.4
  TOP w0.102: U24.AV4 54.05,98.89 v2(54.05,99.9)
  BOTTOM w0.102: C506.2 39.03,112.12 39.22,111.94 39.23,111.91 39.22,111.91 39.22,111.71 arc(39.27,111.42) 39.44,111.18 39.6,111.02 arc(39.71,110.85) 39.75,110.66 39.75,108 arc(39.83,107.61) 40.05,107.28 42.66,104.67 arc(42.88,104.52) 43.14,104.47 49.9,104.47 arc(50.16,104.42) 50.39,104.26 52.63,102.03 arc(52.76,101.83) 52.81,101.6 52.81,100.97 arc(52.99,100.52) 53.44,100.33 54.17,100.33 arc(54.22,100.32) 54.27,100.29 54.28,100.28 arc(54.3,100.25) 54.31,100.21 54.31,100.07 arc(54.29,100.01) 54.25,99.95 arc(54.2,99.91) 54.13,99.9 v2(54.05,99.9)
HYPERLINK1_RXPMCLK: length 83.8
  TOP w0.102: v2(66.02,99.92) U24.AF3
  L8 w0.114: J1.C9 14.82,134.49 26.16,134.49 26.66,134 32.25,134 33.76,132.48 42.9,132.48 43.16,132.22 45.49,132.22 v2(46.42,133.15)
  BOTTOM w0.102: v2(66.02,99.92) 66.4,100.3 66.4,101.45
  BOTTOM w0.127: v2(46.42,133.15) 46.74,133.15 46.99,132.89 46.99,125.73 48.39,124.33 50.44,124.33 52.22,122.56 57.28,122.56 57.66,122.17 58.87,122.17 59.63,121.41 59.63,118.38 63.69,114.32 63.69,112.48 65.21,110.95 65.21,109.92 64.26,108.97 64.26,107.44 67.37,104.33 67.37,102.43 66.4,101.45
HYPERLINK1_RXPMDAT: length 85.1
  TOP w0.102: U24.AF4 v2(66.02,98.92)
  L8 w0.114: v2(45.29,133.77) 45.37,133.7 45.37,132.8 45.13,132.56 43.16,132.56 43,132.72 33.86,132.72 32.3,134.28 26.71,134.28 26.26,134.73 15.78,134.73 J1.D9
  BOTTOM w0.102: v2(66.02,98.92) 66.64,99.53 66.64,101.18
  BOTTOM w0.127: 66.64,101.18 67.88,102.43 67.88,104.2 64.52,107.57 64.52,108.86 65.47,109.81 65.47,111.06 63.94,112.58 63.94,114.49 59.88,118.55 59.88,121.52 58.97,122.43 57.76,122.43 57.38,122.81 52.32,122.81 50.55,124.59 48.64,124.59 47.24,125.98 47.24,133.12 46.8,133.57 45.5,133.57 v2(45.29,133.77)
HYPERLINK1_TXFLCLK: length 75.8
  TOP w0.102: U24.AH3 64.52,99.42 v2(65.02,99.92)
  L8 w0.114: J1.C8 14.73,132.08 27.91,132.08 28.24,131.75 28.24,128.5 29.09,127.66 30.64,127.66 30.73,127.74 31.66,127.74 32.49,126.91 34.43,126.91 v1(34.62,127.11)
  BOTTOM w0.127: v2(65.02,99.92) 64.39,100.55 64.39,105.54 62.92,107.01 62.92,109.09 61.85,110.16 61.85,112.47 60.83,113.48 47.36,113.48 46.93,113.92 46.61,114.24 45.98,114.87 44.72,114.87 43.33,116.26 43.33,117.05 40.77,119.61 40.77,122.38 37.55,125.6 37.54,125.6 37.13,126.02 36.99,126.02 36.33,126.68 35.05,126.68 v1(34.62,127.11)
HYPERLINK1_TXFLDAT: length 75.7
  TOP w0.102: v2(65.02,100.92) 65.05,100.89 65.05,100.41 64.95,100.3 64.64,100.3 U24.AH2
  L8 w0.114: v1(34.67,127.89) 34.51,127.89 34.38,128.02 34.38,128.1 34.24,128.24 33.76,128.24 33.63,128.12 33.63,127.3 33.5,127.18 32.56,127.18 32.08,127.66 31.76,127.98 30.63,127.98 30.54,127.9 29.2,127.9 28.6,128.5 28.6,131.9 28.04,132.46 15.55,132.46 J1.D8
  BOTTOM w0.127: v1(34.67,127.89) 34.67,127.71 35.45,126.94 36.43,126.94 37.1,126.27 37.24,126.27 41.02,122.49 41.02,119.72 43.59,117.15 43.59,116.36 44.82,115.13 46.08,115.13 46.47,114.74 47.47,113.74 60.94,113.74 62.1,112.58 62.1,110.31 63.2,109.22 63.2,107.09 64.64,105.64 64.64,105.61 64.67,105.59 64.67,101.17 64.91,100.92 v2(65.02,100.92)
HYPERLINK1_TXN0: length 65
  TOP w0.102: U24.AT6 56.54,96.42 56.72,96.24 56.72,96.14 56.54,95.97 56.54,95.91 56.44,95.81 v2(56.08,95.81)
  L10 w0.089: J1.F3 19.18,120.81 arc(19.16,120.81) 19.14,120.8 18.77,120.42 arc(18.75,120.39) 18.75,120.36 arc(18.75,120.36) 18.74,120.35 18.73,120.28 18.75,120.28 18.75,120.13 arc(18.77,120.03) 18.84,119.95 18.84,119.94 arc(18.91,119.91) 18.99,119.89 25.89,119.89 arc(26.28,119.82) 26.61,119.6 26.78,119.42 arc(27,119.09) 27.08,118.71 27.08,116.26 arc(27.14,115.95) 27.31,115.69 31.65,111.35 arc(31.92,110.95) 32.01,110.48 32.01,106.66 arc(32.09,106.27) 32.31,105.94 32.77,105.48 arc(33.1,105.26) 33.49,105.19 37.57,105.19 41.54,101.22 46.11,101.22 arc(46.5,101.14) 46.83,100.92 50.74,97.02 arc(50.89,96.78) 50.94,96.51 arc(51.01,96.2) 51.19,95.93 51.83,95.29 arc(51.93,95.17) 52.01,95.05 arc(52.1,94.82) 52.13,94.57 52.13,93.81 arc(52.2,93.42) 52.42,93.09 53.52,91.99 arc(53.85,91.77) 54.24,91.69 55.44,91.69 arc(55.56,91.67) 55.67,91.6 arc(55.78,91.53) 55.9,91.5 58.01,91.5 arc(58.17,91.53) 58.3,91.62 arc(58.38,91.75) 58.41,91.91 58.41,93.91 arc(58.38,94.07) 58.29,94.21 arc(58.15,94.31) 57.98,94.34 56.94,94.34 arc(56.73,94.38) 56.55,94.5 arc(56.44,94.68) 56.39,94.88 56.39,95.55 arc(56.37,95.65) 56.32,95.73 arc(56.23,95.79) 56.13,95.81 v2(56.08,95.81)
HYPERLINK1_TXN1: length 63
  TOP w0.102: v2(58.95,96.82) 58.62,96.82 58.45,97 58.45,97.35 U24.AP5
  BOTTOM w0.102: v2(58.95,96.82) 58.95,96.64 arc(58.94,96.58) 58.9,96.52 arc(58.85,96.48) 58.78,96.47 55.81,96.47 arc(55.77,96.46) 55.74,96.44 55.57,96.27 arc(55.42,96.05) 55.37,95.79 55.37,95.44 arc(55.29,95.25) 55.1,95.17 53.89,95.17 arc(53.71,95.21) 53.56,95.31 arc(53.4,95.42) 53.22,95.45 51.93,95.45 arc(51.87,95.46) 51.82,95.46 arc(51.59,95.54) 51.39,95.68 49.81,97.26 arc(49.48,97.48) 49.09,97.56 46.54,97.56 arc(46.25,97.62) 46,97.78 45.71,98.08 arc(45.46,98.24) 45.17,98.3 43.18,98.3 arc(43.15,98.31) 43.13,98.32 43.04,98.32 arc(42.75,98.38) 42.5,98.55 42.34,98.71 arc(42.23,98.87) 42.19,99.07 42.19,99.46 arc(42.11,99.84) 41.89,100.17 35.08,106.99 arc(34.97,107.16) 34.93,107.35 34.93,107.96 arc(34.85,108.35) 34.63,108.68 34.16,109.15 arc(34.05,109.32) 34.01,109.51 34.01,109.97 arc(33.93,110.36) 33.71,110.69 32.43,111.97 arc(32.1,112.19) 31.71,112.27 30.26,112.27 arc(29.97,112.33) 29.72,112.49 28.66,113.56 arc(28.26,113.72) 27.87,113.56 27.7,113.39 arc(27.52,113.32) 27.35,113.39 27.31,113.43 arc(27.22,113.65) 27.31,113.86 27.41,113.96 arc(27.48,114.07) 27.51,114.21 27.51,114.37 arc(27.45,114.66) 27.29,114.9 27.09,115.1 arc(27.07,115.14) 27.06,115.18 27.06,122.28 arc(27,122.57) 26.84,122.82 25.29,124.37 arc(25.04,124.53) 24.75,124.59 19.34,124.59 arc(19.05,124.65) 18.8,124.81 arc(18.78,124.85) 18.77,124.89 18.77,125.54 arc(18.91,125.79) J1.F5
HYPERLINK1_TXN2: length 62.2
  TOP w0.102: v2(57,96.91) 57.05,96.96 57.05,97.95 U24.AR4
  L10 w0.089: v2(57,96.91) 57.08,96.91 arc(57.15,96.92) 57.21,96.96 57.24,96.99 arc(57.27,97.03) 57.28,97.09 57.28,97.14 arc(57.27,97.2) 57.23,97.25 57.23,97.26 arc(57.17,97.29) 57.1,97.31 54.23,97.31 arc(53.59,97.43) 53.06,97.79 51.66,99.19 51.41,99.44 47.65,103.2 arc(47.39,103.37) 47.09,103.43 43.36,103.43 29.17,117.61 29.17,122.18 arc(29.11,122.49) 28.94,122.75 26.78,124.91 arc(26.51,125.31) 26.42,125.78 26.42,130.16 arc(26.34,130.55) 26.12,130.88 25.28,131.72 arc(24.95,131.94) 24.56,132.02 19.1,132.02 arc(18.95,131.99) 18.82,131.9 arc(18.74,131.78) 18.71,131.63 18.71,131.31 arc(18.73,131.21) 18.78,131.13 19.03,130.88 arc(19.11,130.83) J1.F7
HYPERLINK1_TXN3: length 64.4
  TOP w0.102: U24.AT3 56.52,99.36 56.98,98.9 v2(57,98.9)
  BOTTOM w0.102: v2(57,98.9) arc(56.86,98.93) 56.75,99 56.74,99.01 arc(56.65,99.15) 56.62,99.31 56.62,99.49 arc(56.58,99.68) 56.47,99.85 arc(56.3,99.96) 56.1,100 55.88,100 arc(55.79,99.99) 55.71,99.97 55.67,99.95 arc(55.56,99.89) 55.46,99.81 55.39,99.74 arc(55.14,99.58) 54.85,99.52 52.97,99.52 arc(52.68,99.58) 52.43,99.74 52.39,99.78 arc(52.23,100.02) 52.17,100.32 52.17,101.39 52.16,101.4 arc(52.11,101.54) 52.02,101.65 51.82,101.85 50.1,103.57 arc(49.86,103.73) 49.58,103.78 43.15,103.78 arc(42.65,103.88) 42.22,104.17 39.36,107.03 arc(39.2,107.27) 39.14,107.57 39.14,110.17 arc(39.08,110.47) 38.92,110.71 35.12,114.51 arc(34.88,114.67) 34.58,114.73 34.12,114.73 arc(33.83,114.79) 33.58,114.96 30.07,118.47 arc(29.9,118.72) 29.84,119.01 29.84,123.71 arc(29.79,124) 29.62,124.25 28.16,125.71 arc(28,125.96) 27.94,126.25 27.94,129.78 arc(27.88,130.07) 27.72,130.32 27.55,130.49 arc(27.39,130.73) 27.33,131.02 27.33,132.02 arc(27.27,132.31) 27.11,132.56 25.22,134.45 arc(24.97,134.61) 24.68,134.67 19.33,134.67 arc(18.88,134.86) 18.69,135.3 18.7,135.35 arc(18.86,135.68) J1.F9
HYPERLINK1_TXP0: length 65
  TOP w0.102: U24.AT7 56.54,95.42 v2(56.92,95.81)
  L10 w0.089: J1.E3 18.05,120.81 arc(18.1,120.8) 18.14,120.77 18.35,120.56 arc(18.48,120.36) 18.53,120.13 arc(18.58,119.93) 18.7,119.78 18.71,119.77 arc(18.84,119.7) 18.99,119.68 25.89,119.68 arc(26.19,119.62) 26.45,119.44 26.63,119.27 arc(26.8,119.01) 26.86,118.71 26.86,116.26 arc(26.94,115.87) 27.16,115.54 31.5,111.2 arc(31.72,110.87) 31.8,110.48 31.8,106.66 arc(31.89,106.19) 32.16,105.79 32.62,105.33 arc(33.02,105.06) 33.49,104.97 37.45,104.97 arc(37.48,104.96) 37.51,104.94 41.43,101.03 arc(41.46,101.01) 41.49,101 46.11,101 arc(46.42,100.94) 46.68,100.77 50.58,96.86 arc(50.69,96.7) 50.73,96.51 arc(50.81,96.12) 51.03,95.78 51.68,95.14 arc(51.75,95.05) 51.82,94.95 arc(51.89,94.76) 51.91,94.57 51.91,93.81 arc(52,93.34) 52.27,92.94 53.37,91.84 arc(53.77,91.57) 54.24,91.48 55.44,91.48 arc(55.48,91.47) 55.52,91.45 arc(55.69,91.33) 55.9,91.29 58.01,91.29 arc(58.25,91.33) 58.45,91.47 arc(58.58,91.67) 58.63,91.91 58.63,93.91 arc(58.58,94.16) 58.44,94.37 arc(58.23,94.51) 57.98,94.56 56.94,94.56 arc(56.81,94.58) 56.71,94.65 arc(56.64,94.76) 56.61,94.88 56.61,95.46 arc(56.62,95.49) 56.64,95.52 v2(56.92,95.81)
HYPERLINK1_TXP1: length 63
  TOP w0.102: v2(58.93,95.88) 58.52,96.3 U24.AP6
  BOTTOM w0.102: J1.E5 18.26,125.81 arc(18.44,125.73) 18.52,125.55 18.52,124.89 arc(18.54,124.75) 18.62,124.63 arc(18.95,124.41) 19.34,124.33 24.75,124.33 arc(24.95,124.3) 25.11,124.19 26.66,122.64 arc(26.77,122.48) 26.8,122.28 26.8,115.09 arc(26.81,115.08) 26.81,115.07 26.82,115.03 arc(26.83,115.01) 26.84,115 27.11,114.72 arc(27.22,114.56) 27.26,114.37 27.26,114.21 arc(27.25,114.17) 27.23,114.14 27.13,114.04 arc(26.97,113.65) 27.13,113.25 27.17,113.21 arc(27.52,113.06) 27.87,113.21 28.05,113.38 arc(28.26,113.47) 28.48,113.38 29.71,112.15 arc(29.78,112.09) 29.86,112.05 29.9,112.03 arc(29.94,112.02) 29.98,112.01 31.71,112.01 arc(32.01,111.96) 32.25,111.79 33.53,110.51 arc(33.7,110.26) 33.76,109.97 33.76,109.51 arc(33.81,109.22) 33.98,108.97 34.45,108.5 arc(34.61,108.25) 34.67,107.96 34.67,107.35 arc(34.73,107.06) 34.9,106.81 41.71,99.99 arc(41.88,99.75) 41.94,99.46 41.94,99.07 arc(41.99,98.78) 42.16,98.53 42.32,98.37 arc(42.65,98.15) 43.04,98.07 43.06,98.07 arc(43.12,98.05) 43.18,98.05 45.17,98.05 arc(45.37,98.01) 45.53,97.9 45.82,97.6 arc(46.15,97.38) 46.54,97.31 49.09,97.31 arc(49.38,97.25) 49.63,97.08 51.21,95.5 arc(51.47,95.31) 51.78,95.21 arc(51.8,95.21) 51.82,95.21 arc(51.87,95.2) 51.93,95.2 53.22,95.2 arc(53.3,95.18) 53.38,95.13 arc(53.61,94.97) 53.89,94.92 55.1,94.92 arc(55.47,95.07) 55.63,95.44 55.63,95.79 arc(55.66,95.95) 55.75,96.09 55.84,96.19 arc(55.88,96.21) 55.92,96.22 58.51,96.22 arc(58.58,96.21) 58.64,96.19 58.71,96.16 arc(58.82,96.09) 58.89,95.98 v2(58.93,95.88)
HYPERLINK1_TXP2: length 62.2
  TOP w0.102: v2(57.98,96.93) 57.71,96.93 57.52,97.12 U24.AR5
  L10 w0.089: J1.E7 arc(18.08,130.83) 18.14,130.87 18.42,131.14 arc(18.47,131.23) 18.49,131.32 18.49,131.63 arc(18.54,131.86) 18.67,132.06 arc(18.87,132.19) 19.1,132.23 24.56,132.23 arc(25.03,132.14) 25.43,131.87 26.27,131.03 arc(26.54,130.63) 26.63,130.16 26.63,125.78 arc(26.71,125.39) 26.93,125.06 29.09,122.9 arc(29.31,122.57) 29.39,122.18 29.39,117.74 arc(29.39,117.71) 29.41,117.68 43.42,103.67 arc(43.45,103.65) 43.48,103.65 47.09,103.65 arc(47.48,103.57) 47.81,103.35 51.56,99.59 51.82,99.34 53.21,97.95 arc(53.68,97.63) 54.23,97.52 57.1,97.52 arc(57.25,97.49) 57.38,97.41 57.38,97.4 arc(57.46,97.28) 57.49,97.14 57.49,97.09 arc(57.49,97.06) 57.49,97.04 arc(57.5,96.97) 57.56,96.93 arc(57.77,96.88) v2(57.98,96.93)
HYPERLINK1_TXP3: length 64.4
  TOP w0.102: U24.AT4 56.52,98.5 56.13,98.89 v2(56.03,98.89)
  BOTTOM w0.102: J1.E9 18.15,135.81 arc(18.26,135.79) 18.36,135.72 18.39,135.69 arc(18.43,135.63) 18.44,135.55 18.44,135.37 arc(18.44,135.37) 18.44,135.37 18.44,135.3 arc(18.7,134.68) 19.33,134.42 24.68,134.42 arc(24.87,134.38) 25.04,134.27 26.93,132.38 arc(27.04,132.21) 27.08,132.02 27.08,131.02 arc(27.15,130.64) 27.37,130.31 27.54,130.14 arc(27.65,129.98) 27.69,129.78 27.69,126.25 arc(27.76,125.86) 27.98,125.53 29.44,124.07 arc(29.55,123.91) 29.59,123.71 29.59,119.01 arc(29.67,118.62) 29.89,118.29 33.4,114.78 arc(33.73,114.56) 34.12,114.48 34.58,114.48 arc(34.78,114.44) 34.94,114.33 38.74,110.53 arc(38.85,110.37) 38.89,110.17 38.89,107.57 arc(38.96,107.18) 39.18,106.85 42.04,103.99 arc(42.55,103.65) 43.15,103.53 49.58,103.53 arc(49.76,103.49) 49.92,103.39 51.64,101.67 51.84,101.47 arc(51.88,101.41) 51.91,101.34 arc(51.92,101.31) 51.92,101.28 51.92,100.32 arc(51.99,99.93) 52.22,99.6 52.25,99.56 arc(52.58,99.34) 52.97,99.26 54.85,99.26 arc(55.24,99.34) 55.57,99.56 55.64,99.63 arc(55.7,99.68) 55.77,99.72 55.81,99.73 arc(55.84,99.74) 55.88,99.75 56.1,99.75 arc(56.2,99.73) 56.29,99.67 arc(56.34,99.59) 56.36,99.49 56.36,99.28 56.36,99.28 56.36,99.22 arc(56.34,99.1) 56.26,98.99 56.21,98.94 arc(56.16,98.9) 56.1,98.89 v2(56.03,98.89)
HYPERLINK1_TXPMCLK: length 81.3
  TOP w0.127: v1(65.21,115.19) 65.84,115.82 70.1,115.82 71.75,114.17 71.75,110.11 71.37,109.73 R309.2
  L8 w0.114: J1.C10 14.45,137.36 25.85,137.36 26.8,138.32 30.08,138.32 30.34,138.57 31.85,138.57 32.38,139.1 34.26,139.1 38.47,134.89 45.46,134.89 v2(46.36,133.99)
  BOTTOM w0.127: v1(65.21,115.19) 63.61,115.19 60.13,118.66 60.13,121.62 59.08,122.68 57.87,122.68 57.49,123.06 52.43,123.06 50.65,124.84 48.77,124.84 47.5,126.11 47.5,133.22 46.74,133.99 v2(46.36,133.99)
HYPERLINK1_TXPMCLK_R: length 10.2
  TOP w0.127: U24.AH1 68.89,105.79 69.86,105.79 71.37,107.31 R309.1
HYPERLINK1_TXPMDAT: length 92.7
  TOP w0.102: U24.AF2 66.52,100.43 v2(67.04,100.95)
  L8 w0.114: v2(46.36,134.58) 46.11,134.58 45.56,135.13 38.57,135.13 34.36,139.34 32.28,139.34 31.75,138.81 30.24,138.81 29.98,138.56 26.54,138.56 25.59,137.61 15.4,137.61 J1.D10
  BOTTOM w0.127: v2(67.04,100.95) 68.52,102.43 68.52,105.16 68.39,105.28 67.56,105.28 67.44,105.41 67.44,105.66 67.56,105.79 68.2,105.79 68.33,105.92 68.33,106.3 68.2,106.43 67.06,106.43 66.93,106.55 66.93,106.81 67.06,106.93 68.2,106.93 68.33,107.06 68.33,107.31 68.2,107.44 66.67,107.44 66.17,106.93 65.66,106.93 64.77,107.82 64.77,108.76 65.72,109.71 65.72,111.17 64.64,112.25 64.64,113.92 65.65,114.93 65.65,115.37 65.2,115.82 63.37,115.82 60.39,118.81 60.39,121.73 59.18,122.94 57.97,122.94 57.59,123.32 52.53,123.32 50.76,125.09 49.02,125.09 47.75,126.37 47.75,133.55 46.74,134.57 46.37,134.57 v2(46.36,134.58)
JTAG_TCK: length 4.7
  TOP w0.127: U13.27 131.16,129.51 131.75,130.1 133.07,130.1 TP25.1
JTAG_TDI: length 7.2
  TOP w0.127: TP15.1 133.64,132.88 133.64,132.05 R176.2 132.53,130.94 131.57,130.94 130.16,129.53 U13.29
JTAG_TDO: length 6.1
  TOP w0.127: TP21.1 133.92,132.14 133.92,131.72 133.87,131.67 133.87,131.41 132.97,130.51 131.52,130.51 130.66,129.65 U13.28
JTAG_TMS: length 6.7
  TOP w0.127: U13.30 129.66,129.54 131.63,131.5 R175.2 132.01,131.5 132.36,131.85 132.36,132.51 132.57,132.72 132.57,133.24 133.18,133.86 TP13.1
LAN0_LED_LINK10: length 14.1
  BOTTOM w0.127: PHY1.C8 140.15,71.06 139.7,70.61 139.7,69.6 138.68,68.57 138.68,64.75 140.16,63.27 144.69,63.27 R736.1
LAN0_LED_LINK100: length 22.6
  TOP w0.102: 138.29,69.1 138.15,69.24 138.15,70.1 v2(138.64,70.6)
  TOP w0.127: R371.1 153.29,74.68 151.76,73.15 151.76,70.11 149.57,67.92 139.91,67.92 v1(139.73,68.1) 139.29,68.1 138.29,69.1
  BOTTOM w0.102: PHY1.B8 v2(138.64,70.6)
LAN0_LED_LINK1000: length 28.6
  TOP w0.102: 137.66,69.1 137.64,69.11 v2(137.64,70.6)
  TOP w0.127: 137.66,69.1 142.75,64.01 v1(142.88,64.01) 145.31,66.45 150.58,66.45 152.02,67.89 152.02,72.97 152.32,73.28 R382.1
  BOTTOM w0.102: PHY1.A9 138.14,70.1 v2(137.64,70.6)
  BOTTOM w0.127: R737.1 143.2,63.68 v1(142.88,64.01) 142.55,63.68 R738.1
LAN0_LED_RX: length 28.2
  TOP w0.127: R350.1 153.35,83.24 152.55,82.45 152.55,74.3 151.51,73.26 151.51,70.22 149.56,68.26 140.27,68.26 v2(139.7,68.83)
  BOTTOM w0.127: v2(139.7,68.83) 140.15,69.28 PHY1.C9
LAN0_TRD2_0N: length 20.4
  BOTTOM w0.102: PHY1.N2 150.14,77.37 150.24,77.47 152.27,77.47 152.63,77.83 152.63,80.75 152.98,81.1 153.17,81.1 153.35,80.92 R681.2 153.88,81.05 154.82,81.05 156.44,82.68 158.35,82.68 160.38,84.71 162.28,84.71 162.89,84.1 162.89,83.67 162.38,83.16 CN16.A2
LAN0_TRD2_0P: length 20.4
  BOTTOM w0.102: CN16.A1 164.17,84.2 163.14,84.2 162.38,84.96 160.27,84.96 158.24,82.93 156.34,82.93 154.71,81.31 153.96,81.31 R680.2 153.35,81.49 153.21,81.36 152.88,81.36 152.37,80.85 152.37,77.93 152.17,77.73 150.25,77.73 150.14,77.83 PHY1.N1
LAN0_TRD2_1N: length 18.4
  BOTTOM w0.102: CN16.A4 162.66,80.62 163.12,81.08 163.12,81.17 162.51,81.79 160.66,81.79 155.68,76.81 153.96,76.81 R695.2 153.35,76.55 153.16,76.74 152.76,76.74 152.63,76.61 151.9,76.61 150.76,75.47 150.25,75.47 150.14,75.37 PHY1.N4
LAN0_TRD2_1P: length 18.4
  BOTTOM w0.102: CN16.A3 163.78,81.28 163.37,81.28 162.61,82.04 160.55,82.04 155.57,77.06 153.88,77.06 R689.2 153.35,77.3 153.03,76.99 152.65,76.99 152.53,76.86 151.79,76.86 150.66,75.73 150.25,75.73 150.14,75.83 PHY1.N3
LAN0_TRD2_2N: length 17.1
  BOTTOM w0.102: CN16.A8 162.76,75.54 163.02,75.79 163.02,76.15 162.58,76.58 160.53,76.58 158.24,74.3 156.21,74.3 155.75,73.84 153.91,73.84 R705.2 152.84,73.79 152.38,73.79 151.09,72.5 150.27,72.5 150.14,72.37 PHY1.N7
LAN0_TRD2_2P: length 17.1
  BOTTOM w0.102: CN16.A7 163.91,76.33 163.19,76.33 162.69,76.84 160.42,76.84 158.14,74.55 156.1,74.55 155.65,74.09 153.93,74.09 R700.2 152.71,74.04 152.27,74.04 150.98,72.75 150.26,72.75 150.14,72.87 PHY1.N6
LAN0_TRD2_3N: length 16.9
  BOTTOM w0.102: CN16.A10 162.66,73 163.04,73.38 163.04,73.58 162.58,74.04 160.76,74.04 157.81,71.09 153.96,71.09 R717.2 152.71,71.12 152,71.12 151.32,70.45 150.25,70.45 150.14,70.34 PHY1.N9
LAN0_TRD2_3P: length 16.9
  BOTTOM w0.102: PHY1.N8 150.14,70.83 150.27,70.7 151.22,70.7 151.89,71.37 152.84,71.37 R710.2 153.88,71.35 157.71,71.35 160.66,74.3 162.69,74.3 163.22,73.76 163.89,73.76 CN16.A9
LAN1_LED_LINK10: length 15
  BOTTOM w0.102: 139.47,93.49 139.7,93.73 139.7,95.05 PHY2.C8
  BOTTOM w0.127: R653.1 141.35,86.61 138.05,86.61 136.78,87.88 136.78,90.81 139.47,93.49
LAN1_LED_LINK100: length 19.4
  TOP w0.127: v2(138.64,94.99) 139.19,94.45 139.19,91.44 140.97,89.66 R333.1
  BOTTOM w0.102: PHY2.B8 v2(138.64,94.99)
LAN1_LED_LINK1000: length 27.7
  TOP w0.102: v2(137.64,94.99) 137.67,94.97
  TOP w0.127: R335.1 152.02,88.27 150.89,89.39 139.18,89.39 v1(137.67,87.88) 137.67,94.97
  BOTTOM w0.102: v2(137.64,94.99) 138.14,94.49 PHY2.A9
  BOTTOM w0.127: R654.1 R655.1 138.3,87.25 v1(137.67,87.88)
LAN1_LED_RX: length 18.5
  TOP w0.127: R327.1 152.65,98.04 152.02,97.41 152.02,94.62 149.86,92.46 141.35,92.46 v2(140.08,93.73)
  BOTTOM w0.102: PHY2.C9 140.15,93.79 v2(140.08,93.73)
LAN1_TRD2_0N: length 17.5
  BOTTOM w0.102: CN16.B2 162.84,97.13 163.04,97.33 163.04,97.71 160.8,99.95 153.88,99.95 R624.2 152.69,100.08 152.52,100.08 152.27,100.33 152.27,101.19 151.62,101.84 150.27,101.84 150.14,101.72 PHY2.N2
LAN1_TRD2_0P: length 17.5
  BOTTOM w0.102: CN16.B1 163.84,97.84 163.27,97.84 160.9,100.21 153.97,100.21 R618.2 152.85,100.33 152.63,100.33 152.53,100.43 152.53,101.29 151.73,102.09 150.27,102.09 150.14,102.22 PHY2.N1
LAN1_TRD2_1N: length 18
  BOTTOM w0.102: CN16.B4 162.5,94.59 163.04,95.12 163.04,95.32 162.61,95.76 160.17,95.76 159.15,96.77 155.07,96.77 154.58,97.26 153.96,97.26 R630.2 152.84,97.16 152.22,97.16 151.78,97.6 151.78,98.99 150.9,99.87 150.25,99.87 150.14,99.76 PHY2.N4
LAN1_TRD2_1P: length 18.1
  BOTTOM w0.102: CN16.B3 163.89,95.35 163.37,95.35 162.71,96.01 160.27,96.01 159.26,97.03 155.17,97.03 154.69,97.51 153.88,97.51 R626.2 152.71,97.41 152.33,97.41 152.03,97.71 152.03,99.1 151.01,100.12 150.3,100.12 150.14,100.27 PHY2.N3
LAN1_TRD2_2N: length 18.9
  BOTTOM w0.102: PHY2.N7 150.14,96.7 150.31,96.87 151.29,96.87 152.02,96.14 152.02,94.87 152.41,94.48 152.72,94.48 R636.2 153.92,94.42 157.31,94.42 160.93,90.81 162.38,90.81 162.53,90.65 163.04,90.14 163.04,89.76 162.78,89.51 CN16.B8
LAN1_TRD2_2P: length 18.9
  BOTTOM w0.102: PHY2.N6 150.14,97.22 150.25,97.12 151.4,97.12 152.27,96.24 152.27,94.97 152.52,94.73 152.83,94.73 R633.2 153.92,94.68 157.42,94.68 161.04,91.06 162.48,91.06 163.37,90.17 163.78,90.17 CN16.B7
LAN1_TRD2_3N: length 19.6
  BOTTOM w0.102: PHY2.N9 150.14,94.76 150.25,94.87 150.75,94.87 151,94.62 151,92.48 151.91,91.57 152.84,91.57 R641.2 153.93,91.64 157.68,91.64 161.18,88.14 162.68,88.14 163.02,87.8 163.02,87.45 162.53,86.97 CN16.B10
LAN1_TRD2_3P: length 19.6
  BOTTOM w0.102: PHY2.N8 150.14,95.27 150.3,95.12 150.86,95.12 151.26,94.72 151.26,92.58 152.02,91.82 152.71,91.82 R637.2 153.91,91.9 157.79,91.9 161.29,88.39 162.79,88.39 163.45,87.73 163.89,87.73 CN16.B9
LCD_A0: length 100.2
  L8 w0.114: LCD1.15 78.54,155.4 89.16,155.4 92.24,152.31 92.24,151.87 97.72,146.39 104.25,146.39 111.18,139.47 113.63,139.47 115.68,137.42 116.76,137.42 117.4,136.79 136.79,136.79 142.73,142.72 144.4,142.72 146.02,144.34 153.47,144.34 154.85,145.72 154.85,149.57 v1(153.16,151.26)
  BOTTOM w0.127: v1(153.16,151.26) 153.6,151.7 R514.2
LCD_RSTZ: length 105.4
  TOP w0.127: v1(150.11,151.98) 150.11,153.37 149.96,153.53 U7.100
  L8 w0.114: LCD1.16 79.68,155.04 89.17,155.04 92,152.21 92,151.77 97.62,146.15 102.76,146.15 106.11,142.81 106.74,142.81 107,142.55 107,142.19 107.95,141.23 107.95,140.79 112.07,136.67 117.17,136.67 117.3,136.54 136.89,136.54 142.79,142.44 144.65,142.44 146.25,144.04 153.52,144.04 155.09,145.62 155.09,149.95 153.11,151.93 150.16,151.93 v1(150.11,151.98)
LED0_DUPLEX: length 5
  BOTTOM w0.102: 141.4,69.1 141.53,69.23 141.53,70.31 142.15,70.93 PHY1.E8
  BOTTOM w0.127: 141.4,69.1 141.4,67.46 R729.1
LED0_TX: length 6
  BOTTOM w0.102: PHY1.D9 141.15,69.1
  BOTTOM w0.127: 141.15,69.1 141.15,64.56 TP93.1
LED_DUPLEX: length 6.5
  BOTTOM w0.102: 141.53,93.49 141.53,94.87 141.75,95.1 141.94,95.29 PHY2.E8
  BOTTOM w0.127: R646.1 138.94,90.83 141.53,93.41 141.53,93.49
LED_TX: length 6.6
  BOTTOM w0.102: 141.15,93.49 PHY2.D9
  BOTTOM w0.127: 141.15,93.49 141.15,93.39 138.05,90.3 138.05,90.04 R647.1
MAIN_POWER_GOOD: length 24.3
  TOP w0.127: U7.11 147.36,148.19 147.12,147.96 142.98,147.96 v1(142.54,147.52) ; v1(137.67,132.49) 137.73,132.49 R166.1
  L5 w0.114: v1(137.67,132.49) 140.17,134.99 140.17,137.65 143.06,140.54 143.06,147.04 142.58,147.52 v1(142.54,147.52)
MAIN_POWER_GOOD_R: length 7.6
  TOP w0.127: U13.24 133.46,128.1 133.96,128.6 133.96,129.43 135.85,131.32 137.46,131.32 R166.2
MAIN_POWER_START: length 31.6
  TOP w0.127: v1(142.54,148.21) 147.01,148.21 147.5,148.69 U7.10
  L5 w0.114: v1(142.54,148.21) 143.19,148.21 143.72,147.68 143.72,140.52 141.17,137.97 141.17,137.57 141.22,137.52 141.22,131.99 138.95,129.72 v1(135.89,129.72)
  BOTTOM w0.127: R564.2 136.67,129.96 136.42,129.72 v1(135.89,129.72)
MAIN_POWER_START_R: length 25.6
  TOP w0.127: v1(134.77,128.55) 134.77,128.44 133.42,127.1 U13.22
  L8 w0.114: v1(134.77,128.55) 135.07,128.24 136.75,128.24 137.17,128.66 137.92,128.66 138.31,129.06 139.14,129.06 140.34,130.26 140.34,130.89 140.65,131.2 145.25,131.2 145.71,130.73 148.39,130.73 148.46,130.66 150.6,130.66 151.72,131.78 CN7.5
  BOTTOM w0.127: R564.1 134.77,129.45 v1(134.77,128.55)
MCU_BOOTSELECT: length 33.1
  TOP w0.127: v1(143.43,136.53) 144.37,135.59 150.47,135.59 150.85,135.21 154.26,135.21 154.43,135.38 154.43,136.65 154.56,136.78 154.56,137.92 154.96,138.32 U7.36 ; v1(143.1,128.24) 143.76,127.58 143.76,124.2 144.32,123.64 R222.1 146.76,123.64 CN9.1
  L5 w0.114: v1(143.1,128.24) 143,128.24 141.89,129.36 141.89,133.13 143.63,134.87 143.63,136.33 v1(143.43,136.53)
MCU_EMU_DET: length 15.5
  TOP w0.127: v1(100.41,138.1) 101.47,138.1 101.65,137.92 U11.2
  L5 w0.114: v1(103.3,127.18) 102.66,127.83 102.66,132.33 100.41,134.59 v1(100.41,138.1)
  BOTTOM w0.127: v1(103.3,127.18) 103.21,127.28 U53.24
MCU_EXP_SCL: length 55.3
  TOP w0.127: R306.2 133.63,106.04 v1(133.3,105.71) 133.25,105.66 U22.2 ; v1(145.11,140.11) 145.21,140.11 145.54,139.78 148.62,139.78 149.47,140.63 153.35,140.63 153.96,140.02 U7.34
  L5 w0.114: v1(133.3,105.71) 133.82,106.23 133.82,113.82 137.24,117.25 137.85,117.86 141.21,117.86 141.99,118.64 141.99,119.98 144.56,122.55 144.56,128.55 143.56,129.55 143.56,133.49 144.56,134.48 144.56,137.58 144.55,137.59 144.55,139.54 v1(145.11,140.11)
  BOTTOM w0.127: U22.2 133.25,105.66 v1(133.3,105.71)
MCU_EXP_SDA: length 56.6
  TOP w0.127: v1(144.45,140.18) 144.5,140.18 145.13,140.81 149.11,140.81 149.31,141.01 153.58,141.01 154.46,140.13 U7.35 ; R297.2 133.92,107.3 v1(133.27,106.65) 132.99,106.93 U22.3
  L5 w0.114: v1(133.27,106.65) 133.46,106.84 133.46,113.95 137.67,118.16 137.71,118.2 141.06,118.2 141.55,118.69 141.55,120.03 144.21,122.69 144.21,128.23 143.88,128.56 143.88,128.57 142.47,129.98 142.47,132.89 144.21,134.63 144.21,137.19 144.2,137.2 144.2,139.81 144.45,140.06 v1(144.45,140.18)
  BOTTOM w0.127: v1(133.27,106.65) 132.99,106.93 U22.3
MCU_GPS_ENABLE: length 139
  TOP w0.127: R433.1 v1(147.96,49.4)
  L3 w0.114: v1(123.7,111.89) 123.7,114.09 121.6,116.19 121.6,120.87 120.81,121.66 120.81,125.7 120.4,126.11 120.4,128.35 113.26,135.48 113.26,141.4 112.45,142.21 112.45,144.14 108.71,147.88 107.75,147.88 107.38,148.25 107.38,151.66 108.41,152.69 v1(108.41,152.71)
  L10 w0.114: v1(147.96,49.4) 150.66,49.4 151.49,50.23 151.49,54.28 146.47,59.31 144,59.31 140.7,62.61 136.6,62.61 135.17,64.04 135.17,77.06 125.62,86.62 125.62,109.97 v1(123.7,111.89)
  BOTTOM w0.127: v1(108.41,152.71) 108.41,152.69 108.91,152.19 U50.23
MCU_JTAG_TCK: length 6.8
  TOP w0.127: U7.80 159.96,155.89 160.4,156.34 162.16,156.34 162.92,155.57 R39.2
MCU_JTAG_TDI: length 6.1
  TOP w0.127: U7.78 160.96,154.38 161.07,154.27 161.08,154.27 161.54,153.8 164.95,153.8 165.41,153.34 R45.2
MCU_JTAG_TDO: length 4.8
  TOP w0.127: U7.77 161.46,154.38 161.57,154.27 161.58,154.27 161.8,154.05 165.28,154.05 R51.2
MCU_JTAG_TMS: length 10.1
  TOP w0.127: R46.2 R40.1 167.13,155.57 166.37,154.81 163.32,154.81 162.05,156.08 160.78,156.08 160.46,155.76 U7.79
MCU_PA0_U0RX: length 5.1
  TOP w0.127: U12.5 146.75,137.17 147.98,138.4 149.63,138.4 149.96,138.73 U7.26
MCU_PA1_U0TX: length 49
  TOP w0.127: v1(147.47,136.4) 148.43,137.36 R129.2 148.48,137.36 149.15,138.02 149.79,138.02 150.34,138.57 150.34,138.58 150.46,138.7 U7.27 ; U3.39 147.84,166.1 148.46,165.48 148.46,162.35 147.97,161.85 147.97,159.25 147.96,159.24 147.96,157.68 148.65,156.98 148.65,155.38 v1(147.7,154.43)
  L8 w0.114: v1(147.47,136.4) 151.09,136.4 152.3,137.6 152.3,138.59 154.76,141.06 154.88,141.06 157.11,143.28 157.11,145.51 155.78,146.84 155.78,150.23 153.39,152.62 151.57,152.62 151.42,152.76 149.05,152.76 147.7,154.11 v1(147.7,154.43)
MCU_RESET_SWZ: length 137.1
  TOP w0.127: U6.1 170.19,149.34 171.13,148.41 C827.1 172.27,148.41 172.85,147.83 v1(172.85,142.75) ; R84.1 166.68,40.01 166.67,40.02 166.67,40.44 166.68,40.46 C54.1 R91.2 166.68,43 166.5,43.18 v1(165.74,43.18)
  L3 w0.114: v1(165.74,43.18) 165.61,43.31 155.32,43.31 154.31,44.32 154.31,99.69 154.81,100.2 156.13,100.2 160.58,104.65 163.83,104.65 164.85,105.66 164.85,112.52 163.32,114.05 163.32,118.24 164.97,119.89 168.02,119.89 172.34,124.21 172.34,133.48 172.85,133.99 v1(172.85,142.75)
MCU_RESETSTATZ: length 108.2
  TOP w0.127: R41.2 28.42,155.42 v1(28.34,155.5)
  BOTTOM w0.127: U53.22 100.43,128.58 100.14,128.87 100.14,133.74 98.15,135.74 98.15,146.43 87.13,157.45 85.65,157.45 77.66,165.45 36.75,165.45 36.72,165.42 31.21,165.42 30.48,164.69 30.16,164.37 30.16,162.45 26.94,159.22 26.94,156.9 v1(28.34,155.5)
MCU_RESETZ: length 6.2
  TOP w0.127: U6.4 168.9,148.35 168.53,148.72 166.37,148.72 165.35,147.69 U7.64
MCU_SPI0_CLK: length 147.3
  TOP w0.127: v1(93.62,118.07) 93.58,118.11 93.22,118.11 93,117.89 U19.5 ; v1(52.2,126.11) 52.23,126.14 U14.5 ; v1(60.54,130.32) 60.54,129.74 60.85,129.43 60.85,127.51 62.54,125.82 U15.5 ; v1(149.45,137.57) 149.87,137.57 150.96,138.65 U7.28
  L5 w0.114: v1(97.75,130.45) 97.08,130.45 96.74,130.12 95.83,130.12 94.64,128.93 94.64,121.24 94.51,121.12 94.51,118.75 94.23,118.47 94.23,118.41 93.9,118.07 v1(93.62,118.07)
  L8 w0.114: v1(52.2,126.11) 52.87,126.11 53.06,125.93 57.86,125.93 58.31,126.38 58.73,126.38 59.18,126.84 59.18,128.96 v1(60.54,130.32) 61.21,130.32 61.54,129.99 61.54,128.86 61.75,128.65 62.66,128.65 63.14,129.13 67.46,129.13 70.23,131.9 75.25,131.9 76.48,130.68 77.57,130.68 78.41,129.84 82.31,129.84 82.73,129.42 89.33,129.42 91.14,127.61 92.09,127.61 92.51,127.18 96.96,127.18 98.48,128.7 98.48,129.36 97.75,130.09 v1(97.75,130.45) 97.77,130.45 97.84,130.53 98.15,130.53 102.29,134.68 104.34,134.68 105.19,133.83 117.87,133.83 118.83,134.79 137.61,134.79 139.37,136.55 142.66,136.55 143.11,137 143.99,137 144.44,136.55 145.95,136.55 147.15,137.75 149.27,137.75 v1(149.45,137.57)
  BOTTOM w0.127: U53.12 95.88,131.83 97.18,130.53 97.64,130.53 97.71,130.45 v1(97.75,130.45) ; U52.16 151.19,139.3 v1(149.45,137.57)
MCU_SPI0_CLK_1V8: length 81.9
  L8 w0.114: v1(97.91,166.5) 98.75,166.5 103.16,162.09 103.16,156.26 v1(103.91,155.51) 104.33,155.09 110.97,155.09 112.52,153.54 140.31,153.54 141.2,152.65 142.11,152.65 146.43,148.34 149.18,148.34 v1(151.19,146.33)
  BOTTOM w0.127: U50.12 103.33,156.09 103.91,155.51 v1(103.91,155.51) ; v1(97.91,166.5) U47.12 95.75,166.5 95.17,167.08 95.17,168.33 94.92,168.58 88.82,168.58 88.29,168.05 88.29,167.13 87.66,166.5 86.85,166.5 U48.12 ; U52.5 v1(151.19,146.33)
MCU_SPI0_CS0Z: length 160.8
  TOP w0.127: v1(139.7,146.25) 143.13,142.82 143.13,140.41 144.14,139.4 148.85,139.4 149.7,140.25 151.29,140.25 151.46,140.09 U7.29 ; v1(51.56,126.24) 51.56,126.32 51.73,126.49 U14.4
  L8 w0.114: v1(58.74,133.41) 58.67,133.41 58.67,133.35 58.49,133.53 58.49,136.73 57.52,137.71 54.59,137.71 53.69,138.6 53.69,138.97 52.7,139.95 50.04,139.95 48.39,141.6 48.39,150.37 51.61,153.59 63.52,153.59 69.41,159.48 99.57,159.48 102.72,156.33 102.72,152.27 103.68,151.3 104.83,151.3 105.33,151.81 108.91,151.81 109.71,152.62 133.54,152.62 134.43,151.73 136.09,151.73 140.14,147.68 140.14,146.69 v1(139.7,146.25)
  L10 w0.114: v1(58.74,133.41) 58.42,133.1 57.15,133.1 55.88,131.83 55.88,128.14 54.99,127.25 52.45,127.25 51.56,126.37 v1(51.56,126.24)
MCU_SPI0_CS1Z: length 146.9
  TOP w0.127: v1(139.7,146.89) 143.66,142.93 143.66,141.81 144.47,141 144.75,141 144.95,141.19 U7.25 ; U15.4 62.67,126.32 61.23,127.76 61.23,129.83 61.21,129.85 61.21,130.31 60.33,131.19 v1(60.33,131.83)
  L8 w0.114: v1(139.7,146.89) 139.7,147.63 135.95,151.38 134.28,151.38 133.4,152.27 110.35,152.27 108.46,150.38 103.23,150.38 102.43,151.19 97.94,151.19 97.88,151.13 96.09,151.13 88.08,159.14 69.55,159.14 63.66,153.24 63.66,153.24 63.6,153.19 51.69,153.19 48.74,150.23 48.74,141.74 50.18,140.3 53,140.3 54.07,139.22 54.31,139.22 54.57,138.97 54.57,138.73 55.24,138.05 57.66,138.05 60.07,135.64 60.07,132.06 60.3,131.83 v1(60.33,131.83)
MCU_SPI0_CS2Z: length 88.6
  TOP w0.127: v1(94.1,117.66) 94.05,117.66 93.86,117.47 92.93,117.47 92.85,117.39 U19.4 ; v1(155.8,140.44) 154.84,141.4 151.78,141.4 151.49,141.69 U7.24
  L5 w0.114: v1(98.48,130.15) 98.32,130 97.23,130 97.01,129.77 96.03,129.77 95.05,128.79 95.05,121.11 94.92,120.98 94.92,118.36 94.22,117.66 v1(94.1,117.66)
  L8 w0.114: v1(98.48,130.15) 101.19,130.15 102.87,131.83 109.81,131.83 109.93,131.7 111.89,131.7 112.01,131.83 118.26,131.83 119.35,132.92 122.22,132.92 122.87,132.28 123.24,132.28 123.57,132.61 126.31,132.61 127.43,133.72 138.06,133.72 139.26,134.92 141.95,134.92 142.19,134.68 145.88,134.68 146.22,135.02 151.11,135.02 153.14,137.05 153.14,137.95 155.02,139.83 155.19,139.83 v1(155.8,140.44)
MCU_SPI0_CS3Z: length 18.6
  TOP w0.127: U7.23 149,142.19 149.45,142.65 149.45,143.3 150.81,144.65 156.46,144.65 160.41,148.6 160.41,148.98 v1(159.96,149.42)
  BOTTOM w0.127: U51.4 159.31,149.03 159.71,149.42 v1(159.96,149.42)
MCU_SPI0_CS3Z_1V8: length 97.7
  L8 w0.114: v1(88.82,167.89) 90.55,169.62 101.92,169.62 103.14,170.84 112.16,170.84 112.68,171.37 123.2,171.37 124.7,172.86 127.84,172.86 127.88,172.9 142.09,172.9 143.56,171.43 143.56,170.81 154.43,159.94 154.43,153.47 156.01,151.89 156.65,151.89 158.25,150.29 158.25,145.29 v1(159.43,144.11)
  BOTTOM w0.127: U51.13 159.31,143.99 v1(159.43,144.11) ; U48.11 87.75,165.85 88.82,166.93 v1(88.82,167.89)
MCU_SPI0_CS4Z: length 15.9
  TOP w0.127: v1(159.96,148.79) 156.21,145.03 150.65,145.03 149.07,143.46 149.07,142.88 148.89,142.69 U7.22
  BOTTOM w0.127: U51.5 v1(159.96,148.79)
MCU_SPI0_CS4Z_1V8: length 68.8
  L10 w0.114: v1(160.11,144.11) 160.11,143.38 158.52,141.78 145.82,141.78 144.48,143.13 143.15,143.13 141.4,144.88 141.4,145.93 137.62,149.71 127.15,149.71 125.17,151.69 110.29,151.69 109.24,150.64 108.07,150.64 104.71,154 104.71,154.06 v1(103.91,154.86)
  BOTTOM w0.127: v1(160.11,144.11) 159.96,143.96 U51.12 ; v1(103.91,154.86) 103.34,155.44 U50.11
MCU_SPI0_CS5Z: length 4.6
  TOP w0.127: U7.60 162.71,145.69 v1(162.69,145.72)
  BOTTOM w0.127: U51.6 160.61,146.47 161.37,145.72 v1(162.69,145.72)
MCU_SPI0_CS5Z_1V8: length 88.7
  L8 w0.114: v1(160.61,142.62) 160.29,142.62 157.76,145.16 157.76,145.69 156.36,147.08 156.36,150.27 156.36,150.47 153.59,153.24 153.59,153.24 152.15,154.69 152.15,161.89 146.32,167.72 145.75,167.72 141.52,171.95 140.32,171.95 139.6,172.66 127.98,172.66 127.94,172.62 124.8,172.62 123.3,171.13 112.78,171.13 112.24,170.59 103.23,170.59 101.75,169.11 v1(100.46,169.11)
  BOTTOM w0.127: U47.11 100.18,165.85 100.58,166.26 100.58,168.99 v1(100.46,169.11) ; v1(160.61,142.62) U51.11
MCU_SPI0_CS6Z: length 78.1
  TOP w0.127: U7.59 161.83,145.19 160.2,143.57 154.77,143.57 v1(154.48,143.28)
  L8 w0.114: v1(93.45,131.83) 97.13,131.83 101.01,135.71 109.79,135.71 110.48,135.01 117.49,135.01 118.31,135.82 137.19,135.82 141.02,139.65 150.85,139.65 v1(154.48,143.28)
  BOTTOM w0.127: v1(93.45,131.83) 93.45,131.7 93.97,131.18 U53.11
MCU_SPI0_MISO: length 161.1
  TOP w0.127: v1(50.8,125.86) 50.8,126.11 51.23,126.54 U14.3 ; v1(94.13,116.78) 93.69,117.22 93.22,117.22 92.89,116.89 U19.3 ; v1(60.96,131.27) 61.34,131.27 61.59,131.01 61.59,130.01 61.61,129.99 61.61,127.92 62.71,126.82 U15.3 ; R131.2 150.67,137.19 v1(150.96,137.48)
  L5 w0.114: v1(98.04,131.06) 98.35,131.06 98.93,130.48 98.93,129.86 98.68,129.61 97.77,129.61 97.58,129.42 96.16,129.42 95.61,128.87 95.61,127.62 95.9,127.33 95.9,123.99 95.39,123.48 95.39,120.96 95.29,120.86 95.29,117.66 94.41,116.78 v1(94.13,116.78)
  L8 w0.114: v1(150.96,137.48) 150.35,138.09 147,138.09 145.8,136.89 144.58,136.89 144.13,137.34 142.96,137.34 142.51,136.89 139.23,136.89 137.47,135.13 118.69,135.13 117.73,134.17 110.35,134.17 109.5,135.02 102,135.02 v1(98.04,131.06) ; v1(60.96,131.27) 60.26,131.27 58.16,133.37 57.33,133.37 56.26,132.3 56.26,128.14 55.5,127.38 50.42,127.38 49.76,126.72 49.76,125.75 49.91,125.6 50.55,125.6 v1(50.8,125.86)
  L10 w0.114: v1(98.04,131.06) 98.42,131.06 99.63,129.86 99.63,128.04 98.97,127.38 92.78,127.38 91.87,128.29 90.94,128.29 89.8,129.42 85.34,129.42 83.9,127.98 77.25,127.98 73.35,131.88 63.37,131.88 62.76,131.27 v1(60.96,131.27)
  BOTTOM w0.127: U52.14 152.49,138.16 151.78,137.45 150.99,137.45 v1(150.96,137.48) ; U53.14 95.98,133.13 v1(98.04,131.06)
MCU_SPI0_MISO_1V8: length 84.7
  L8 w0.114: v1(150.5,149.73) 150.01,149.24 147.59,149.24 141.13,155.7 138.18,155.7 136.7,154.23 112.81,154.23 110.61,156.42 104.46,156.42 v1(104.42,156.46) 104.39,156.5 104.39,163.33 100.71,167 98.76,167 v1(97.97,167.8)
  BOTTOM w0.127: U48.14 86.85,168.46 87.86,169.47 95.91,169.47 96.63,168.75 U47.14 v1(97.97,167.8) ; v1(150.5,149.73) 151.02,149.21 151.65,149.21 152.49,148.38 U52.7 ; U50.14 103.51,157.39 104.39,156.51 104.39,156.5 v1(104.42,156.46)
MCU_SPI0_MOSI: length 149.6
  TOP w0.127: v1(151.49,137.9) 151.47,137.88 151.47,137 R130.2 ; v1(50.2,126.14) 50.73,126.68 U14.2 ; U15.2 62.77,127.32 62.14,127.95 v1(62.14,129.16) ; v1(93.47,116.78) 93.41,116.78 93.03,116.39 U19.2
  L5 w0.114: v1(97.41,131.06) 96.15,131.06 95.45,130.36 95.45,130.28 94.53,129.35 94.52,129.35 94.29,129.12 94.29,121.38 94.17,121.26 94.17,118.89 93.79,118.51 93.44,118.51 93.16,118.23 93.16,117.09 v1(93.47,116.78)
  L8 w0.114: v1(151.49,137.9) 150.95,138.44 146.84,138.44 145.64,137.24 144.72,137.24 144.27,137.69 142.82,137.69 142.37,137.24 139.09,137.24 137.33,135.48 118.55,135.48 117.58,134.51 110.49,134.51 109.64,135.36 101.71,135.36 v1(97.41,131.06) 94.72,131.06 93.47,129.81 91.67,129.81 88.46,133.03 79.84,133.03 79.57,133.29 76.56,133.29 75.26,134.59 68.63,134.59 67.74,133.71 65.2,133.71 62.61,131.11 62.61,129.63 v1(62.14,129.16) 62.14,129.87 61.25,130.76 60.29,130.76 58.02,133.03 57.48,133.03 56.6,132.15 56.6,128 55.64,127.04 51.09,127.04 v1(50.2,126.14)
  BOTTOM w0.127: v1(151.49,137.9) 151.84,138.25 U52.15 ; v1(97.41,131.06) 95.99,132.48 U53.13
MCU_SPI0_MOSI_1V8: length 82.9
  L8 w0.114: v1(100.13,166.5) 100.73,166.5 103.5,163.73 103.5,156.67 v1(103.76,156.41) 104.74,155.44 111.11,155.44 112.66,153.89 137.01,153.89 137.69,154.57 141.78,154.57 147.63,148.72 v1(150.48,148.72)
  BOTTOM w0.127: U50.13 103.44,156.74 v1(103.76,156.41) ; U48.13 87.76,167.15 87.88,167.28 87.88,168.76 88.21,169.09 95.2,169.09 95.61,168.68 95.61,167.25 95.71,167.15 U47.13 99.47,167.15 v1(100.13,166.5) ; v1(150.48,148.72) 151.51,148.72 151.84,148.39 U52.6
MCU_SPI1_CLK: length 108.4
  TOP w0.127: v1(154.41,145.9) 154.9,145.41 155.78,145.41 158.95,148.58 158.95,150.13 160.28,151.46 161.49,151.46 162.73,152.69 U7.74
  L8 w0.114: v1(154.41,145.9) 154.41,145.81 153.31,144.7 145.25,144.7 144.89,144.34 143.86,144.34 136.65,137.13 117.6,137.13 116.94,137.79 115.8,137.79 111.21,142.38 110.6,142.38 109.85,143.14 109.85,143.16 109.59,143.42 109.56,143.42 106.25,146.74 97.86,146.74 92.58,152.01 92.58,152.45 88.59,156.44 78.09,156.44 LCD1.14
MCU_SPI1_CS0Z: length 103.1
  TOP w0.127: v1(155.6,145.86) 158.55,148.81 158.55,150.27 160.12,151.84 161.28,151.84 162.64,153.19 U7.75
  L8 w0.114: v1(155.6,145.86) 155.6,145.63 153.51,143.54 152.58,143.54 150.11,141.07 141.76,141.07 136.99,136.3 117.2,136.3 117.07,136.43 111.97,136.43 111.96,136.44 110.71,136.44 105.77,141.37 105.77,142.26 102.79,145.24 96.62,145.24 90.17,151.69 88.98,151.69 86.12,154.54 80.68,154.54 LCD1.17
MCU_SPI1_MISO: length 2.5
  TOP w0.127: TP7.1 151.38,156.84 152.46,155.77 U7.95
MCU_SPI1_MOSI: length 103.3
  L8 w0.114: v1(151.38,151.38) 153.79,148.98 153.79,145.67 153.45,145.33 144.36,145.33 136.5,137.47 117.74,137.47 117.08,138.14 116.19,138.14 111.28,143.05 110.64,143.05 105.87,147.82 97.49,147.82 92.93,152.39 92.93,152.6 88.74,156.79 77.31,156.79 75.07,154.55 74.69,154.55 LCD1.13
  BOTTOM w0.127: R515.2 151.7,151.7 v1(151.38,151.38)
MCU_SRSTN_R: length 4
  TOP w0.127: R52.2 C42.1 R59.2 169.54,151.19 U6.2
MCU_U0RX: length 1.4
  TOP w0.127: R123.2 141.69,138.67 U12.1
MCU_U1RX: length 2.1
  TOP w0.127: v1(165.1,148.84) 164.95,148.69 U7.66
  BOTTOM w0.127: R524.2 164.97,148.97 v1(165.1,148.84)
MCU_U1TX: length 3.9
  TOP w0.127: U7.67 164.69,149.19 166.12,150.62 TP9.1
MCU_UART0_DETECT: length 31.2
  TOP w0.127: U12.6 145.61,137.67 145.36,137.42 145.36,136.19 145.72,135.84 150.58,135.84 150.76,135.65 v1(153.09,135.65) ; R232.2 156.29,121.54 MCU.1
  BOTTOM w0.127: v1(153.09,135.65) 153.58,136.14 154.21,136.14 156.59,133.76 156.59,130.05 155.83,129.29 155.83,124.21 156.92,123.11 MCU.1
MCU_UART_RX: length 37.3
  TOP w0.127: R123.1 140.77,137.74 143.18,135.33 150.37,135.33 150.74,134.96 154.1,134.96 v1(154.43,134.62)
  BOTTOM w0.127: v1(154.43,134.62) 154.18,134.37 154.18,129.2 154.81,128.57 154.81,123.15 154.35,122.68 152.27,122.68 151.76,122.17 151.76,118.49 152.43,117.83 U56.9
MCU_UART_TX: length 29.3
  TOP w0.127: v1(153.99,135.65) 153.99,135.66 153.55,136.1 152.37,136.1 152.3,136.04 150.92,136.04 150.73,136.22 148.7,136.22 R129.1
  BOTTOM w0.127: v1(153.99,135.65) 154.16,135.65 155,134.81 155,134.31 154.69,133.99 154.69,129.41 155.19,128.91 155.19,122.99 154.51,122.3 152.53,122.3 152.15,121.92 152.15,119.76 152.47,119.44 R578.1 153.23,119.44 153.92,118.75 154.88,118.75 154.95,118.67 154.99,118.67 155.23,118.43 U56.11
MCU_WAKEZ: length 11.7
  TOP w0.127: U7.50 161.96,140.19 v1(161.68,140.46)
  L8 w0.114: v1(161.68,140.46) 162.05,140.46 163.19,141.6 163.19,144.78 164.72,146.3 165.86,146.3 167,147.45 CN8.2
MCUOSC0: length 6.5
  TOP w0.127: Y2.1 160.32,134.16 160.75,134.59 C70.1 160.96,137.39 U7.48
MCUOSC1: length 7.1
  TOP w0.127: Y2.2 162,134.16 161.54,134.62 161.54,136.59 C71.2 162.14,137.23 161.46,137.91 U7.49
MCUXOSC0: length 2.8
  TOP w0.127: U7.52 164.43,141.69 164.72,141.99 165.41,141.99 R100.1
MCUXOSC0_R: length 7.1
  TOP w0.127: OSC1.3 167.51,137.98 167.51,141.68 167.07,142.12 R100.2
MMC_BLUE_LED: length 37.5
  TOP w0.254: v1(149.3,146.11) 149.22,146.19 U7.15
  L10 w0.254: v1(178.05,155.46) 178.05,155.44 176.81,154.2 176.81,151.66 170.16,145.02 161.94,145.02 161.29,145.67 157.73,145.67 157.35,145.29 149.99,145.29 149.3,145.97 v1(149.3,146.11)
  BOTTOM w0.254: R494.1 178.03,155.45 v1(178.05,155.46)
MMC_ENABLE_N: length 289.7
  TOP w0.127: AMC1.41 v1(8.38,64.46) ; R98.2 145.12,144.26 144.7,144.68 v1(144.7,144.78)
  L8 w0.114: v1(159.92,150.47) 159.92,153.45 159.3,154.06 159.3,157.11 158.1,158.31 158.1,163.94 155.7,166.34 155.7,167.52 148.85,174.38 146.92,174.38 146.43,174.87 145.04,174.87 144.17,175.74 76.94,175.74 58.28,157.08 48.82,157.08 47.08,155.34 47.08,141.38 50.01,138.45 50.01,129.35 46.67,126.02 45.82,126.02 43.52,123.71 43.52,123.18 43.03,122.69 43.03,120.28 39.95,117.21 39.95,116.51 37.38,113.93 34.33,113.93 31.76,111.35 31.76,105.26 31.91,105.11 31.91,97.91 24.21,90.21 13.56,90.21 10.89,92.88 8.08,92.88 7.12,91.92 7.12,76.2 8.14,75.18 8.56,75.18 9.06,74.68 9.06,65.14 v1(8.38,64.46)
  L10 w0.114: v1(159.92,150.47) 157.2,147.75 148.66,147.75 145.69,144.78 v1(144.7,144.78)
MMC_GA0: length 309.9
  TOP w0.127: v1(155.51,156.11) 155.48,156.11 155.06,156.53 154.62,156.53 153.96,155.86 U7.92 ; AMC1.5 5.39,37.46 6.06,36.79 8.81,36.79 v1(9.27,37.25)
  L8 w0.114: v1(9.27,37.25) 8.82,36.8 8.19,36.8 7.89,37.1 7.89,45 8.25,45.36 8.73,45.36 8.83,45.46 8.83,45.47 11.49,48.12 11.49,52.39 9.4,54.48 9.4,57.66 7.92,59.14 7.92,60.11 10.15,62.35 10.15,76.78 9.59,77.34 8.97,77.34 7.84,78.48 7.84,91.62 8.38,92.16 10.59,92.16 13.26,89.49 26.29,89.49 32.63,95.83 32.63,105.41 32.48,105.56 32.48,111.05 34.63,113.21 37.68,113.21 40.68,116.21 40.68,116.91 44.07,120.3 44.07,121.54 44.58,122.05 44.58,122.82 44.39,123.01 44.39,123.37 45,123.98 45.7,123.98 49.09,127.37 49.09,127.41 50.73,129.05 50.73,138.75 48.05,141.43 48.05,150.52 52.26,154.72 62.1,154.72 78.34,170.97 91.08,170.97 93.67,173.55 116.15,173.55 117.61,175.01 143.66,175.01 146.24,172.43 147.47,172.43 156.48,163.42 156.48,162.04 157.1,161.42 157.1,158.29 158.58,156.81 158.58,156.21 158.14,155.77 155.85,155.77 v1(155.51,156.11)
  BOTTOM w0.127: R501.1 151.76,155.96 151.13,156.59 R489.1 151.68,157.45 151.68,158.02 152.55,158.89 154.41,158.89 155.45,157.85 155.45,156.17 v1(155.51,156.11)
MMC_GA1: length 297.2
  TOP w0.127: U7.91 154.46,155.75 154.79,156.08 v1(154.88,156.08) ; AMC1.17 5.71,46.46 6.37,45.8 v1(8.39,45.8)
  L8 w0.114: v1(8.39,45.8) 9.68,47.08 9.68,52.79 9.13,53.34 8.57,53.34 7.68,54.23 7.68,60.21 9.91,62.45 9.91,76.68 9.51,77.09 8.89,77.09 7.6,78.38 7.6,91.72 8.28,92.4 10.69,92.4 13.36,89.73 26.19,89.73 32.39,95.93 32.39,105.31 32.24,105.46 32.24,111.15 34.53,113.45 37.58,113.45 40.44,116.31 40.44,117.01 43.69,120.26 43.69,122.67 44,122.98 44,123.32 44.9,124.22 45.6,124.22 48.85,127.47 48.85,127.51 50.49,129.15 50.49,138.65 47.81,141.33 47.81,150.62 52.16,154.97 62,154.97 78.31,171.27 91.05,171.27 93.57,173.79 112.76,173.79 114.22,175.25 143.94,175.25 145.71,173.48 147.94,173.48 148.59,172.83 148.59,171.99 156.72,163.86 156.72,162.14 157.35,161.5 157.35,158.38 158.82,156.91 158.82,156.11 158.24,155.53 155.43,155.53 v1(154.88,156.08)
  BOTTOM w0.127: R500.1 153.16,155.79 153.33,155.95 153.33,156.36 152.79,156.9 R488.1 151.98,157.45 151.98,157.96 152.66,158.64 154.3,158.64 154.98,157.96 154.98,156.18 v1(154.88,156.08)
MMC_GA2: length 289
  TOP w0.127: v1(9.14,52.7) 9.14,52.83 8.76,53.21 AMC1.26 ; U7.90 154.96,153.83 v1(154.87,153.74)
  L8 w0.114: v1(9.14,52.7) 8.76,53.09 8.48,53.09 7.44,54.13 7.44,60.81 9.3,62.67 9.3,74.78 8.65,75.44 8.22,75.44 7.36,76.3 7.36,91.82 8.18,92.64 10.79,92.64 13.46,89.97 26.09,89.97 32.15,96.03 32.15,105.21 32,105.36 32,111.25 34.43,113.69 37.48,113.69 40.2,116.41 40.2,117.11 43.33,120.25 43.33,122.66 43.76,123.08 43.76,123.42 44.8,124.46 45.5,124.46 48.61,127.57 48.61,127.61 50.25,129.25 50.25,138.55 47.32,141.48 47.32,155.24 48.92,156.84 61.77,156.84 77.62,172.69 89.87,172.69 92.67,175.49 144.04,175.49 145.81,173.72 148.04,173.72 148.84,172.92 148.84,172.68 157.71,163.81 157.71,158.36 159.06,157.01 159.06,156.01 156.79,153.74 v1(154.87,153.74)
  BOTTOM w0.127: R487.1 R499.1 154.98,154.84 154.98,153.85 v1(154.87,153.74)
MMC_GAPU: length 6.8
  TOP w0.127: U7.89 155.46,153.7 155.05,153.3 154.32,153.3 v1(153.93,153.68)
  BOTTOM w0.127: v1(153.93,153.68) 154.43,154.18 R499.2 R500.2 R501.2
MMC_PS_N0: length 340.1
  TOP w0.127: AMC1.83 7.34,95.96 7.66,95.64 8.62,95.64 9.02,96.04 v1(9.02,96.34) ; U7.63 162.5,147.19 v1(161.61,146.3) 158.88,146.3 v1(156.67,144.09) ; v1(12.06,37.08) 12.06,37.43 11.81,37.68 D10.2
  L3 w0.114: v1(9.02,96.34) 9.02,95.63 8.61,95.22 6.38,95.22 4.9,93.75 4.9,40.06 8.26,36.7 11.68,36.7 v1(12.06,37.08) ; v1(111.52,132.9) 111.52,132.91 110.38,134.04 110.38,135.41 105.99,139.8 104.27,139.8 102.78,141.29 102.78,141.31 98.96,145.14 98.96,148.27 96.86,150.37 95.83,150.37 89.87,156.33 89.87,156.77 82.11,164.53 42.23,164.53 41.34,163.65 39.19,163.65 38.1,162.56 35.94,162.56 31.65,158.27 31.65,157.51 28.96,154.81 v1(28.3,154.81)
  L8 w0.114: v1(111.52,132.9) 112.1,133.48 118.01,133.48 118.21,133.68 123.5,133.68 124.27,134.45 137.76,134.45 139.4,136.09 145.97,136.09 146.74,136.86 151.06,136.86 151.92,137.71 151.92,138.7 154.62,141.4 154.74,141.4 156.67,143.33 v1(156.67,144.09) ; v1(28.3,154.81) 26.93,153.45 26.93,148.86 32.96,142.84 37.59,142.84 38.17,143.41 38.17,143.82 38.43,144.08 39.82,144.08 40.49,143.41 40.49,142.37 41.58,141.27 42.55,141.27 42.75,141.48 43.03,141.48 43.43,141.07 43.43,139.41 46.83,136.02 46.83,131.58 46.53,131.27 45.93,131.27 44.9,130.24 39.9,130.24 37.47,127.81 37.47,125.18 34.84,122.56 34.48,122.56 24.61,112.69 15.92,112.69 12.95,109.72 12.95,98.42 10.88,96.34 v1(9.02,96.34)
  BOTTOM w0.127: v1(161.61,146.3) 161.67,146.24 163.44,146.24 R528.2
