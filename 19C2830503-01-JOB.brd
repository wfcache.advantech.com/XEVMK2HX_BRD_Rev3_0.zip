# Allegro board 19C2830503-01-JOB.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N14625100: length 2.8
  TOP w0.279: U27.5 24.97,66.83 v1(25.12,66.68)
  BOTTOM w0.381: C293.1 25.74,66.06 v1(25.12,66.68)
N14634249: length 2.7
  TOP w0.279: U27.1 22.11,66.42 21.72,66.02 21.72,65.09 C292.2
N14638052: length 1.9
  TOP w0.279: U27.9 23.61,70.5 23.63,70.52 C314.1
N14711749: length 1.5
  TOP w0.279: U13.34 127.66,129.56 127.54,129.68 127.54,130.33
N14715464: length 12.5
  TOP w0.127: U13.19 133.38,125.6 133.57,125.79 133.74,125.79 134.35,126.41 134.35,127.11 136.88,129.64 141.05,129.64 141.84,130.44 R179.2
N14715500: length 10.4
  TOP w0.127: R162.2 139.94,132.56 139.65,132.28 v1(139.65,132.21) ; v1(133.91,126.59) 133.41,126.1 U13.20
  BOTTOM w0.127: v1(133.91,126.59) 134.04,126.59 137.83,130.39 137.83,130.81 139.18,132.16 139.6,132.16 v1(139.65,132.21)
N14716011: length 5.8
  TOP w0.127: TP14.1 130.94,133.22 130.94,132.14 R174.2 130.3,130.56 129.16,129.42 U13.31
N14719575: length 2.4
  TOP w0.254: R212.2 123.52,125.1 U13.43
N14809841: length 4.6
  BOTTOM w0.254: R769.2 39.05,42.29 38.04,42.29 R770.1 38.1,41.98 38.1,41.08 C764.1 38.2,40.56 U60.1
N14810291: length 3.2
  BOTTOM w0.305: R508.1 75.56,157.73 R505.2
  BOTTOM w0.381: R508.1 75.57,157.72 Q13.1
N14872798: length 2.4
  TOP w0.127: C117.1 R227.2 R221.1
N14873463: length 1.9
  TOP w0.381: R219.1 63.38,134.82 C123.1
N14876495: length 5.2
  BOTTOM w0.127: TP19.1 74.93,128.92 73.98,127.98 73.98,125.91 73.35,125.28 R183.1
N14876513: length 5.1
  BOTTOM w0.127: TP18.1 74.93,129.93 74.04,129.04 74.04,128.39 73.73,128.08 73.73,126.37 R182.1
N14876577: length 3.2
  BOTTOM w0.127: R181.1 73.35,128.06 73.73,128.44 73.73,130.36 TP12.1
N14876581: length 2
  BOTTOM w0.127: TP24.1 72.39,129.77 73.35,128.81 R180.1
N14876667: length 2.2
  TOP w0.127: U15.35 71.62,127.32 v1(71.7,127.41)
  BOTTOM w0.127: v1(71.7,127.41) 71.73,127.38 R181.2
N14876671: length 2.6
  TOP w0.127: U15.36 71.18,127.82 v1(71.37,128.02)
  BOTTOM w0.127: v1(71.37,128.02) 72.14,128.78 R180.2
N14876735: length 2.9
  TOP w0.127: v1(71.48,125.82) U15.32
  BOTTOM w0.127: R183.2 72.45,124.85 v1(71.48,125.82)
N14876739: length 2.9
  TOP w0.127: U15.33 71.84,126.32 v1(72.21,126.7)
  BOTTOM w0.127: v1(72.21,126.7) 72.45,126.46 R182.2
N14994125: length 4.6
  TOP w0.356: 131.4,66.17 U29.1
  TOP w0.508: 131.4,66.17 131.02,65.79 128.52,65.79
N14997851: length 9.7
  TOP w0.381: B15.3 106.12,117.98 C140.1 C146.2 105.59,116.33 OSC2.1 103.68,115.62 103.25,115.19 101.35,115.19 101.04,115.49 OSC2.6
N15094693: length 11
  TOP w0.279: U10.30 50.88,143.23 50.73,143.09 v1(50.67,143.09) ; v1(54.69,140.41) 54.5,140.59 U10.37
  TOP w0.508: v1(54.69,140.41) 54.69,139.98 54.93,139.74 C74.2 54.93,138.54 55.3,138.17 C829.2
  L5 w0.508: v1(54.69,140.41) 54.69,140.46 52.06,143.09 v1(50.67,143.09)
  BOTTOM w0.508: v1(50.67,143.09) 50.67,143.03 50.23,142.59 R122.1
N15442351: length 5.9
  BOTTOM w0.127: LCD1.1 51.82,153.87 C408.1
N15442395: length 5.9
  BOTTOM w0.127: LCD1.2 53.21,153.97 C407.1
N15442399: length 6
  BOTTOM w0.127: C406.2 54.61,154.08 LCD1.3
N15442403: length 6
  BOTTOM w0.127: LCD1.4 56.01,154.18 C405.1
N15442407: length 6
  BOTTOM w0.127: LCD1.5 57.4,154.28 C404.2
N15443451: length 6.3
  BOTTOM w0.127: C412.1 58.99,154.19 LCD1.6
N15443455: length 6.3
  BOTTOM w0.127: C412.2 60.64,154.04 LCD1.7
N15443549: length 6
  BOTTOM w0.127: LCD1.8 62.8,153.38 C411.2
N15443557: length 5.9
  BOTTOM w0.127: C411.1 64.45,153.23 LCD1.9
N15443902: length 5.5
  BOTTOM w0.127: LCD1.10 67.88,152.24 C410.1
N15556145: length 1.5
  TOP w0.102: U24.L4 81.94,98 v2(81.94,97.93)
  BOTTOM w0.102: v2(81.94,97.93) 81.92,97.95 81.92,97.99 TP66.1
N15556149: length 10.1
  TOP w0.127: U24.L1 81.52,101.77 81.34,101.94 81.34,102.72 81.36,102.73 81.36,104.65 80.39,105.61 80.39,107.52 80.7,107.82 80.7,110.46 TP44.1
N15571799: length 2.7
  TOP w0.508: R83.1 168.85,131.47 CN2.1
N15576101: length 2.8
  TOP w0.381: Q1.3 166.06,167.5 166.3,167.26 R20.2 R19.2
N15576385: length 7.2
  TOP w0.381: Q1.5 167.43,171.17 v1(167.92,170.69)
  BOTTOM w0.381: v1(167.92,170.69) 167.77,170.69 167.65,170.57 R4.2 162.26,170.57 R3.1
N15613486: length 8.3
  TOP w0.102: 93.18,75.8 91.36,75.8 90.98,75.42 U24.B27
  TOP w0.127: R367.2 97.95,76.61 93.99,76.61 93.18,75.8
N15624378: length 2.6
  TOP w0.127: TP40.1 91.05,113.03 90.35,113.73 90.35,114.05 90.12,114.27 U19.45
N15625166: length 3.1
  TOP w0.127: R277.1 94.67,118.1 94.2,118.58 93.02,118.58 92.83,118.39 U19.6
N15625345: length 1.3
  TOP w0.127: R299.2 C172.1
N15626537: length 3.1
  TOP w0.254: U19.40 87.62,114.17 86.55,113.09 C169.2
N15627377: length 2.4
  TOP w0.127: U19.1 94.18,115.89 94.49,116.21 R285.1
N15627381: length 2.7
  TOP w0.127: R301.1 92.33,113.48 91.12,114.69 U19.47
N15633874: length 2
  TOP w0.127: U15.23 69,120.88 R200.2
N15633892: length 1.7
  TOP w0.127: R204.2 68.5,120.11 U15.22
N15633910: length 1.6
  TOP w0.127: TP27.1 69.93,118.75 R200.1
N15633914: length 1.2
  TOP w0.127: R204.1 68.66,117.93 TP28.1
N15634110: length 3.1
  TOP w0.127: U15.29 70.99,124.32 72.07,123.24 R184.2
N15634114: length 4.1
  TOP w0.127: R185.2 71.69,121.41 71.69,123.27 71.13,123.82 U15.28
N15634136: length 6.8
  TOP w0.127: R184.1 72.97,122.7 v1(72.51,123.15)
  BOTTOM w0.127: TP20.1 74.24,127.2 74.24,125.41 73.76,124.94 73.76,124.18 72.73,123.15 v1(72.51,123.15)
N15634140: length 7
  TOP w0.127: v1(72.49,121.69) 72.97,121.22 R185.1
  BOTTOM w0.127: TP17.1 74.93,124.08 74.55,123.7 74.17,123.7 72.49,122.02 v1(72.49,121.69)
N15634384: length 1.2
  TOP w0.127: R215.1 66.04,117.91 TP30.1
N15634388: length 1.2
  TOP w0.127: R210.1 TP29.1
N15634420: length 2.6
  TOP w0.127: U15.20 67.5,120.71 67.13,120.34 66.99,120.34 66.61,119.96 R215.2
N15634424: length 1.9
  TOP w0.127: U15.21 68,120.57 R210.2
N15783905: length 6.9
  TOP w0.127: R262.2 136.09,119.63 134.54,121.18 132.83,121.18 132.55,120.91 131.6,120.91 131.16,121.34 U13.10
N15783945: length 7.5
  TOP w0.127: R263.2 136.99,119.09 134.64,121.44 134.43,121.44 132.72,121.44 132.45,121.16 131.9,121.16 131.66,121.4 U13.11
N15994751: length 5.2
  BOTTOM w0.127: C360.2 R440.1 36.39,44.9 36.7,45.21 37.35,45.21 37.6,44.96 U36.8 37.6,43.8 37.72,43.69 37.97,43.69 38.1,43.81 38.1,44.43 U36.7
N15995652: length 3.4
  TOP w0.102: U24.AN19 58.99,83.95 v2(58.93,83.95)
  BOTTOM w0.102: TP74.1 58.55,84.33 v2(58.93,83.95)
N15996235: length 1.4
  TOP w0.381: U24.AK32 62.52,70.42 v2(62.99,69.95)
  BOTTOM w0.381: RR1.1 63.34,69.67 63.06,69.95 v2(62.99,69.95)
N16003549: length 2.4
  TOP w0.102: v2(87.05,78.94) 87.05,78.95 U24.E23
  BOTTOM w0.102: v2(87.05,78.94) 87.05,79.41 87.52,79.89 TP78.1
N16003553: length 1.4
  TOP w0.102: U24.F23 86.09,78.99 v2(86,78.99)
  BOTTOM w0.102: TP77.1 85.51,78.51 v2(86,78.99)
N16007057: length 1.8
  BOTTOM w0.508: NOR1.8 135.11,133.9 R558.2
N16018876: length 127
  TOP w0.102: v2(87.99,68.88) 87.99,68.95 U24.E33
  TOP w0.127: v1(32.7,34.42) 32.31,34.03 CN20.1
  L8 w0.102: v2(87.99,68.88) 88.62,68.25 88.62,63.62 90.64,61.59
  L8 w0.114: 90.64,61.59 94.47,57.77 94.47,55.87 95.76,54.58 95.76,53.8 98.63,50.93 104.71,50.93 109.29,46.35 109.29,44.25 109.79,43.75 109.79,35.66 107.39,33.25 33.86,33.25 v1(32.7,34.42)
N16018889: length 133.4
  TOP w0.102: v2(85.94,75.84) 86.52,76.42 U24.F26
  TOP w0.127: CN20.2 35.44,35.08 35.69,35.33 v1(35.69,35.46)
  L8 w0.102: 90.3,61.59 86.64,65.26 86.64,69.82 86.54,69.93 86.54,75.25 v2(85.94,75.84)
  L8 w0.114: 90.3,61.59 94.23,57.67 94.23,55.77 95.52,54.48 95.52,53.7 98.53,50.69 104.61,50.69 109.05,46.25 109.05,44.15 109.55,43.65 109.55,35.76 107.29,33.5 35.34,33.5 35.05,33.78 35.05,34.82 v1(35.69,35.46)
N16018895: length 125.8
  TOP w0.102: v2(86,69.93) 86.5,70.42 U24.F32
  TOP w0.127: CN20.3 36.31,33.64 37.03,34.37 37.03,34.85 36.61,35.27 v1(36.61,35.48)
  L8 w0.102: 89.96,61.59 86.41,65.14 86.41,69.52 v2(86,69.93)
  L8 w0.114: v1(36.61,35.48) 36.79,35.31 36.79,34.84 37.89,33.74 107.19,33.74 109.31,35.86 109.31,43.55 108.81,44.05 108.81,46.15 104.51,50.44 98.43,50.44 95.28,53.6 95.28,54.38 93.99,55.67 93.99,57.57 89.96,61.59
N16018907: length 129.2
  TOP w0.102: v2(85.02,75.92) U24.G26
  TOP w0.127: v1(37.34,35.43) 37.64,35.43 37.99,35.08 CN20.4
  L8 w0.102: v2(85.02,75.92) 85.09,75.85 85.09,75.84 85.47,75.46 85.47,65.28 88.27,62.48
  L8 w0.114: v1(37.34,35.43) 37.64,35.43 39.1,33.98 107.09,33.98 109.07,35.96 109.07,43.45 108.57,43.95 108.57,46.05 104.41,50.2 97.01,50.2 88.27,58.94 88.27,62.48
N16053779: length 2.4
  TOP w0.127: U7.19 147.4,144.19 147.11,144.49 146.36,144.49 R98.1
N16114816: length 2
  TOP w0.127: U13.14 133.74,123.1 v1(133.89,123.25)
  BOTTOM w0.127: v1(133.89,123.25) 133.45,122.81 R574.2
N16169033: length 1.7
  TOP w0.127: R193.1 53.47,136.85 TP26.1
N16169055: length 1.3
  TOP w0.127: TP16.1 49.47,136.85 R190.1
N16169087: length 1.8
  TOP w0.127: U14.32 52.23,135.79 R193.2
N16169091: length 2.4
  TOP w0.127: R190.2 51.06,135.95 51.73,135.27 U14.33
N16169113: length 3.7
  TOP w0.127: U14.35 50.73,134.94 50.42,135.25 48.2,135.25 R189.2
N16169117: length 3.7
  TOP w0.127: U14.36 50.23,134.75 49.98,135 48.77,135 47.95,134.18 R188.2
N16169139: length 2.7
  TOP w0.127: R189.1 47.94,135.89 TP23.1
N16169161: length 1.3
  TOP w0.127: R188.1 47.12,133.66 TP22.1
N16188479: length 5.4
  TOP w0.127: R39.1 166.5,155.76 166.5,158.12 167.89,159.51 U4.6
N16257033: length 19.5
  TOP w0.127: TP42.1 70.67,114.37 70.68,114.37 71.25,113.8 71.25,110.62 70.61,109.98 70.61,107.58 69.46,106.43 68.56,106.43 66.15,104.01 64.39,104.01 62.52,102.14 U24.AK1
N16257361: length 6.2
  TOP w0.127: TP41.1 74.9,105.82 78.52,102.2 U24.P1
N16294811: length 8.7
  BOTTOM w0.305: 77.42,123.9 U54.8 ; 77.42,123.9 76.65,124.67 R586.2 ; 77.42,123.9 77.42,123.98 77.67,124.23 80.11,124.23 81.23,123.11 U54.5
N16297458: length 2.8
  TOP w0.254: DBG_D1.3 v1(179.07,152.26)
  BOTTOM w0.254: Q14.3 178.12,153.23 179.07,152.27 v1(179.07,152.26)
N16299090: length 2.9
  TOP w0.254: v1(178.31,145.82) 178.33,145.8 DBG_D2.1
  BOTTOM w0.254: v1(178.31,145.82) 178,145.82 177.48,145.3 Q16.3
N16301183: length 2.9
  TOP w0.254: DBG_D3.1 178.44,141.86 177.74,142.56 Q5.3
N16301445: length 9.8
  TOP w0.102: v2(79.06,100.03) 78.91,100.03 U24.P2
  BOTTOM w0.102: 80.26,104.01 80.26,101.23 v2(79.06,100.03)
  BOTTOM w0.127: 80.26,104.01 80.49,104.24 80.49,108.36 TP62.1
N16305012: length 24.1
  L3 w0.114: v1(139.29,159.61) 140.28,159.61 144.09,163.42 146.06,163.42 150.53,167.89 150.53,172.31 v1(151.16,172.93)
  BOTTOM w0.127: U45.14 v1(151.16,172.93) ; v1(139.29,159.61) 138.39,158.71 U49.42
N16305018: length 20.2
  L3 w0.114: v1(141.12,161.57) 141.9,161.57 143.99,163.66 144.35,163.66 147.07,166.37 147.07,168.4 148.58,169.92 148.58,170.7 v1(147.96,171.32)
  BOTTOM w0.127: v1(141.12,161.57) 140.76,161.21 U49.47 ; U45.16 148.26,171.63 v1(147.96,171.32)
N16305024: length 18.4
  L3 w0.114: v1(140.27,161.71) 140.61,162.05 142.04,162.05 143.89,163.9 144.21,163.9 146.69,166.37 146.69,169.16 v1(148.08,170.56)
  BOTTOM w0.127: v1(140.27,161.71) 139.82,161.71 139.82,161.71 U49.48 ; v1(148.08,170.56) 148.31,170.33 U45.18
N16307332: length 4.1
  TOP w0.127: v1(154.91,80.52) 154.91,82.3 v1(154.84,82.37) 154.38,81.91 C246.2
  BOTTOM w0.127: C246.2 154.38,81.91 v1(154.84,82.37) ; R681.1 v1(154.91,80.52)
N16307607: length 5
  L3 w0.114: v1(155.27,77.6) 155.3,77.57 v1(155.3,76.15)
  BOTTOM w0.127: R695.1 155.24,76.2 v1(155.3,76.15) ; v1(155.27,77.6) R689.1 154.29,77.64 154.29,78.95 C644.2
N16307811: length 4.9
  TOP w0.127: C294.2 154.25,72.31 155.07,73.13 v1(155.07,73.28)
  L3 w0.114: v1(155.17,74.68) 155.17,73.38 v1(155.07,73.28)
  BOTTOM w0.127: R705.1 v1(155.07,73.28) ; R700.1 v1(155.17,74.68)
N16308017: length 4.8
  TOP w0.127: v1(155.12,70.48) 155.04,70.56 v1(155.04,71.88)
  BOTTOM w0.127: C714.2 154.25,69.72 R717.1 v1(155.12,70.48) ; R710.1 v1(155.04,71.88)
N16308726: length 3.5
  TOP w0.127: v1(154.93,100.83) 154.94,100.82 v1(154.94,99.42) 154.93,99.42 C201.2
  BOTTOM w0.127: R624.1 v1(154.94,99.42) ; R618.1 v1(154.93,100.83)
N16308822: length 4.7
  TOP w0.127: v1(155.19,97.7) v1(155.19,96.27) 154.81,96.65 C209.2
  BOTTOM w0.127: v1(155.19,96.27) 154.81,96.27 154.43,96.65 C209.2 ; R626.1 154.85,98.04 v1(155.19,97.7)
N16308918: length 4.2
  TOP w0.127: C214.2 v1(155.19,95.25) v1(155.19,93.85)
  BOTTOM w0.127: R636.1 v1(155.19,93.85) ; C214.2 v1(155.19,95.25)
N16309014: length 4.5
  L3 w0.114: v1(155.09,91.06) 155.12,91.09 v1(155.12,92.46)
  BOTTOM w0.127: v1(155.09,91.06) R641.1 C572.2 ; R637.1 v1(155.12,92.46)
N16316172: length 1.9
  TOP w0.127: R86.1 146.72,145.19 U7.17
N16319325: length 16.3
  TOP w0.127: v1(162.69,146.69) 162.69,146.63 163.13,146.19 U7.61
  L8 w0.114: v1(159.48,152.78) 159.48,150.29 159.88,149.89 162.04,149.89 163.15,148.77 163.15,147.15 v1(162.69,146.69)
  BOTTOM w0.127: R514.1 154.81,152.6 155.19,152.98 159.28,152.98 v1(159.48,152.78)
N16321956: length 1.7
  BOTTOM w0.127: R521.2 154.44,149.28 U52.10
N16474415: length 1.5
  TOP w0.254: R110.1 D6.1
N16474431: length 2.6
  TOP w0.254: D6.2 v1(175.95,139.47)
  BOTTOM w0.254: Q18.3 175.3,140.12 v1(175.95,139.47)
N16572263: length 2.2
  TOP w0.127: U7.16 147.37,145.69 R75.1
N16574652: length 10.3
  TOP w0.127: R9.1 144.19,172.19 v1(144.96,171.42)
  BOTTOM w0.127: U45.1 144.6,169.03 144.96,169.39 v1(144.96,171.42) 146.15,171.42 147.89,169.68 U45.19
N16576068: length 4.3
  BOTTOM w0.127: U45.15 151.35,172.28 R472.2 151.54,171.51 151.02,170.98 U45.17
N16577490: length 18.3
  L3 w0.114: v1(141.27,159.61) 143.03,161.37 143.95,161.37 144.77,162.19 145.85,162.19 v1(150.01,166.34)
  BOTTOM w0.127: v1(150.01,166.34) 149.86,166.34 149.16,167.05 R480.1 ; U49.41 139.87,158.21 v1(141.27,159.61)
N16755452: length 18.2
  TOP w0.102: v2(89.02,74.92) U24.D28
  BOTTOM w0.102: v2(89.02,74.92) 89.4,75.31 90.15,75.31 90.37,75.09 90.37,74.79 90.87,74.3 93.18,74.3
  BOTTOM w0.127: 93.18,74.3 95.84,76.95 103.09,76.95 103.84,76.2 R691.1
N16755456: length 11.1
  TOP w0.102: U24.A29 91.88,73.79 92.99,73.79 93.18,73.98
  TOP w0.127: 93.18,73.98 96.83,73.98 96.93,73.88 99.28,73.88 99.52,74.12 101.5,74.12 102.05,74.67 R373.1
N16755460: length 19.3
  TOP w0.102: U24.E25 87.52,77.41 v2(87.12,77.01)
  BOTTOM w0.102: 93.18,80.54 89.1,80.54 88.4,79.84 88.4,79.77 88.17,79.54 88.1,79.54 87.54,78.99 87.54,77.43 v2(87.12,77.01)
  BOTTOM w0.127: R690.1 101.85,79.12 99.45,81.52 94.16,81.52 93.18,80.54
N16755464: length 28.6
  TOP w0.102: U24.G28 85.03,73.94 v2(84.99,73.94)
  BOTTOM w0.102: 93.18,81.3 86.86,81.3 86.64,81.08 86.64,77.08 85.56,76 85.56,75.93 84.97,75.34 84.91,75.34 84.66,75.09 84.66,74.27 v2(84.99,73.94)
  BOTTOM w0.127: R692.1 102.43,78.23 102.43,79.44 102.21,79.67 102.07,79.67 98.87,82.87 94.75,82.87 93.18,81.3
N16755468: length 20
  TOP w0.102: v2(88.02,77.12) 88.22,77.12 U24.D25
  TOP w0.127: R369.1 104.32,76.7 v1(103.94,77.08)
  BOTTOM w0.102: v2(88.02,77.12) 88.1,77.12 89.1,76.12 89.62,76.12 90.68,75.07 90.68,74.77 90.9,74.55 92.99,74.55 93.18,74.74
  BOTTOM w0.127: v1(103.94,77.08) 103.82,77.2 95.65,77.2 93.18,74.74
N16757437: length 1.4
  BOTTOM w0.254: Q16.1 R525.2
N16758697: length 1.5
  TOP w0.254: Q5.1 177.55,146.67 R76.2
N16759046: length 2
  TOP w0.102: v2(89.99,74.93) 89.52,75.41 U24.C27
  BOTTOM w0.102: v2(89.99,74.93) 89.41,74.35 TP84.1
N16759085: length 2
  TOP w0.102: v2(88.01,74.9) 88.52,75.41 U24.D27
  BOTTOM w0.102: v2(88.01,74.9) 88.47,74.44 88.47,73.81 TP85.1
N16759125: length 2.4
  TOP w0.102: v2(86.97,74.93) 87.02,74.93 U24.E27
  BOTTOM w0.102: TP87.1 87.54,74.02 86.97,74.59 v2(86.97,74.93)
N16759185: length 2.3
  TOP w0.102: v2(89.97,76.96) 89.97,76.97 U24.C25
  BOTTOM w0.102: TP80.1 89.53,77.4 v2(89.97,76.96)
N16759219: length 1.5
  TOP w0.102: v2(86.97,75.84) 87.52,76.39 U24.E26
  BOTTOM w0.102: v2(86.97,75.84) 86.91,75.84 TP82.1
N16759253: length 1.5
  TOP w0.102: v2(88.03,75.94) 88.51,76.42 U24.D26
  BOTTOM w0.102: TP81.1 88.03,75.9 v2(88.03,75.94)
N16761112: length 1.5
  BOTTOM w0.254: R522.2 178.57,150.61 Q14.1
N16761155: length 2.3
  TOP w0.254: Q4.3 176.98,150.81 178.03,149.76 DBG_D1.2
N16761582: length 3
  TOP w0.254: Q4.1 v1(177.42,152.2)
  BOTTOM w0.254: v1(177.42,152.2) 177.14,152.2 176.4,152.93 R510.2
N16762531: length 11.8
  TOP w0.127: R12.2 134.78,170.97 137.9,174.09 v1(141.78,174.09)
  BOTTOM w0.127: v1(141.78,174.09) 141.92,174.23 U45.9
N16762648: length 12.3
  BOTTOM w0.127: U45.12 152.66,174.23 153.38,173.52 153.38,170.17 151.82,168.61 151.82,167.69 151.51,167.39 150.31,167.39 R480.2
N16762689: length 2.3
  BOTTOM w0.254: R490.1 135.32,156.84 135.74,156.84 135.88,156.71 U49.38
N16762695: length 4.1
  TOP w0.127: v1(134.48,156.34) 134.93,156.78 135.69,156.78 136.19,156.28 U5.5
  BOTTOM w0.127: R490.2 133.92,156.91 v1(134.48,156.34)
N16787536: length 7.3
  TOP w0.127: v1(61.3,125.37) 61.3,125.46 60.8,125.96 C137.1 60.33,126.24 59.62,125.53 R239.2 R240.2 59.62,122.92 R241.1
  BOTTOM w0.127: v1(61.3,125.37) 61.3,126.21 R584.2
N16789476: length 15.2
  TOP w0.254: R302.2 94.04,112.07 94.41,112.45 C168.1 R303.1 96.64,114.05 97.36,114.78 97.36,115.24 97.21,115.4 97.21,115.68 97.73,116.21 97.73,116.63 97.21,117.15 97.21,117.37 96.07,118.51 v1(96.07,118.52) 95.83,118.52 95.57,118.78 R273.2 ; R272.2 95.57,120.72 96.04,121.18 v1(96.27,121.18)
  L5 w0.254: v1(96.27,121.18) 96.19,121.11 96.19,118.64 v1(96.07,118.52)
N16800870: length 1.8
  BOTTOM w0.381: R533.2 174.12,144.32 174.35,144.09 Q18.1
N16809810: length 3
  TOP w0.127: CN3.79 39.34,151.7 39.91,151.13 R60.2
N16809812: length 2.8
  TOP w0.127: CN3.81 39.39,152.2 39.5,152.31 40.16,152.31 40.25,152.4 R55.2
N16815045: length 8.3
  TOP w0.102: 93.18,74.39 92.84,74.04 90.9,74.04 U24.B28
  TOP w0.127: 93.18,74.39 93.34,74.55 95.74,74.55 96.11,74.92 98.11,74.92 R372.1
N16822090: length 2.3
  TOP w0.254: v1(117.73,120.52) 117.73,120.52 117.54,120.71 U16.33
  BOTTOM w0.254: v1(117.73,120.52) 118.37,121.16 R575.1
N16822339: length 2.5
  TOP w0.254: v1(117.78,121.82) 117.75,121.82 117.65,121.71 U16.35
  BOTTOM w0.254: R573.1 118.55,122.19 118.18,121.82 v1(117.78,121.82)
N16822637: length 4.3
  TOP w0.254: R331.1 27.3,89.29 27.3,87.34 27.17,87.2 27.17,86.48 27.06,86.36 U25.41
N16822639: length 4.2
  TOP w0.254: R330.1 26.92,89.44 26.92,87.63 26.77,87.48 26.77,86.63 26.55,86.41 U25.42
N16822641: length 4.8
  TOP w0.254: R366.1 35.24,76.84 33.66,78.42 33.2,78.42 32.82,78.03 U25.18
N16822643: length 4.2
  TOP w0.254: R379.1 31.31,74.81 30.22,74.81 29.06,75.97 U25.12
N16822690: length 3.8
  TOP w0.254: v1(33.89,79.43) 33.71,79.25 32.6,79.25 32.38,79.03 U25.20
  BOTTOM w0.254: v1(33.89,79.43) 34.36,79.43 34.92,78.87 R688.1
N16822692: length 5.7
  TOP w0.254: R362.1 34.69,78.27 34.69,78.96 34.48,79.17 34.48,80.03 33.94,80.57 33.48,80.57 32.95,80.03 U25.22
N16822705: length 4.2
  TOP w0.254: R344.1 34.82,85.47 32.88,83.53 U25.29
N16822707: length 6.9
  TOP w0.254: U25.14 30.06,76.17 30.61,75.62 33.86,75.62 35.11,74.36 R381.1
N16822989: length 4.5
  TOP w0.254: U25.30 32.6,84.03 35.18,86.61 R341.1
N16822991: length 5.1
  TOP w0.254: R340.1 35.24,87.43 32.34,84.53 U25.31
N16822993: length 5.7
  TOP w0.254: U25.32 32.27,85.03 34.7,87.46 34.7,88.51 R334.1
N16822995: length 3.5
  TOP w0.254: R339.1 33.78,87.22 32.35,85.78 U25.33
N16823042: length 2
  TOP w0.254: U25.36 29.55,86.46 29.5,86.52 29.5,86.95 29.98,87.43 R337.1
N16823044: length 4.4
  TOP w0.254: R332.1 30.05,89.61 29.34,88.9 29.34,87.38 29.06,87.09 U25.37
N16823057: length 1.8
  TOP w0.127: v1(28.06,86.73) U25.39
  BOTTOM w0.127: R650.1 28.07,86.74 v1(28.06,86.73)
N16823059: length 1.7
  TOP w0.127: U25.35 30.06,86.68 v1(30,86.73)
  BOTTOM w0.127: v1(30,86.73) 30.1,86.83 R651.1
N16825201: length 2
  TOP w0.254: U1.1 113.46,172.96 R8.2
N16825817: length 2.2
  TOP w0.254: U1.4 109.98,174.68 110.19,174.88 v1(110.19,175.01) ; v1(109.55,175.01) 109.48,174.94 U1.5
N16826413: length 2.8
  TOP w0.254: C16.1 107.77,168.6 108.98,169.82 U1.9
N16826793: length 5.1
  TOP w0.254: v1(105.03,170.05) 105.66,170.69 R17.1 107.82,170.69 108.23,171.1 U1.8
  BOTTOM w0.254: R17.1 105.66,170.69 v1(105.03,170.05)
N16826901: length 1.9
  TOP w0.254: U1.13 110.98,170.07 111.83,169.22 C13.1
N16827286: length 2.1
  TOP w0.254: U1.11 109.98,169.42 ; U1.12 110.48,169.43
N16827414: length 4.7
  TOP w0.254: U1.7 108.22,172.97 106.49,172.97 R10.1 104.84,173.35 R7.2
N16865403: length 2.1
  BOTTOM w0.381: R504.2 173.57,155.43 174.35,156.21 Q12.1
N16865412: length 3.7
  TOP w0.381: v1(169.95,157.71) 169.95,157.3 170.26,157 D4.1
  BOTTOM w0.381: R492.1 170.69,156.97 v1(169.95,157.71)
N16865430: length 4.8
  TOP w0.381: D4.2 v1(169.8,158.5)
  BOTTOM w0.381: v1(169.8,158.5) 173.23,158.5 Q12.3
N16865801: length 3.1
  TOP w0.254: Q3.1 176.54,155.32 176.8,155.57 v1(176.8,156.2)
  BOTTOM w0.254: v1(176.8,156.2) 176.68,156.2 176.26,155.79 R494.2
N16865808: length 2.1
  TOP w0.254: R30.1 178.31,158.24 179.2,157.35 D3.2
N16865818: length 3
  TOP w0.254: 179.2,158.62 v1(179.2,159.49)
  BOTTOM w0.254: v1(179.2,159.49) 179.18,159.49 178.97,159.7 Q11.3
N16865822: length 2.4
  TOP w0.254: v1(178.05,154.05) 178.77,153.34 D5.2
  BOTTOM w0.254: v1(178.05,154.05) 178.56,153.54 178.82,153.54
N16865834: length 4.5
  TOP w0.254: Q3.3 177.1,157.93 179.2,155.82 D5.1
N16865898: length 4.1
  TOP w0.254: R31.2 175.99,159.02 v1(176.02,158.98)
  BOTTOM w0.254: v1(176.02,158.98) 176.05,158.98 176.95,158.08 177.74,158.08 178.05,157.76 Q11.1
N16869469: length 2.1
  TOP w0.254: R213.1 42.16,120.02 42.8,120.65 43.5,121.35 C113.1
N16870184: length 1.3
  TOP w0.305: R207.1 C108.1
N16870591: length 1.5
  TOP w0.254: R305.1 84.46,111.44 C169.1
N16876414: length 4.3
  TOP w0.254: U23.22 16.76,103.12 17.14,103.5 17.14,104.33 C181.2
N16969569: length 8.1
  TOP w0.254: Q2.8 108.33,165.81 v1(108.28,165.86) ; R23.2 104.08,167.81 104.7,168.43 v1(104.95,168.43)
  BOTTOM w0.254: v1(108.28,165.86) 108.33,165.91 R481.1 108.33,166.9 106.81,168.43 v1(104.95,168.43)
N16996048: length 1.6
  TOP w0.254: Q2.7 108.83,166.05 108.78,166.1 C18.1
N17000861:
  vias: v1(123.34,174.57) v1(123.32,173.36)
N17007218: length 37.2
  L8 w0.508: v3(12.6,114.3) 25.28,114.3 25.91,114.93 25.91,116.64 25.5,117.05 13.89,117.05 13.5,117.44 J1.C2
  BOTTOM w0.508: v3(12.6,114.3) 12.6,110.39 13.83,109.16 R549.1
N17260565: length 1.4
  TOP w0.127: R32.1 C32.1
N17261802: length 2.8
  TOP w0.254: R218.1 124.41,124.6 U13.44
N17515515: length 18.8
  TOP w0.254: U8.37 119.1,141.76 118.72,141.38 C61.2 118.72,140.26 118.66,140.26 117.06,138.66 114.99,138.66 111.51,142.14 111.51,143.45 R93.1 112.78,144.72 114.48,144.72 114.86,144.35 115.62,144.35 115.72,144.45 U8.30
N17759045: length 2
  BOTTOM w0.127: U53.21 102.69,129.23 103.07,129.61 R568.1
N17761475: length 19.8
  TOP w0.508: DC_IN1.1 18.9,43.94 ; DC_IN1.1 14.38,43.94 ; DC_IN1.1 14.38,45.97 ; DC_IN1.1 18.9,45.97
  BOTTOM w0.508: DC_IN1.1 18.9,43.94 ; DC_IN1.1 18.9,45.97 ; DC_IN1.1 14.38,43.94 ; DC_IN1.1 14.38,45.97
  vias: v3(13.72,44.96) v3(13.72,44.07) v3(15.27,46.48) v3(16,46.48) v3(18.29,46.61) v3(19.43,46.61)
N18200913: length 4.8
  BOTTOM w0.254: PHY1.M9 150.21,69.03 R796.2
N18201367: length 5.8
  BOTTOM w0.254: PHY2.M9 149.14,93.17 151,91.31 151,90.75 R797.2
N18454569: length 2.2
  TOP w0.279: U44.5 127.5,36.69 127.13,36.32 R468.2
N18458097: length 1.4
  TOP w0.127: C796.1 R798.1
N18489905: length 2.5
  BOTTOM w0.127: U53.8 92.97,129.23 R801.1
N18495173: length 7.6
  TOP w0.254: OSC3.4 49.45,119.17 48.9,118.62 C163.1 C162.2 46.42,120.52 45.97,120.97 B25.3
N18495232: length 5.9
  TOP w0.254: OSC3.1 48.75,117.2 47.24,117.2 47.07,117.37 R260.2 C135.2 R261.1
N18495910: length 1.9
  TOP w0.356: U61.5 130.02,70.38 C800.1
N18495926: length 1.1
  TOP w0.356: U29.2 130.75,68.6 130.91,68.76
N18628275: length 3.8
  TOP w0.279: 127.46,169.88 127.87,169.47 U2.7
  TOP w0.508: 127.46,169.88 127.09,170.24 R14.1 R13.2
N18719819: length 1.3
  TOP w0.381: U24.AB13 70.52,89.54 v2(70.87,89.89)
  BOTTOM w0.381: v2(70.87,89.89) 70.87,89.84 71.3,89.41 B48.1
N18899244: length 17.9
  BOTTOM w0.102: NAND1.G5 39.05,158.24 39.4,157.89 39.4,155.47 38.86,154.94 38.86,152.59
  BOTTOM w0.127: 38.86,152.59 38.86,151.64 39.5,151 43.01,151 44.9,149.11 44.9,147.46 R804.1 R805.2
N19339535: length 3.6
  TOP w0.102: U43.L8 95.24,40.11 v2(95.63,40.5)
  BOTTOM w0.102: v2(95.63,40.5) 95.23,40.11 93.38,40.11 R777.2
N19350255: length 2.9
  TOP w0.102: v2(60.58,40.5) 60.19,40.11 U40.L8
  BOTTOM w0.127: v2(60.58,40.5) 61.27,39.81 R784.2
N19351108: length 3.1
  TOP w0.102: U39.L8 48.52,40.1 v2(48.92,40.5)
  BOTTOM w0.102: R771.2 47.12,41.4 47.62,40.89 48.53,40.89 v2(48.92,40.5)
N19356481: length 3.9
  TOP w0.102: U42.L8 83.55,40.11 v2(83.95,40.5)
  BOTTOM w0.127: v2(83.95,40.5) 83.95,40.64 84.33,41.02 86.68,41.02 R776.2
N19359494: length 4.1
  TOP w0.102: U41.C7 v2(71.42,46.1)
  BOTTOM w0.102: v2(71.42,46.1) 71.83,45.69 71.83,45.18 72.8,44.21 73.27,44.21 73.51,44.45 R758.1
N19359500: length 3.4
  TOP w0.102: U41.B7 v2(71.42,47.7)
  BOTTOM w0.102: v2(71.42,47.7) 71.8,48.09 73.17,48.09
  BOTTOM w0.127: R745.1 73.79,48.7 73.18,48.09 73.17,48.09
N19359630: length 2.1
  TOP w0.102: v2(68.28,46.29) 68.28,45.79 68.19,45.7 U41.D3
  BOTTOM w0.102: R754.1 68.03,46.04 v2(68.28,46.29)
N19359646: length 2.3
  TOP w0.102: U41.L8 71.82,40.11 72.21,40.5 v2(72.21,40.51)
  BOTTOM w0.127: v2(72.21,40.51) 72.33,40.39 R778.2
N19643635: length 11.6
  BOTTOM w0.127: U50.21 111.25,153.49 112.37,154.61 112.37,158.47 111.51,159.33 R812.1
N20001256: length 9.4
  BOTTOM w0.127: R814.1 153.55,104.84 U59.4 155.38,104.84 156.21,104.01 156.77,104.01 157.48,103.3 157.48,102.69 157.96,102.21 158.67,102.21 159.3,101.59 U70.4 159.31,101.23 R813.2
N20002440: length 1.7
  TOP w0.508: C9.1 R17.2
N36253337: length 4.2
  TOP w0.254: R280.2 143.37,110.93 R281.2 144.27,112.4 143.58,113.09 Q7.3
N36291863: length 5.2
  TOP w0.254: R283.2 R284.1 151.47,111.57 150.31,112.73 Q8.3
N39781722: length 5
  BOTTOM w0.102: PHY2.K2 147.14,101.95 146.76,102.33 146.76,103.49
  BOTTOM w0.127: 146.76,103.49 146.76,105.74 TP61.1
N41034021: length 5
  TOP w0.254: 138.59,61.74 138.71,61.62 138.94,61.62 139.09,61.78 U31.7 ; 138.59,61.74 U31.8 ; 138.59,61.74 138.59,61.73 138.43,61.57 137.51,61.57 C325.2 R403.1
N43929945: length 2.9
  TOP w0.127: U18.12 155.88,110.82 155.63,110.56 155.23,110.56 155.2,110.53 154.53,110.53 R290.2
N43929982: length 6.2
  TOP w0.127: C130.2 158.88,118.8 158.88,116.87 158.23,116.22 157.6,116.22 157.19,116.64 U18.3
N43929984: length 2.8
  TOP w0.127: U18.5 155.88,119.17 155.99,119.28 155.99,119.79 C128.2
N43929986: length 1.7
  TOP w0.127: U18.6 155.23,119.22 C128.1
N43930002: length 2.9
  TOP w0.127: U18.2 157.84,118.49 157.48,118.85 157.48,119.7 C129.2
N43930004: length 1.7
  TOP w0.127: U18.4 156.54,119.13 C129.1
N43930022: length 1.8
  TOP w0.127: U18.7 154.58,119.03 C127.2
N43930050: length 1.7
  TOP w0.127: R291.2 158.49,110.29 U18.16
N44510146:
  vias: v3(131.11,173.41) v3(131.98,173.41)
N44510176: length 2.6
  TOP w0.279: C22.1 132.65,166.03 131.71,166.97 U2.13
N44510178: length 1.7
  TOP w0.254: U2.1 132.51,169.47 133.01,169.97 R15.2
N44510240: length 2.3
  TOP w0.279: U2.8 127.71,167.97 127.44,167.7
  TOP w0.508: 127.44,167.7 126.75,167 R22.1
N44510256: length 1.8
  TOP w0.508: R22.2 C14.1
N44510258: length 1.4
  TOP w0.254: v1(128.46,166.97) U2.9
  BOTTOM w0.254: C391.1 128.42,167 v1(128.46,166.97)
N56424980: length 7.5
  TOP w0.508: R431.1 18.09,49.6 18.42,49.27 18.42,49.25 19.05,48.63 R434.2 17.39,48.2 C351.2 17.08,48.13 14.24,48.13 Q19.4
N56425114: length 1.4
  TOP w0.381: R435.1 23.02,48.49 D8.1
N56425122: length 4.2
  TOP w0.254: R431.2 18.99,50.62 19.7,51.33 v1(20.19,51.33)
  BOTTOM w0.254: Q20.3 20.41,51.1 v1(20.19,51.33)
N56425140: length 11
  TOP w0.381: R436.2 v1(21.28,45.72) ; Q9.3 25.4,50.22 R427.1 25.2,50.42 25.15,50.42 v1(24.38,51.18)
  BOTTOM w0.381: v1(21.28,45.72) 21.53,45.97 C745.1 21.53,48.26 21.97,48.71 21.97,50.16 22.41,50.61 Q20.1 23.81,50.61 v1(24.38,51.18)
N56425144: length 3.6
  TOP w0.381: Q9.1 24.45,46.92 24.2,47.17 R435.2 R437.1
N59999809: length 1.7
  BOTTOM w0.127: U58.8 133.79,104.39 R611.2
N60785066: length 4.4
  BOTTOM w0.102: PHY2.A6 137.15,97.49
  BOTTOM w0.127: 137.15,97.49 137.12,97.49 134.87,95.25 R634.1
N60785068: length 3.6
  BOTTOM w0.102: 137.15,98.49 PHY2.A5
  BOTTOM w0.127: R627.1 134.93,98.04 135.38,98.49 137.15,98.49
N60820080: length 3.9
  TOP w0.102: v2(68.28,46.93) 68.24,46.93 U41.C3
  BOTTOM w0.127: R749.2 65.33,47.28 67.56,47.28 67.9,46.93 v2(68.28,46.93)
N60820095: length 3.3
  TOP w0.102: U41.C8 v2(71.42,46.9)
  BOTTOM w0.102: 73.17,46.35 71.97,46.35 v2(71.42,46.9)
  BOTTOM w0.127: R752.2 73.42,46.35 73.17,46.35
N60820110: length 1.6
  TOP w0.102: U41.A7 70.78,48.1 v2(70.43,48.45)
  BOTTOM w0.102: R747.2 70.63,48.26 v2(70.43,48.45)
N60820114: length 1.9
  TOP w0.102: v2(66.62,48.5) 67.02,48.11 U41.A2
  BOTTOM w0.102: 66.88,48.77 v2(66.62,48.5)
  BOTTOM w0.127: 66.88,48.77 67.13,49.02 R744.2
N60820127: length 3.2
  TOP w0.102: v2(67.4,46.88) U41.C2
  BOTTOM w0.127: R753.2 65.74,45.72 66.9,46.88 v2(67.4,46.88)
N60820155: length 1.6
  TOP w0.102: v2(67.42,48.5) 67.82,48.11 U41.A3
  BOTTOM w0.102: R746.2 67.5,48.58 v2(67.42,48.5)
N60820166: length 2.3
  TOP w0.102: v2(72.26,46.91) 72.21,46.91 U41.B8
  BOTTOM w0.102: v2(72.26,46.91) 72.26,46.95 72.6,47.28 73.17,47.28
  BOTTOM w0.127: R748.2 73.71,47.28 73.17,47.28
N63574595: length 3.2
  TOP w0.254: R326.1 R325.2 133.53,99.69 EEPROM1.2
N63574605: length 3.1
  TOP w0.254: EEPROM1.3 133.32,100.97 133.45,100.84 R323.2 R322.1
N65094088: length 1.5
  TOP w0.127: C60.2 60.32,142.68
  TOP w0.508: 60.32,142.68 R117.1
N65094092: length 2.8
  TOP w0.279: U10.5 57.34,144.23 57.53,144.42 58.5,144.42
  TOP w0.381: 58.5,144.42 58.8,144.12 R117.2
N65094154: length 2.1
  TOP w0.254: R106.1 49.75,144.23 U10.28
N65094220: length 4.3
  TOP w0.254: v1(52.45,139.45) 52.72,139.17 R135.2
  BOTTOM w0.254: R551.2 C434.1 52.27,140.34 R553.1 52.01,139.88 v1(52.45,139.45)
N65832500: length 5.3
  TOP w0.381: GPS1.E1 144.82,38.01 143.58,36.77 R471.2 C382.2
N66015127: length 2.8
  TOP w0.381: C370.2 C375.1 L11.1
N66015725: length 6.1
  TOP w0.508: 175.19,40.71 CN18.1 ; CN18.1 178.5,40.71 ; CN18.1 177.1,42.11 ; CN18.1 177.1,39.31
N66065896: length 2.6
  TOP w0.381: R419.2 153.18,52.3 SIM1.SW1
N66414815: length 2.9
  TOP w0.102: GPS1.C2 v2(148.57,41.99)
  BOTTOM w0.102: v2(148.57,41.99) 147.85,41.27 TP95.1
N67021867: length 5
  TOP w0.127: v1(138.84,154.08) 138.84,154.41 137.61,155.63 U5.6
  BOTTOM w0.127: U49.32 137.68,153.71 137.81,153.58 138.34,153.58 v1(138.84,154.08)
N67021870: length 2.4
  TOP w0.127: U5.4 137.84,156.93 v1(138.05,157.14)
  BOTTOM w0.127: v1(138.05,157.14) 137.98,157.21 U49.39
N67021873: length 4.4
  TOP w0.127: U5.1 135.61,158.88 v1(134.95,159.54)
  BOTTOM w0.127: v1(134.95,159.54) 135.62,160.21 U49.45
N67021879: length 4.3
  TOP w0.127: v1(138.1,159.61) 138.1,157.91 137.77,157.58 U5.3
  BOTTOM w0.127: U49.44 138.01,159.71 v1(138.1,159.61)
N67021882: length 1.7
  BOTTOM w0.254: U49.31 135.89,153.21 135.81,153.29 R511.1
N67021897: length 1.9
  BOTTOM w0.127: U49.26 135.88,150.71 R519.1
N67022560: length 1.8
  TOP w0.127: R48.2 135.46,153.03 U5.10
N68010936: length 1.7
  TOP w0.127: R402.2 124.79,59.43 U32.11
N68010938: length 2.1
  TOP w0.127: R401.2 124.53,60.81 125.26,60.08 U32.10
N68025719: length 2.2
  TOP w0.127: U7.31 152.46,137.79 R130.1
N68025736: length 3.7
  TOP w0.127: R131.1 149.77,136.92 151.27,138.43 151.69,138.43 151.96,138.7 U7.30
N68027970: length 4.6
  TOP w0.127: SW1.8 101.6,167.51 v1(101.09,168.02)
  BOTTOM w0.127: v1(101.09,168.02) 101.6,168.53 R476.2
N68027994: length 4.1
  TOP w0.127: SW1.7 v1(99.06,168.28)
  BOTTOM w0.127: v1(99.06,168.28) R475.2
N68028184: length 5.4
  TOP w0.127: SW1.6 96.52,169.29 97.34,170.11 v1(97.41,170.11)
  BOTTOM w0.127: v1(97.41,170.11) R474.2
N68028192: length 5.2
  TOP w0.127: v1(94.74,170.11) 93.98,169.35 SW1.5
  BOTTOM w0.127: v1(94.74,170.11) R473.2
N68035165: length 36.8
  TOP w0.279: U7.38 155.96,137.48 C72.1 ; v1(157.05,152.53) 155.96,153.62 U7.88 ; v1(149.73,150.62) 149.3,150.19 U7.7
  TOP w0.381: v1(155.32,137.92) 155.32,137.79 155.76,137.36 C72.1
  L8 w0.381: v1(157.05,152.53) 157.05,152.02 158.62,150.45 158.62,150.37 158.65,150.34 158.65,148.08 161.19,145.54 161.19,142.38 160.79,141.99 159.38,141.99 v1(155.32,137.92)
  BOTTOM w0.381: C415.2 149.55,150.81 v1(149.73,150.62) 153.61,150.62 155.26,152.27 155.26,152.28 155.57,152.6 C414.2 156.98,152.6 v1(157.05,152.53)
N68049827: length 2.6
  TOP w0.127: TP32.1 65.5,130.84 U15.45
N68049869: length 4.1
  TOP w0.127: U15.6 62.19,125.32 60.47,127.05 R265.1
N68049909: length 2.5
  TOP w0.254: U15.40 68,130.07 68.07,130.15 C108.2
N68057675: length 3
  TOP w0.127: R252.1 49.7,125.51 49.7,126.33 50.23,126.86 U14.1
N68057679: length 4.4
  TOP w0.127: U14.45 49,129.51 48.53,129.03 48.53,128.73 48.27,128.48 48.27,126.91 48.39,126.79 48.39,126.03 TP35.1
N68057721: length 2.9
  TOP w0.127: U14.6 52.73,125.88 51.82,124.97 R253.1
N68057761: length 13.7
  TOP w0.254: C113.2 43.56,123.57 44.08,124.09 44.52,124.09 44.82,124.4 47.11,124.4 47.43,124.73 47.43,125.41 47.35,125.5 47.35,126.16 47.35,126.16 47.35,126.42 47.45,126.52 47.45,128.82 47.56,128.93 47.56,131.13 48.44,132.01 U14.40
N68057795: length 4.6
  TOP w0.127: R235.1 49.02,125.32 49.26,125.56 49.26,126.42 49.26,126.64 48.78,127.12 48.78,128.27 49.02,128.51 U14.47
N68067792: length 11.1
  TOP w0.127: U15.1 63.25,128.89 61.97,130.17 61.97,132.09 61.34,132.72 60.33,132.72 59.56,131.95 59.56,130.18 60.47,129.27 R264.1
N68067794: length 1.7
  TOP w0.127: R225.1 64.5,129.74 U15.47
N68073129: length 1.6
  TOP w0.127: v1(163.73,140.46) 163.78,140.51 U7.51
  BOTTOM w0.127: v1(163.73,140.46) 163.3,140.02 R546.2
N151708088: length 2.3
  TOP w0.254: TP33.1 118.22,123.21 U16.38
N151794428: length 3.9
  TOP w0.254: TP45.1 28.96,87.65 28.67,87.37 28.67,86.74 28.55,86.62 U25.38
N1517080885: length 4.3
  TOP w0.127: U16.10 104,123.71 TP31.1
N1517944285: length 1.5
  TOP w0.127: TP48.1 28.06,75.45 U25.10
N1627346115: length 1.7
  TOP w0.305: R298.1 27.12,107.2 U20.9

## Copper pours and planes (outline as drawn)
AVCC2V5A on TOP (solid shape): 152.27,78.48 152.27,77.41 151.74,76.87 151.73,76.87 151.52,76.73 151.39,76.53 151.39,76.52 151.19,76.33 151.19,70.28 149.45,68.53 140.77,68.53 138.91,70.39 138.93,70.43 138.86,70.85 138.44,70.86 138.18,71.12 138.18,72.64 138.56,73.03 138.94,73.03 139.32,72.65 139.32,72.62 139.41,72.37 139.67,72.27 139.69,72.27 141.6,70.36 146.42,70.36 146.64,70.27 146.87,70.36 147.83,70.36 149.35,71.88 149.35,73.55 149.48,73.69 149.52,73.87 149.52,74.24 149.52,74.26 149.46,74.4 149.35,74.51 149.35,76.7 149.99,77.34 149.99,78.61 150.24,78.86 151.89,78.86
AVCC2V5A on L5: 149.61,78.99 152.27,78.99 152.78,78.49 152.78,68.83 150.88,66.93 138.3,66.93 136.91,68.33 136.91,72.77 137.16,73.03 138.68,73.03 139.06,72.64 139.06,72.01 141.48,69.6 147.83,69.6 149.1,70.87 149.1,78.49
AVCC2V5B on TOP (solid shape): 152.27,103.12 152.27,102.24 151.51,101.47 151.51,95.25 149.38,93.12 141.07,93.12 140.44,93.75 140.43,93.77 140.33,93.98 140.12,94.08 140.11,94.08 138.3,95.88 138.3,97.03 138.56,97.28 139.32,97.28 139.39,97.21 139.37,97.17 139.41,96.76 139.83,96.72 139.86,96.74 141.94,94.67 142.16,94.67 142.21,94.62 147.78,94.62 149.35,96.19 149.35,97.95 149.48,98.08 149.52,98.26 149.52,98.63 149.52,98.65 149.46,98.8 149.35,98.9 149.35,101.09 150.11,101.85 150.11,103.12 150.24,103.25 152.15,103.25
AVCC2V5B on L5 (solid shape): outline of 253 points within 148.08,93.85 152.53,103.25
AVDDA1 on BOTTOM: 66.65,114.02 67.72,114.02 68.22,113.51 69.27,113.51 69.44,113.33 69.44,112.55 69.14,112.24 67.94,112.24 67.36,112.83 67.13,112.83 66.5,113.46 66.5,113.87
AVDDA1 on L10: 64.77,104.65 65.41,104.01 65.41,91.31 65.66,91.06 68.33,91.06 68.71,91.44 68.71,112.65 68.33,113.03 67.44,113.03 66.8,112.4 65.02,112.4 64.77,112.14
AVDDA4 on TOP: 40.38,71.25 39.6,71.25 39.33,70.99 39.33,69.65 39.55,69.43 39.55,69 39.54,68.99 39.54,67.16 39.69,67.01 41.08,67.01 41.39,67.32 41.39,69.58 41.39,69.58 41.39,70.24
AVDDA4 on L3: 65.71,74.65 64.7,74.65 63.42,75.94 49.86,75.94 49.1,75.18 49.1,74.09 48.28,73.27 46.45,73.27 44.94,71.76 40.24,71.76 39.91,71.43 39.91,68.98 45.7,68.98 47.85,71.13 57.27,71.13 57.29,71.15 58.3,71.15 58.72,71.57 58.72,72 58.9,72.18 65.61,72.18 66.01,72.57 66.01,74.35
AVDDAHV on TOP: 39.75,54.1 40.01,54.36 40.01,55.88 39.75,56.13 37.21,56.13 36.83,55.75 36.83,54.36 37.08,54.1
AVDDAHV on L8: 40.61,61.09 47.5,61.09 50.99,64.58 50.99,86.17 54.1,89.28 58.8,89.28 60.83,91.31 60.83,92.35 62.1,93.62 63.3,93.62 63.65,93.27 63.65,86.89 62.48,85.72 62.48,78.23 62.99,77.72 63.02,77.72 63.65,77.09 63.65,72.03 60.96,69.34 59.69,69.34 58.8,68.45 58.8,65.58 58.78,65.56 58.78,64.87 57.91,64.01 54.74,64.01 49.78,59.05 47.93,59.05 47.29,58.42 43.66,58.42 39.85,54.61 37.9,54.61 37.57,54.94 37.57,58.04 ; 2 cut-outs
AVDDALV on BOTTOM: 33.4,85.72 37.34,85.72 39.5,83.57 39.5,82.3 39.62,82.17 39.62,81.66 39.5,81.53 37.97,81.53 36.45,83.06 33.78,83.06 33.02,83.82 33.02,85.34
AVDDALV on BOTTOM: 63.12,91.69 66.19,91.69 66.8,91.08 66.8,88.75 66.55,88.49 66.55,87 66.73,86.82 67.21,86.82 67.34,86.69 67.34,86.23 67.21,86.11 66.78,86.11 66.55,85.88 66.55,79.78 66.24,79.48 65.76,79.48 65.58,79.3 65.58,78.33 64.99,77.74 63.92,77.74 63.47,78.18 63.47,79.45 63.32,79.6 62.51,79.6 62.36,79.76 62.36,90.93
AVDDALV on L5: 64.39,79.63 64.26,79.5 62.74,79.5 62.36,79.12 54.1,79.12 53.59,79.63 48.01,79.63 47.88,79.76 47.88,85.85 48.26,86.23 52.2,86.23 52.58,86.61 64.39,86.61 64.52,86.49 66.67,86.49 67.69,85.47 67.69,81.28 66.04,79.63 ; 2 cut-outs
AVDDALV on L8: 38.73,83.82 39.37,83.82 39.5,83.69 39.5,82.3 40.34,81.46 40.34,80.57 43.05,77.85 45.59,77.85 46.48,78.74 46.48,81.03 46.99,81.53 48.39,81.53 48.51,81.41 48.51,77.6 47.24,76.33 42.16,76.33 38.81,79.68 38.81,80.82 37.97,81.66 37.97,83.06
GND on L3 (solid shape): 150.5,88.9 150.5,86.36 149.99,85.85 144.91,85.85 144.53,86.23 144.53,88.9 144.91,89.28 150.11,89.28
GND on L5 (solid shape): 150.5,88.9 150.5,86.36 149.99,85.85 144.91,85.85 144.53,86.23 144.53,88.9 144.91,89.28 150.11,89.28
GND on L8 (solid shape): 150.5,88.9 150.5,86.36 149.99,85.85 144.91,85.85 144.53,86.23 144.53,88.9 144.91,89.28 150.11,89.28
GND on TOP: 68.83,127.1 68.83,123.04 68.76,122.96 64.77,122.96 64.67,123.06 64.67,127.08 64.77,127.18 68.76,127.18
GND on TOP: 137.79,136.65 137.67,136.78 137.67,140.59 136.78,141.48 136.4,141.48 135.84,142.04 135.84,150.22 135.36,150.7 130.51,150.7 128.89,149.09 128.89,137.93 128.5,137.54 125.43,137.54 125.27,137.69 125.27,141.15 126.24,142.11 126.85,142.11 127.56,142.82 127.56,149.1 126.8,149.86 121.34,149.86 120.52,149.05 120.52,143.56 120.4,143.43 117.3,143.43 117.2,143.54 117.2,148.97 116.94,149.22 116.94,150.06 116.52,150.48 114,150.48 113.77,150.26 111.72,150.26 111.3,150.67 111.3,152.93 111.58,153.21 121.74,153.21 123.55,151.4 127.71,151.4 128.55,152.25 128.55,157.33 128.8,157.58 132.31,157.58 132.75,157.14 132.75,155.08 133.76,154.08 133.76,152.65 134.39,152.02 136.58,152.02 137.79,150.8 137.79,144.91 139.45,143.26 139.45,136.91 139.19,136.65
GND on TOP: 74.3,141.55 74.3,139.19 74.22,139.12 73.25,139.12 73.05,139.32 71.65,139.32 71.4,139.06 70.33,139.06 70.24,139.15 70.24,141.24 70.92,141.91 70.93,141.9 73.95,141.9
GND on TOP: 160.4,120.5 161.49,120.5 161.87,120.12 161.87,117.45 161.49,117.07 160.35,117.07 159.84,117.58 159.84,119.94
GND on TOP: 30.51,91.34 27.08,91.34 27.03,91.29 21.39,91.29 19.46,93.22 19.46,94.59 19.1,94.95 19.1,95.94 18.87,96.16 16.46,96.16 16.18,96.44 16.18,97.36 16.31,97.49 21.41,97.49 21.54,97.36 21.54,93.01 21.95,92.61 25.1,92.61 25.58,93.09 25.58,103.89 25.07,104.39 21.92,104.39 21.48,103.96 21.48,100.48 20.35,99.34 16.36,99.34 16.15,99.54 16.15,100.51 16.38,100.74 18.8,100.74 19.08,101.02 19.08,101.88 19.3,102.11 19.3,102.62 19.96,103.28 19.96,105.03 20.09,105.16 20.9,105.16 21.59,105.84 34.48,105.84 34.8,105.52 34.8,104.78 34.67,104.65 32.99,104.65 32.62,104.28 27.8,104.28 27.51,103.99 27.51,100.08 27.91,99.67 30.61,99.67 30.63,99.69 35.05,99.69 35.31,99.44 35.31,97.28 34.92,96.9 27.81,96.9 27.51,96.6 27.51,92.51 27.81,92.2 28.45,92.2 28.5,92.15 31.65,92.15 31.66,92.14 34.61,92.14 35.18,91.57 35.18,90.93 35.43,90.68 35.43,89.66 35.31,89.53 32.31,89.53
GND on TOP: 59.79,136.45 59.66,136.58 59.66,139.88 59.49,140.06 59.49,141.39 59.68,141.58 60.48,141.58 62.07,143.18 62.51,143.18 62.51,143.18 63.3,143.18 64.41,144.3 64.41,149.2 63.91,149.71 57.84,149.71 55.91,147.78 55.91,142.34 55.85,142.29 52.63,142.29 52.5,142.42 52.5,147.8 51.79,148.51 47.66,148.51 47.18,148.99 47.18,150.09 48.1,151 74.1,151 74.48,150.62 74.48,147.24 73.76,146.52 73.76,142.72 73.25,142.21 72.29,142.21 71.94,142.56 71.94,150.27 71.74,150.47 66.47,150.47 65.63,149.63 65.63,141.33 64.95,140.64 64.95,137.24 64.16,136.45
GND on TOP: 108.2,172.57 108.2,171.88 108.25,171.83 108.81,171.83 108.94,171.7 108.94,171.2 108.97,171.17 111,171.17 111.02,171.2 111.02,171.68 111.15,171.81 111.73,171.81 111.76,171.83 111.76,172.62 111.73,172.64 111.12,172.64 111.02,172.75 111.02,173.18 110.95,173.25 108.99,173.25 108.94,173.2 108.94,172.72 108.81,172.59 108.23,172.59
GND on TOP: 71.88,130.51 71.88,128.4 72.09,128.19 73,128.19 73.13,128.32 73.13,128.5 73.15,128.52 74.52,128.52 74.6,128.45 74.6,128.35 74.75,128.19 75.79,128.19 75.92,128.32 75.92,130.45 75.64,130.73 72.11,130.73
GND on TOP: 145.54,61.72 145.52,61.75 144.04,61.75 144.02,61.72 144.02,60.22 144.04,60.2 145.52,60.2 145.54,60.22
GND on TOP: 46.35,139.57 46.1,139.83 46.1,142.11 45.97,142.24 44.7,142.24 44.58,142.11 42.8,142.11 42.67,142.24 42.67,143.64 46.99,143.64 48.51,142.11 48.51,139.57
GND on TOP: 13.59,42.16 18.8,42.16 21.08,44.45 22.48,44.45 22.49,44.44 22.87,44.44 23.86,43.45 23.86,36.31 21.84,34.29 21.84,32.38 20.83,31.37 13.84,31.37 13.21,32 13.21,41.78
GND on TOP: 42.55,132.21 44.32,132.21 44.45,132.08 44.45,129.29 44.32,129.16 42.55,129.16 42.42,129.29 42.42,132.08
GND on TOP: 90.91,120.62 90.91,116.64 90.88,116.61 86.84,116.61 86.82,116.64 86.82,120.57 86.92,120.68 90.86,120.68
GND on TOP: 125.63,113.61 131.88,113.61 132.13,113.36 132.13,109.91 131.8,109.58 125.55,109.58 125.37,109.75 125.37,113.36
GND on TOP: 132.87,71.25 132.49,70.87 132.49,68.68 131.9,68.1 131.9,65.3 132.18,65.02 134.26,65.02 134.72,65.48 134.72,70.97 134.54,71.15 133.2,71.15 133.1,71.25
GND on TOP: 158.72,136.02 163.96,136.02 164.24,135.74 164.24,132.66 163.93,132.36 158.57,132.36 158.34,132.59 158.34,135.64
GND on TOP: 120.52,170.31 123.06,170.31 123.44,169.93 123.44,167.26 123.19,167 120.4,167 120.14,167.26 120.14,169.93
GND on TOP: 111.63,159.64 115.06,159.64 115.82,158.88 115.82,154.69 115.32,154.18 111.63,154.18 111.12,154.69 111.12,159.13
GND on TOP: 50.83,132.84 55.02,132.84 55.07,132.79 55.07,128.75 55.04,128.73 50.88,128.73 50.77,128.83 50.77,132.79
GND on TOP: 118.36,170.56 118.62,170.31 118.62,169.04 118.36,168.78 113.92,168.78 113.67,169.04 113.67,170.31 113.92,170.56
GND on TOP: 19.51,90.5 19.79,90.22 19.79,88.29 19.43,87.93 13.34,87.93 13.01,87.61 13.01,87.45 12.52,86.96 11.75,86.96 11.37,87.33 10.6,87.33 10.27,87.66 10.27,89.52 11.25,90.5
GND on TOP: 71.78,126.03 71.78,123.8 71.91,123.67 76.56,123.67 76.83,123.95 76.83,125.98 76.58,126.24 74.63,126.24 74.47,126.09 74.47,125.81 74.42,125.76 73.38,125.76 73.28,125.86 73.28,126.09 71.83,126.09
GND on TOP: 18.97,71.5 19.23,71.75 22.61,71.75 24,73.15 24,73.53 23.88,73.66 20.37,73.66 19.84,73.13 16.61,73.13 15.93,72.44 15.93,70.51 16.41,70.03 18.39,70.03 18.97,70.61
GND on TOP: 109,76.34 108.62,75.96 107.22,75.96 106.46,76.72 106.46,84.21 107.1,84.85 108.75,84.85 109,84.59
GND on TOP: 124.24,48.65 131.99,48.65 132.24,48.4 132.24,44.33 131.99,44.08 127.16,44.08 127.04,44.21 127.04,47.25 126.78,47.51 124.12,47.51 123.99,47.63 123.99,48.4
GND on TOP: 108.69,120.7 108.48,120.9 108.48,124.38 108.31,124.56 107.19,124.56 107.14,124.61 107.14,124.84 107.19,124.89 108.36,124.89 108.48,125.02 108.48,127.84 108.23,128.09 108.23,129.44 108.31,129.51 108.48,129.51 108.56,129.44 108.56,128.4 109.4,127.56 114.81,127.56 115.72,128.47 115.72,129.54 116,129.82 119.53,129.82 120.42,128.93 120.42,128.32 120.24,128.14 119.76,128.14 118.8,129.11 117.93,129.11 117.25,128.42 117.25,128.22 117.09,128.07 116.15,128.07 115.8,127.71 115.8,126.01 115.95,125.86 117.07,125.86 117.14,125.78 117.14,125.65 117.07,125.58 115.93,125.58 115.8,125.45 115.8,121.16 115.34,120.7 113.26,120.7 113.03,120.47 113.03,119.13 113.23,118.92 113.23,118.69 113.11,118.57 112.85,118.57 112.75,118.67 112.75,120.47 112.52,120.7
GND on TOP: 23.88,78.31 23.88,84.48 23.39,84.96 22.15,84.96 21.31,85.8 21.31,86.39 20.42,87.27 20.17,87.27 20.04,87.4 20.04,87.93 20.88,88.77 20.88,89.41 21.03,89.56 21.67,89.56 21.77,89.46 21.77,88.87 20.95,88.06 20.95,87.48 21.62,86.82 23.16,86.82 23.72,86.26 23.72,85.09 24.23,84.58 25.65,84.58 25.91,84.84 25.91,86.28 25.96,86.33 26.16,86.33 26.21,86.28 26.21,84.84 26.47,84.58 30.35,84.58 30.61,84.33 30.61,82.37 30.76,82.22 30.76,82.19 32.41,82.19 32.61,82.4 32.84,82.4 32.99,82.25 32.99,82.07 32.82,81.89 30.78,81.89 30.61,81.71 30.61,78.97 29.24,77.6 27.33,77.6 27.2,77.47 27.2,76.33 27.15,76.28 26.95,76.28 26.9,76.33 26.9,77.47 26.77,77.6 24,77.6 23.75,77.34 22.81,77.34 22.35,76.89 22.35,76.61 22.12,76.38 21.72,76.38 21.54,76.56 21.54,77.01 22.28,77.75 23.32,77.75
GND on TOP: 101.22,47.17 100.94,46.89 99.42,46.89 99.19,47.12 99.19,50.16 99.44,50.42 100.97,50.42 101.22,50.16
GND on TOP: 144.45,116.23 145.14,116.92 148.06,116.92 148.69,116.28 152.12,116.28 152.2,116.21 152.2,114.78 152.07,114.66 147.7,114.66 147.22,114.17 147.19,114.2 145.9,114.2 145.41,114.68 140.94,114.68 140.39,114.12 139.22,114.12 138.94,114.4 138.94,116.64 139.09,116.79 140.72,116.79 141.27,116.23
GND on TOP: 104.65,30.99 104.17,31.47 104.17,35.59 104.44,35.86 106.73,35.86 107.72,36.86 107.72,41.09 108,41.36 108,42.77 108.15,42.92 110.26,42.92 110.39,42.8 110.39,32.21 110.39,32.18 110.87,31.7 115.82,31.7 115.98,31.85 118.08,31.85 118.49,32.26 118.49,38.99 117.22,40.26 117.22,42.55 117.42,42.75 120.5,42.75 120.9,42.34 120.9,39.75 120.27,39.12 120.27,32.89 121.47,31.7 127.17,31.7 127.19,31.71 127.5,31.71 128.75,32.97 128.75,38.58 128.91,38.73 132.13,38.73 132.28,38.58 132.28,33.12 132.64,32.77 138.25,32.77 138.56,32.46 138.56,31.24 138.3,30.99
GND on TOP: 47.75,122.3 57.02,122.3 57.15,122.17 57.15,120.27 57.4,120.02 57.4,114.94 57.15,114.68 47.75,114.68 47.5,114.94 47.5,122.05
GND on TOP: 157.86,46.99 154.94,46.99 154.31,46.36 154.31,44.45 154.43,44.32 157.23,44.32 158.12,45.21 158.12,46.74
GND on TOP: 74.27,144.81 76.91,144.81 77.14,144.58 77.14,142.75 76.91,142.52 76.58,142.52 76.05,143.05 74.17,143.05 74.09,143.13 74.09,144.63
GND on TOP: 165.86,160.3 165.86,157 165.58,156.72 160.25,156.72 159.92,157.05 159.92,160.35 160.17,160.6 165.56,160.6
GND on TOP: 85.34,132.08 85.34,129.54 85.09,129.29 82.55,129.29 82.3,129.54 82.3,132.08 82.8,132.59 84.84,132.59
GND on TOP: 106.05,49.48 105.36,48.79 104.65,48.79 104.27,49.17 104.27,49.22 104.13,49.22 102.73,50.62 102.73,52.94 102.91,53.12 103.38,53.12 103.8,53.55 103.8,55.15 104.14,55.48 105.88,55.48 106.04,55.32 106.04,55.12
GND on TOP: 42.55,138.3 44.32,138.3 44.45,138.18 44.45,135.38 44.32,135.25 42.55,135.25 42.42,135.38 42.42,138.18
GND on TOP: 78.84,128.02 78.59,127.76 77.67,127.76 77.42,128.02 77.42,131.7 76.96,132.16 76.96,132.89 77.14,133.07 78.54,133.07 78.84,132.77
GND on TOP: 36.96,56.52 25.78,56.52 25.4,56.9 25.4,60.33 25.78,60.71 36.83,60.71 37.08,60.45 37.08,56.64
GND on TOP: 163.83,170.28 164.02,170.47 167.37,170.47 167.64,170.21 167.64,169.19 167.34,168.88 164.11,168.88 163.83,169.16
GND on TOP: 106.43,163.88 106.81,164.26 109.93,164.26 110.24,163.96 110.24,162.94 109.93,162.64 106.65,162.64 106.43,162.86
GND on TOP: 165.15,141.68 168.15,141.68 168.48,141.35 169.42,141.35 170.69,140.08 170.69,136.65 169.67,135.64 165.1,135.64 164.95,135.79 164.95,141.48
GND on TOP: 39.37,175.64 42.16,175.64 42.29,175.51 42.29,173.48 42.16,173.36 39.24,173.36 39.12,173.48 39.12,175.39
GND on TOP: 128.3,169.09 128.3,168.35 128.32,168.33 128.98,168.33 129.01,168.3 129.01,167.74 129.06,167.69 131.06,167.69 131.09,167.72 131.09,168.28 131.14,168.33 131.78,168.33 131.83,168.38 131.83,169.09 131.8,169.11 131.14,169.11 131.09,169.16 131.09,169.72 131.06,169.75 129.03,169.75 129.01,169.72 129.01,169.19 128.93,169.11 128.32,169.11
GND on TOP: 154.62,104.33 154.25,103.96 150.9,103.96 150.57,104.29 150.57,107.67 150.98,108.08 154.31,108.08 154.62,107.76
GND on TOP: 90.04,133.22 92.2,133.22 92.58,132.84 92.58,129.41 91.5,128.33 90.36,128.33 89.79,128.91 89.79,132.97
GND on TOP: 22.96,68.48 25.04,68.48 25.7,69.14 25.7,72.03 25.45,72.29 24.66,72.29 24.43,72.06 24.43,71.04 24.05,70.66 24.05,69.24 23.9,69.09 23.11,69.09 22.91,68.88 22.91,68.53
GND on TOP: 125.3,79.93 126.82,79.93 127.36,79.4 127.36,72.72 127.01,72.38 125.41,72.38 124.94,72.85 124.94,79.58
GND on TOP: 126.87,128.02 131.95,128.02 132.08,127.89 132.08,122.81 131.95,122.68 126.87,122.68 126.75,122.81 126.75,127.89
GND on TOP: 82.8,143.71 82.8,147.17 83.01,147.37 83.97,147.37 84.15,147.19 84.15,144.86 84.19,144.82 84.19,144.59 84.38,144.4 85.95,144.4 86.33,144.02 86.33,143.41 86.51,143.23 87.27,143.23 87.31,143.19 87.31,142.71 87.22,142.62 83.9,142.62
GND on TOP: 148.46,50.42 148.21,50.16 146.3,50.16 146.05,50.42 146.05,53.85 146.18,53.98 148.34,53.98 148.46,53.85
GND on TOP: 125.2,62.43 125.07,62.31 122.99,62.31 122.89,62.41 122.89,66.8 123.22,67.13 124.84,67.13 125.2,66.78
GND on TOP: 101.02,120.17 103.86,120.17 104.6,119.43 104.6,115.7 103.91,115.01 101.07,115.01 100.18,115.9 100.18,119.76 100.61,120.19 101.02,120.19
GND on TOP: 173.23,69.22 179.07,69.22 179.58,68.71 179.58,45.85 178.56,44.83 173.61,44.83 172.09,46.36 172.09,68.07
GND on TOP: 80.95,147.27 80.95,143.46 80.06,142.57 77.47,142.57 77.28,142.76 77.28,144.72 77.37,144.81 77.75,144.81 78.08,144.48 79.4,144.48 79.63,144.7 79.63,147.22 79.83,147.42 80.8,147.42
GND on TOP: 106.1,48.54 106.32,48.31 106.32,45.03 106.02,44.73 105,44.73 104.7,45.03 104.7,48.34 104.9,48.54
