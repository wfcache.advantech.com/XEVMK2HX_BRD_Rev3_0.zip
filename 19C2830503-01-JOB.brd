# Allegro board 19C2830503-01-JOB.brd (continued)
## Nets (continued)
BSC_JTAG_TDO: R51.1 R493.1
BSC_JTAG_TMS: R46.1 R485.1
CLK1_ELF: C118.1 R221.2 R227.1 U14.41(ELF)
CLK1_REF_SEL: R253.2 U53.27(GPA6)
CLK1_SYNC: R228.2 U14.42(SYNCN)
CLK2_ELF: C112.1 R219.2 U15.41(ELF)
CLK2_REF_SEL: R265.2 U53.26(GPA5)
CLK2_SYNC: R214.2 U15.42(SYNCN)
CLK3_ELF: C497.1 R299.1 U19.41(ELF)
CLK3_REF_SEL: R277.2 U53.25(GPA4)
CLK3_SYNC: R300.2 U19.42(SYNCN)
CLK_RSTZ: U14.44(RESETN/PWR) U15.44(RESETN/PWR) U19.44(RESETN/PWR) U53.7(GPB6)
COREPLLOBSCLKN: TP64.1 U24.AM4(COREPLLOBSCLKN)
COREPLLOBSCLKP: TP65.1 U24.AN4(COREPLLOBSCLKP)
CVDD: C52.1 C56.1 C64.1 C66.1 C75.1 C365.1 C368.1 C373.1 C377.1 C380.1 C422.1 C428.1 C431.1 C433.1 C434.2 C437.1 C520.1 C526.1 C527.1 C532.1 C533.1 C539.1 C540.1 C541.1 C542.1 C545.1 C546.1 C547.1 C548.1 C549.1 C550.1 C551.1 C552.1 C555.1 C556.1 C559.1 C562.1 C563.1 C571.1 C575.1 C576.1 C578.1 C585.1 C586.1 C587.1 C591.1 C595.1 C597.1 C600.1 C603.1 C606.1 C608.1 C609.1 C611.1 C614.1 C615.1 C617.1 C619.1 C622.1 C623.1 C633.1 C634.1 C635.1 C639.1 C641.1 C645.1 C646.1 C647.1 C648.1 C649.1 C651.1 C656.1 C657.1 C658.1 C659.1 C660.1 C661.1 C662.1 C667.1 C669.1 C673.1 C674.1 C677.1 C679.1 C680.1 C681.1 C682.1 C683.1 C684.1 C689.1 C697.1 C698.1 C700.1 C701.1 C749.2 C762.1 C765.1 C773.1 C779.1 C795.1 C831.1 L4.2 L12.1 R77.2 R145.1 R614.2 R741.2 R755.1 R783.2 TP11.1 TP59.1 U24.AA8(CVDD_08) U24.AA10(CVDD_01) U24.AA16(CVDD_02) U24.AA18(CVDD_03) U24.AA20(CVDD_04) U24.AA22(CVDD_05) U24.AA24(CVDD_06) U24.AA26(CVDD_07) U24.AB9(CVDD_17) U24.AB11(CVDD_09) U24.AB15(CVDD_10) U24.AB17(CVDD_11) U24.AB19(CVDD_12) U24.AB21(CVDD_13) U24.AB23(CVDD_14) U24.AB25(CVDD_15) U24.AB27(CVDD_16) U24.AC8(CVDD_26) U24.AC10(CVDD_18) U24.AC12(CVDD_19) U24.AC14(CVDD_20) U24.AC16(CVDD_21) U24.AC20(CVDD_22) U24.AC22(CVDD_23) U24.AC24(CVDD_24) U24.AC26(CVDD_25) U24.AD9(CVDD_33) U24.AD13(CVDD_27) U24.AD15(CVDD_28) U24.AD21(CVDD_29) U24.AD23(CVDD_30) U24.AD25(CVDD_31) U24.AD27(CVDD_32) U24.AE8(CVDD_43) U24.AE10(CVDD_34) U24.AE12(CVDD_35) U24.AE14(CVDD_36) U24.AE16(CVDD_37) U24.AE18(CVDD_38) U24.AE20(CVDD_39) U24.AE22(CVDD_40) U24.AE24(CVDD_41) U24.AE26(CVDD_42) U24.AF9(CVDD_46) U24.AF25(CVDD_44) U24.AF27(CVDD_45) U24.AG8(CVDD_49) U24.AG10(CVDD_47) U24.AG28(CVDD_48) U24.AH9(CVDD_51) U24.AH27(CVDD_50) U24.AJ8(CVDD_54) U24.AJ10(CVDD_52) U24.AJ28(CVDD_53) U24.AK7(CVDD_56) U24.AK9(CVDD_57) U24.AK29(CVDD_55) U24.AL6(CVDD_59) U24.AL8(CVDD_60) U24.AL30(CVDD_58) U24.AM5(CVDD_62) U24.AM31(CVDD_61) U24.H31(CVDDT_01) U24.J30(CVDDT_02) U24.K29(CVDDT_03) U24.L6(CVDD_63) U24.L28(CVDDT_04) U24.M7(CVDD_65) U24.M9(CVDD_66) U24.M25(CVDD_64) U24.M27(CVDDT_05) U24.N6(CVDD_73) U24.N8(CVDD_74) U24.N10(CVDD_67) U24.N12(CVDD_68) U24.N14(CVDD_69) U24.N16(CVDD_70) U24.N18(CVDD_71) U24.N22(CVDD_72) U24.N24(CVDDT_06) U24.N26(CVDDT_07) U24.P7(CVDD_81) U24.P9(CVDD_82) U24.P13(CVDD_75) U24.P15(CVDD_76) U24.P17(CVDD_77) U24.P19(CVDD_78) U24.P21(CVDD_79) U24.P23(CVDDT_08) U24.P25(CVDDT_09) U24.P27(CVDD_80) U24.R8(CVDD_89) U24.R10(CVDD_83) U24.R12(CVDD_84) U24.R14(CVDD_85) U24.R16(CVDD_86) U24.R18(CVDD_87) U24.R20(CVDD_88) U24.R24(CVDDT_10) U24.R26(CVDDT_11) U24.T9(CVDD_95) U24.T11(CVDD_90) U24.T15(CVDD_91) U24.T17(CVDD_92) U24.T19(CVDD_93) U24.T23(CVDDT_12) U24.T25(CVDDT_13) U24.T27(CVDD_94) U24.U8(CVDD_99) U24.U10(CVDD_96) U24.U12(CVDD_97) U24.U18(CVDD_98) U24.U24(CVDDT_14) U24.U26(CVDDT_15) U24.V9(CVDD_103) U24.V15(CVDD_100) U24.V19(CVDD_101) U24.V23(CVDDT_16) U24.V25(CVDDT_17) U24.V27(CVDD_102) U24.W8(CVDD_109) U24.W10(CVDD_104) U24.W12(CVDD_105) U24.W14(CVDD_106) U24.W18(CVDD_107) U24.W20(CVDD_108) U24.W24(CVDDT_18) U24.W26(CVDDT_19) U24.Y9(CVDD_117) U24.Y15(CVDD_110) U24.Y17(CVDD_111) U24.Y19(CVDD_112) U24.Y21(CVDD_113) U24.Y23(CVDD_114) U24.Y25(CVDD_115) U24.Y27(CVDD_116)
CVDD1: C97.1 C104.1 C110.1 C115.1 C436.1 C440.1 C452.1 C457.1 C498.1 C583.1 C584.1 C604.1 C605.1 C610.1 C621.1 L5.1 R198.2 R294.2 U24.AC18(CVDD1_01) U24.AD11(VNWA2) U24.AD17(CVDD1_02) U24.AD19(CVDD1_03) U24.AG24(VNWA1) U24.M23(VNWA3) U24.T13(CVDD1_04) U24.T21(CVDD1_05) U24.U14(CVDD1_06) U24.U16(CVDD1_07) U24.U20(CVDD1_08) U24.V11(VNWA4) U24.V13(CVDD1_09) U24.V17(CVDD1_10) U24.V21(CVDD1_11) U24.W16(CVDD1_12)
CVDD1T: C92.1 C98.1 C105.1 C111.1 C116.1 C435.1 C451.1 C461.1 C630.1 C640.1 C642.1 L6.1 R567.2 R606.2 U24.R22(CVDDT1_01) U24.U22(CVDDT1_02) U24.W22(CVDDT1_03)
CVDD_PWR_MON: R243.1 R583.2 U13.1(MON1)
CVDD_PWR_OK: D7.1(ANODE) R243.2 R271.1 U16.24(POWER_GOOD)
DAC_SSPCK_3.3V: U29.6(SCLK) U32.6(2A1)
DAC_SSPCS2_3.3V: U29.5(S\Y\N\C\) U32.5(1A2)
DAC_VOUT: C301.2 R261.2 TP49.1 U29.3(VFB) U29.4(VOUT)
DDR3A_CLKN: C670.1 U19.33(Y6_N)
DDR3A_CLKP: C671.1 U19.32(Y6_P)
DDR3AATO: TP71.1 U24.F13(RSV029)
DDR3ACLKN_C: C670.2 U24.A25(DDR3ACLKN)
DDR3ACLKP_C: C671.2 U24.B25(DDR3ACLKP)
DDR3APLLOBSCLKN: TP46.1 U24.A24(DDR3APLLOBSCLKN)
DDR3APLLOBSCLKP: TP47.1 U24.B24(DDR3APLLOBSCLKP)
DDR3B_CLKN: C324.1 U19.36(Y7_N)
DDR3B_CLKP: C323.1 U19.35(Y7_P)
DDR3BATO: TP88.1 U24.AB32(RSV032)
DDR3BCLKN_C: C324.2 U24.AR39(DDR3BCLKN)
DDR3BCLKP_C: C323.2 U24.AR38(DDR3BCLKP)
DDR3BPLLOBSCLKN: TP55.1 U24.AP39(DDR3BPLLOBSCLKN)
DDR3BPLLOBSCLKP: TP53.1 U24.AP38(DDR3BPLLOBSCLKP)
DIMM_SA0: DIMM1.197(SA0) R410.1 R421.1
DIMM_SA1: DIMM1.201(SA1) R428.1 R432.1
DIMM_SCL: DIMM1.202(SCL) R424.1 U34.7(SCLB)
DIMM_SDA: DIMM1.200(SDA) R420.1 U34.6(SDAB)
DIP_SW_B0: R498.1 SW1.1 U7.86(PH0)
DIP_SW_B1: R497.1 SW1.2 U7.85(PH1)
DIP_SW_B2: R496.1 SW1.3 U7.84(PH2)
DIP_SW_B3: R495.1 SW1.4 U7.83(PH3)
DSP_SCL_AMC: AMC1.160(RX20+) R764.1
DSP_SDA_AMC: AMC1.159(RX20-) R759.1
DSP_UCD9244_VID1A: R450.1 U16.41(VID1A) U37.4(1A1)
DSP_UCD9244_VID1B: R451.1 U16.42(VID1B) U37.5(1A2)
DSP_UCD9244_VID1C: R452.1 U16.18(VID1C) U37.6(2A1)
DSP_UCD9244_VID1S: R453.1 U16.12(VID1S) U37.7(2A2)
DSP_VCL_R: CN19.1 U24.AP36(VCL)
DSP_VD_R: CN19.2 U24.AP35(VD)
DSP_VIDA: R415.1 U24.AR36(VCNTL2) U37.13(1B1)
DSP_VIDB: R416.1 U24.AT38(VCNTL3) U37.12(1B2)
DSP_VIDC: R417.1 U24.AU38(VCNTL4) U37.11(2B1)
DSP_VIDS: R418.1 U24.AR35(VCNTL5) U37.10(2B2)
ECC_NU: R751.2 U41.D7(DQU0)
EEPROM_WPZ: EEPROM1.7(W\C\) R324.2 U50.2(GPB1)
EMIF_DIR: R810.2 U50.22(GPA1)
EMIF_DIR_R: R810.1 R811.1 U65.1(DIR) U68.1(DIR)
EMIF_OEZ: R812.2 U65.19(O\E\) U68.19(O\E\) U69.4(Y)
EMIFA00: U24.F34(EMIFA00) U63.47(1A1)
EMIFA01: U24.F37(EMIFA01) U63.46(1A2)
EMIFA02: U24.G36(EMIFA02) U63.44(1A3)
EMIFA03: U24.E39(EMIFA03) U63.43(1A4)
EMIFA04: U24.E34(EMIFA04) U63.41(2A1)
EMIFA05: U24.J34(EMIFA05) U63.40(2A2)
EMIFA06: U24.H35(EMIFA06) U63.38(2A3)
EMIFA07: U24.K33(EMIFA07) U63.37(2A4)
EMIFA08: U24.C35(EMIFA08) U63.36(3A1)
EMIFA09: U24.G37(EMIFA09) U63.35(3A2)
EMIFA10: U24.F38(EMIFA10) U63.33(3A3)
EMIFA11: NAND1.C4(ALE) U24.D35(EMIFA11) U63.32(3A4)
EMIFA12: NAND1.D5(CLE) U24.H36(EMIFA12) U63.30(4A1)
EMIFA13: U24.E35(EMIFA13) U63.29(4A2)
EMIFA14: U24.G38(EMIFA14) U63.27(4A3)
EMIFA15: U24.F39(EMIFA15) U63.26(4A4)
EMIFA16: U24.K34(EMIFA16) U64.47(1A1)
EMIFA17: U24.F35(EMIFA17) U64.46(1A2)
EMIFA18: U24.J35(EMIFA18) U64.44(1A3)
EMIFA19: U24.G39(EMIFA19) U64.43(1A4)
EMIFA20: U24.C36(EMIFA20) U64.41(2A1)
EMIFA21: U24.J36(EMIFA21) U64.40(2A2)
EMIFA22: U24.H38(EMIFA22) U64.38(2A3)
EMIFA23: U24.D36(EMIFA23) U64.37(2A4)
EMIFBE0Z: U24.H34(E\M\I\F\B\E\0\) U64.36(3A1)
EMIFBE1Z: U24.H33(E\M\I\F\B\E\1\) U64.35(3A2)
EMIFCE0Z: R27.2 U24.G33(E\M\I\F\C\E\0\)
EMIFCE1Z: U24.G32(E\M\I\F\C\E\1\) U64.33(3A3)
EMIFCE2Z: U24.G34(E\M\I\F\C\E\2\) U64.32(3A4)
EMIFCE3Z: U24.E36(E\M\I\F\C\E\3\) U64.30(4A1)
EMIFD0: NAND1.H4(I/O0) U24.M32(EMIFD00) U65.2(A1)
EMIFD1: NAND1.J4(I/O1) U24.J37(EMIFD01) U65.3(A2)
EMIFD2: NAND1.K4(I/O2) U24.L33(EMIFD02) U65.4(A3)
EMIFD3: NAND1.K5(I/O3) U24.L34(EMIFD03) U65.5(A4)
EMIFD4: NAND1.K6(I/O4) U24.H39(EMIFD04) U65.6(A5)
EMIFD5: NAND1.J7(I/O5) U24.J38(EMIFD05) U65.7(A6)
EMIFD6: NAND1.K7(I/O6) U24.K37(EMIFD06) U65.8(A7)
EMIFD7: NAND1.J8(I/O7) U24.J39(EMIFD07) U65.9(A8)
EMIFD8: U24.K39(EMIFD08) U68.2(A1)
EMIFD9: U24.K38(EMIFD09) U68.3(A2)
EMIFD10: U24.K36(EMIFD10) U68.4(A3)
EMIFD11: U24.L36(EMIFD11) U68.5(A4)
EMIFD12: U24.L35(EMIFD12) U68.6(A5)
EMIFD13: U24.M34(EMIFD13) U68.7(A6)
EMIFD14: U24.M36(EMIFD14) U68.8(A7)
EMIFD15: U24.M35(EMIFD15) U68.9(A8)
EMIFOEZ: NAND1.D4(R\E\) R811.2 U24.E37(E\M\I\F\O\E\) U64.27(4A3)
EMIFRNW: U24.F33(EMIFRNW) U64.29(4A2)
EMIFWAIT0: NAND1.C8(R\/B\) R25.2 U24.E38(EMIFWAIT0)
EMIFWAIT1: R69.2 U24.D39(EMIFWAIT1) U67.4(Y)
EMIFWEZ: NAND1.C7(W\E\) U24.F36(E\M\I\F\W\E\) U64.26(4A4)
EMU_EMU_00: R61.2 R62.1 U49.34(5B1)
EMU_EMU_00_R: EMU1.19(PTH_23) R62.2
EMU_EMU_01: R516.2 R517.2 U49.29(6B1)
EMU_EMU_01_R: EMU1.21(PTH_25) R516.1
EMU_TCK: R32.2 R36.2 R37.1 U45.8(1A4) U45.11(2A1)
EMU_TCK_R: EMU1.3(PTH_7) R37.2
EMU_TCKRTN: EMU1.7(PTH_11) R12.1
EMU_TDI: R42.2 R43.1 U45.2(1A1)
EMU_TDI_R: EMU1.5(PTH_9) R43.2
EMU_TDO: R49.1 R50.2 U45.7(2Y2)
EMU_TDO_B: U45.13(2A2) U49.35(4B1)
EMU_TDO_R: EMU1.4 R49.2
EMU_TMS: R38.2 R44.1 U45.4(1A2)
EMU_TMS_R: EMU1.2 R44.2
EMU_TRST#: R57.1 R58.2 U45.6(1A3)
EMU_TRST#_R: EMU1.8 R57.2
EXP_SCL2_3V3: CN3.7 R536.2 R569.1 R764.2 U54.7(SCLB)
EXP_SDA2_3V3: CN3.5 R541.2 R571.1 R759.2 U54.6(SDAB)
EXP_TIMO0: CN3.73 U30.2(B)
EXP_TIMO1: CN3.77 U17.2(B)
EXP_TP0: CN3.96 TP8.1
EXP_TP1: CN3.98 R41.1
EXP_TP2: CN3.100 R35.1
EXP_UART1_RXD_3V3: CN3.95 U52.12(B8)
EXP_UART1_TXD_3V3: CN3.93 U51.7(2A2)
EXP_UARTTXD: U26.6(Y0) U52.9(A8)
EXT_EMU_DET: EMU1.58 R112.1 U11.1(A)
EXT_EMU_DET_C: U11.4(Y) U49.24(SEL)
EXT_PS#: R34.1 R35.2 U53.23(GPA2)
EXT_TIMO1: CN15.1 U17.1(A)
EXTFRAMEEVENT: CN15.2 R623.2 U24.AC4(EXTFRAMEEVENT)
FAN_PWM: C724.1 FAN1.4 R574.1
FARM0_AVGG1: C67.2 R550.2 U10.40(AVGG)
FARM0_AVGG2: C371.2 R459.2 U44.40(AVGG)
FARM0_CSN1: R134.1 U10.35(CSN)
FARM0_CSN2: R766.1 U44.35(CSN)
FARM0_CSP1: R135.1 U10.36(CSP)
FARM0_CSP2: R767.1 U44.36(CSP)
FARM0_FF-1A: R223.1 U10.29(FLT) U62.1(A)
FARM0_FF-1A_L: C119.1 R223.2 U16.11(FLT1A) U62.4(Y)
FARM0_FF-2A: R231.1 R806.2 U44.29(FLT) U62.2(B)
FARM0_FF-2A_L: C124.2 R231.2 U16.13(FLT2A)
FARM0_FF-3A: R269.1 U9.9(FLT_B)
FARM0_FF-3A_L: C145.1 R269.2 U16.25(FLT3A)
FARM0_FF-4A: R238.1 U9.18(FLT_A)
FARM0_FF-4A_L: C125.1 R238.2 U16.34(FLT4A)
FARM0_ILIM1: R122.2 R128.2 U10.32(ILIM)
FARM0_ILIM2: R456.2 R461.2 U44.32(ILIM)
FARM0_LSENES-1A: R146.1 U10.33(IMON)
FARM0_LSENES-2A: R201.1 U44.33(IMON)
FARM0_LSENES-3A: R195.1 R544.1 U9.7(IMON_B)
FARM0_LSENES-4A: R170.1 R540.1 U9.20(IMON_A)
FARM0_PWM-1A: R807.2 U10.38(PWM) U16.17(DPWM1A)
FARM0_PWM-2A: R807.1 R808.1 U44.38(PWM)
FARM0_PWM-2A_L: R808.2 U16.19(DPWM2A)
FARM0_PWM-3A: U9.1(PWM_B) U16.21(DPWM3A)
FARM0_PWM-4A: U9.26(PWM_A) U16.23(DPWM4A)
FARM0_RDLY1: R136.2 U10.39(RDLY)
FARM0_RDLY2: R768.2 U44.39(RDLY)
FARM0_SRE_A1: R121.1 U10.31(SRE)
FARM0_SRE_A2: R460.1 U44.31(SRE)
FARM0_SRE_A3: R82.1 U9.2(SRE_B)
FARM0_SRE_A4: R81.1 U9.25(SRE_A)
FARM0_SW_SHAPE1: C60.1 L4.1 R551.1 R802.1 U10.7(SW_1) U10.8(SW_2) U10.9(SW_3) U10.10(SW_4) U10.11(SW_5) U10.12(SW_6)
FARM0_SW_SHAPE2: C791.1 L12.2 R761.1 R803.1 U44.7(SW_1) U44.8(SW_2) U44.9(SW_3) U44.10(SW_4) U44.11(SW_5) U44.12(SW_6)
FARM0_UCD_EAN1: C84.2 R150.2 R615.1 U16.51(EAN1)
FARM0_UCD_EAN2: C83.2 R149.2 R743.1 U16.53(EAN2)
FARM0_UCD_EAN3: C82.2 R148.2 R293.1 U16.55(EAN3)
FARM0_UCD_EAN4: C81.2 R147.2 R605.1 U16.57(EAN4)
FARM0_UCD_EAP1: R140.1 R614.1
FARM0_UCD_EAP2: R139.1 R741.1
FARM0_UCD_EAP3: R138.1 R294.1
FARM0_UCD_EAP4: R137.1 R606.1
FARM0_UCD_TEMP1: C453.2 Q17.3(VOUT) U16.5(TEMP1/AUXADC1)
FARM0_UCD_TEMP2: C458.2 Q21.3(VOUT) U16.6(TEMP2/AUXADC2)
FARM0_UCD_TEMP3: C58.1 C79.2 U9.19(TMON) U16.62(TEMP3/AUXADC3) U16.63(TEMP4/AUXADC4)
FARM0_UCD_VIN: C109.1 R208.2 R209.1 U16.4(VINMON)
FARM0_VGG1: C429.1 R550.1 U10.3(VGG)
FARM0_VGG2: C767.1 R459.1 U44.3(VGG)
FARM1_AVGG2: C62.2 R537.2 U8.40(AVGG)
FARM1_CSN2: R114.1 U8.35(CSN)
FARM1_CSP2: R115.1 U8.36(CSP)
FARM1_FF-1A: R378.1 U27.2(FLT)
FARM1_FF-1A_L: C283.1 R378.2 U25.11(FLT1A)
FARM1_FF-2A: R380.1 U8.29(FLT)
FARM1_FF-2A_L: C284.1 R380.2 U25.13(FLT2A)
FARM1_FF-3A: R354.1 U23.9(FLT_B)
FARM1_FF-3A_L: C251.1 R354.2 U25.25(FLT3A)
FARM1_FF-4A: R338.1 U23.18(FLT_A)
FARM1_FF-4A_L: C231.1 R338.2 U25.34(FLT4A)
FARM1_FLTRST: R395.1 U27.12(FLTRST)
FARM1_ILIM2: R93.2 R105.2 U8.32(ILIM)
FARM1_LSENES-1A: C722.1 R370.1 R699.2 U27.11(IMON)
FARM1_LSENES-2A: R693.1 U8.33(IMON)
FARM1_LSENES-3A: R639.1 R682.1 U23.7(IMON_B)
FARM1_LSENES-4A: R612.1 R683.1 U23.20(IMON_A)
FARM1_PWM-1A: U25.17(DPWM1A) U27.4(PWM)
FARM1_PWM-2A: U8.38(PWM) U25.19(DPWM2A)
FARM1_PWM-3A: U23.1(PWM_B) U25.21(DPWM3A)
FARM1_PWM-4A: U23.26(PWM_A) U25.23(DPWM4A)
FARM1_RDLY2: R113.2 U8.39(RDLY)
FARM1_SRE_A1: R386.1 U27.3(SRE)
FARM1_SRE_A2: R92.1 U8.31(SRE)
FARM1_SRE_A3: R329.1 U23.2(SRE_B)
FARM1_SRE_A4: R318.1 U23.25(SRE_A)
FARM1_SW_SHAPE1: C292.1 L9.1 U27.6(SW)
FARM1_SW_SHAPE2: C63.1 L3.2 R538.1 U8.7(SW_1) U8.8(SW_2) U8.9(SW_3) U8.10(SW_4) U8.11(SW_5) U8.12(SW_6)
FARM1_UCD_EAN1: C236.2 R343.2 R668.1 U25.51(EAN1)
FARM1_UCD_EAN2: C239.2 R347.2 R756.1 U25.53(EAN2)
FARM1_UCD_EAN3: C244.2 R352.1 R353.2 U25.55(EAN3)
FARM1_UCD_EAN4: C252.2 R357.1 R358.2 U25.57(EAN4)
FARM1_UCD_EAP1: R342.1 R670.1
FARM1_UCD_EAP2: R345.1 R757.1
FARM1_UCD_EAP3: R348.1 R349.1
FARM1_UCD_EAP4: R355.1 R356.1
FARM1_UCD_EN: R246.1 R346.2
FARM1_UCD_EN_L: R346.1 R351.2 U25.28(PMBUS_CNTRL)
FARM1_UCD_EN_R: R246.2 U13.5(GPIO2)
FARM1_UCD_TEMP1: C280.2 C723.2 U25.5(TEMP1/AUXADC1) U27.10(TMON)
FARM1_UCD_TEMP2: C281.2 Q15.3(VOUT) U25.6(TEMP2/AUXADC2)
FARM1_UCD_TEMP3: C186.1 C269.2 U23.19(TMON) U25.62(TEMP3/AUXADC3) U25.63(TEMP4/AUXADC4)
FARM1_UCD_VIN: C279.1 R375.2 R376.1 U25.4(VINMON)
FARM1_VGG2: C420.1 R537.1 U8.3(VGG)
FT2232HL_RESET#1: R16.2 U3.14(R\E\S\E\T\)
FTDI_MCU_U0RX: U3.38(BDBUS0) U12.2(B)
FTDI_SOC_U0RX: U3.16(ADBUS0) U55.2(B)
FULL_RESETZ: C77.1 CN8.1 R152.2 R161.1 U7.87(PJ1)
GPS_ENABLE: GPS1.C4(GPS_ENABLE) R433.2 R762.1
GPS_PPS: CN17.1 GPS1.C1(GPS_PPS)
GPS_RF: C369.1 GPS1.B1(GPS_RF) L11.2
GPS_RTC_CLK: GPS1.C5(RTC_CLK) R423.1
GPS_RTC_CLK_R: OSC4.3(OUT) R423.2
GPS_UARTRXD: R774.1 U21.2(B)
GPS_UARTRXD_R: GPS1.C3(GPS_TX) R774.2
GPS_UARTTXD: GPS1.B3(GPS_RX) U26.4(Y1)
GTX_CLK: PHY2.E2(GTX_CLK) R592.2
GTX_CLK_0: PHY1.E2(GTX_CLK) R663.2
HEAD_UCD_CNTRL_L: D7.2(CATHODE) R267.1 R268.2 U16.28(PMBUS_CNTRL)
HYPER0_LINK_CLKN: C534.1 U19.15(Y0_N)
HYPER0_LINK_CLKP: C524.1 U19.14(Y0_P)
HYPER0LINKCLKN_C: C534.2 U24.AT10(HYPLNK0CLKN)
HYPER0LINKCLKP_C: C524.2 U24.AT9(HYPLNK0CLKP)
HYPER1_LINK_CLKN: C191.1 U19.16(Y1_N)
HYPER1_LINK_CLKP: C187.1 U19.17(Y1_P)
HYPER1LINKCLKN_C: C191.2 U24.AW5(HYPLNK1CLKN)
HYPER1LINKCLKP_C: C187.2 U24.AW4(HYPLNK1CLKP)
HYPERLINK0_RXFLCLK: J1.C3(RXFLCLK1) R628.2
HYPERLINK0_RXFLCLK_R: R628.1 U24.AJ5(HYPLNK0RXFLCLK)
HYPERLINK0_RXFLDAT: J1.D3(RXFLDAT1) U24.AJ4(HYPLNK0RXFLDAT)
HYPERLINK0_RXN0: C216.1 J1.B4(RX0_1-)
HYPERLINK0_RXN0_C: C216.2 U24.AW10(HYPLNK0RXN0)
HYPERLINK0_RXN1: C210.1 J1.B6(RX1_1-)
HYPERLINK0_RXN1_C: C210.2 U24.AU10(HYPLNK0RXN1)
HYPERLINK0_RXN2: C200.1 J1.B8(RX2_1-)
HYPERLINK0_RXN2_C: C200.2 U24.AV9(HYPLNK0RXN2)
HYPERLINK0_RXN3: C190.1 J1.B10(RX3_1-)
HYPERLINK0_RXN3_C: C190.2 U24.AW7(HYPLNK0RXN3)
HYPERLINK0_RXP0: C218.1 J1.A4(RX0_1+)
HYPERLINK0_RXP0_C: C218.2 U24.AW11(HYPLNK0RXP0)
HYPERLINK0_RXP1: C215.1 J1.A6(RX1_1+)
HYPERLINK0_RXP1_C: C215.2 U24.AU11(HYPLNK0RXP1)
HYPERLINK0_RXP2: C203.1 J1.A8(RX2_1+)
HYPERLINK0_RXP2_C: C203.2 U24.AV10(HYPLNK0RXP2)
HYPERLINK0_RXP3: C199.1 J1.A10(RX3_1+)
HYPERLINK0_RXP3_C: C199.2 U24.AW8(HYPLNK0RXP3)
HYPERLINK0_RXPMCLK: J1.C5(RXPMCLK1) U24.AJ2(HYPLNK0RXPMCLK)
HYPERLINK0_RXPMDAT: J1.D5(RXPMDAT1) U24.AG3(HYPLNK0RXPMDAT)
HYPERLINK0_TXFLCLK: J1.C4(TXFLCLK1) U24.AJ3(HYPLNK0TXFLCLK)
HYPERLINK0_TXFLDAT: J1.D4(TXFLDAT1) U24.AG5(HYPLNK0TXFLDAT)
HYPERLINK0_TXN0: J1.B3(TX0_1-) U24.AP11(HYPLNK0TXN0)
HYPERLINK0_TXN1: J1.B5(TX1_1-) U24.AR10(HYPLNK0TXN1)
HYPERLINK0_TXN2: J1.B7(TX2_1-) U24.AP8(HYPLNK0TXN2)
HYPERLINK0_TXN3: J1.B9(TX3_1-) U24.AR7(HYPLNK0TXN3)
HYPERLINK0_TXP0: J1.A3(TX0_1+) U24.AP12(HYPLNK0TXP0)
HYPERLINK0_TXP1: J1.A5(TX1_1+) U24.AR11(HYPLNK0TXP1)
HYPERLINK0_TXP2: J1.A7(TX2_1+) U24.AP9(HYPLNK0TXP2)
HYPERLINK0_TXP3: J1.A9(TX3_1+) U24.AR8(HYPLNK0TXP3)
HYPERLINK0_TXPMCLK: J1.C6(TXPMCLK1) R609.2
HYPERLINK0_TXPMCLK_R: R609.1 U24.AH5(HYPLNK0TXPMCLK)
HYPERLINK0_TXPMDAT: J1.D6(TXPMDAT1) U24.AJ1(HYPLNK0TXPMDAT)
HYPERLINK1_RXFLCLK: J1.C7(RXFCLK2) R621.2
HYPERLINK1_RXFLCLK_R: R621.1 U24.AH4(HYPLNK1RXFLCLK)
HYPERLINK1_RXFLDAT: J1.D7(RXFLDAT2) U24.AG2(HYPLNK1RXFLDAT)
HYPERLINK1_RXN0: C517.1 J1.F4(RX0_2-)
HYPERLINK1_RXN0_C: C517.2 U24.AU7(HYPLNK1RXN0)
HYPERLINK1_RXN1: C511.1 J1.F6(RX1_2-)
HYPERLINK1_RXN1_C: C511.2 U24.AV6(HYPLNK1RXN1)
HYPERLINK1_RXN2: C505.1 J1.F8(RX2_2-)
HYPERLINK1_RXN2_C: C505.2 U24.AU4(HYPLNK1RXN2)
HYPERLINK1_RXN3: C502.1 J1.F10(RX3_2-)
HYPERLINK1_RXN3_C: C502.2 U24.AV3(HYPLNK1RXN3)
HYPERLINK1_RXP0: C523.1 J1.E4(RX0_2+)
HYPERLINK1_RXP0_C: C523.2 U24.AU8(HYPLNK1RXP0)
HYPERLINK1_RXP1: C513.1 J1.E6(RX1_2+)
HYPERLINK1_RXP1_C: C513.2 U24.AV7(HYPLNK1RXP1)
HYPERLINK1_RXP2: C510.1 J1.E8(RX2_2+)
HYPERLINK1_RXP2_C: C510.2 U24.AU5(HYPLNK1RXP2)
HYPERLINK1_RXP3: C506.1 J1.E10(RX3_2+)
HYPERLINK1_RXP3_C: C506.2 U24.AV4(HYPLNK1RXP3)
HYPERLINK1_RXPMCLK: J1.C9(RXPMCLK2) U24.AF3(HYPLNK1RXPMCLK)
HYPERLINK1_RXPMDAT: J1.D9(RXPMDAT2) U24.AF4(HYPLNK1RXPMDAT)
HYPERLINK1_TXFLCLK: J1.C8(TXFCLK2) U24.AH3(HYPLNK1TXFLCLK)
HYPERLINK1_TXFLDAT: J1.D8(TXFLDAT2) U24.AH2(HYPLNK1TXFLDAT)
HYPERLINK1_TXN0: J1.F3(TX0_2-) U24.AT6(HYPLNK1TXN0)
HYPERLINK1_TXN1: J1.F5(TX1_2-) U24.AP5(HYPLNK1TXN1)
HYPERLINK1_TXN2: J1.F7(TX2_2-) U24.AR4(HYPLNK1TXN2)
HYPERLINK1_TXN3: J1.F9(TX3_2-) U24.AT3(HYPLNK1TXN3)
HYPERLINK1_TXP0: J1.E3(TX0_2+) U24.AT7(HYPLNK1TXP0)
HYPERLINK1_TXP1: J1.E5(TX1_2+) U24.AP6(HYPLNK1TXP1)
HYPERLINK1_TXP2: J1.E7(TX2_2+) U24.AR5(HYPLNK1TXP2)
HYPERLINK1_TXP3: J1.E9(TX3_2+) U24.AT4(HYPLNK1TXP3)
HYPERLINK1_TXPMCLK: J1.C10(TXPMCLK2) R309.2
HYPERLINK1_TXPMCLK_R: R309.1 U24.AH1(HYPLNK1TXPMCLK)
HYPERLINK1_TXPMDAT: J1.D10(TXPMDAT2) U24.AF2(HYPLNK1TXPMDAT)
JTAG_TCK: TP25.1 U13.27(TCK/GPIO18)
JTAG_TDI: R176.2 TP15.1 U13.29(TDI/GPIO20)
JTAG_TDO: TP21.1 U13.28(TDO/GPIO19)
JTAG_TMS: R175.2 TP13.1 U13.30(TMS/GPIO21)
LAN0_LED_LINK10: PHY1.C8(LED_LINK10) R736.1
LAN0_LED_LINK100: PHY1.B8(LED_LINK100) R371.1
LAN0_LED_LINK1000: PHY1.A9(LED_LINK1000) R382.1 R737.1 R738.1
LAN0_LED_RX: PHY1.C9(LED_RX) R350.1
LAN0_TRD2_0N: CN16.A2(TRD0-_A) PHY1.N2(MDI0-) R681.2
LAN0_TRD2_0P: CN16.A1(TRD0+_A) PHY1.N1(MDI0+) R680.2
LAN0_TRD2_1N: CN16.A4(TRD1-_A) PHY1.N4(MDI1-) R695.2
LAN0_TRD2_1P: CN16.A3(TRD1+_A) PHY1.N3(MDI1+) R689.2
LAN0_TRD2_2N: CN16.A8(TRD2-_A) PHY1.N7(MDI2-) R705.2
LAN0_TRD2_2P: CN16.A7(TRD2+_A) PHY1.N6(MDI2+) R700.2
LAN0_TRD2_3N: CN16.A10(TRD3-_A) PHY1.N9(MDI3-) R717.2
LAN0_TRD2_3P: CN16.A9(TRD3+_A) PHY1.N8(MDI3+) R710.2
LAN1_LED_LINK10: PHY2.C8(LED_LINK10) R653.1
LAN1_LED_LINK100: PHY2.B8(LED_LINK100) R333.1
LAN1_LED_LINK1000: PHY2.A9(LED_LINK1000) R335.1 R654.1 R655.1
LAN1_LED_RX: PHY2.C9(LED_RX) R327.1
LAN1_TRD2_0N: CN16.B2(TRD0-_B) PHY2.N2(MDI0-) R624.2
LAN1_TRD2_0P: CN16.B1(TRD0+_B) PHY2.N1(MDI0+) R618.2
LAN1_TRD2_1N: CN16.B4(TRD1-_B) PHY2.N4(MDI1-) R630.2
LAN1_TRD2_1P: CN16.B3(TRD1+_B) PHY2.N3(MDI1+) R626.2
LAN1_TRD2_2N: CN16.B8(TRD2-_B) PHY2.N7(MDI2-) R636.2
LAN1_TRD2_2P: CN16.B7(TRD2+_B) PHY2.N6(MDI2+) R633.2
LAN1_TRD2_3N: CN16.B10(TRD3-_B) PHY2.N9(MDI3-) R641.2
LAN1_TRD2_3P: CN16.B9(TRD3+_B) PHY2.N8(MDI3+) R637.2
LCD_A0: LCD1.15(A0) R514.2
LCD_RSTZ: LCD1.16(RST) U7.100(PD7)
LED0_DUPLEX: PHY1.E8(LED_DUPLEX) R729.1
LED0_TX: PHY1.D9(LED_TX) TP93.1
LED_DUPLEX: PHY2.E8(LED_DUPLEX) R646.1
LED_TX: PHY2.D9(LED_TX) R647.1
MAIN_POWER_GOOD: R166.1 U7.11(PD1)
MAIN_POWER_GOOD_R: R166.2 U13.24(GPIO15)
MAIN_POWER_START: R564.2 U7.10(PD0)
MAIN_POWER_START_R: CN7.5 R564.1 U13.22(PWM1/GPI1)
MCU_BOOTSELECT: CN9.1 R222.1 U7.36(PG7)
MCU_EMU_DET: U11.2(B) U53.24(GPA3)
MCU_EXP_SCL: R306.2 U7.34(PA6) U22.2(SCLA) U58.7(SCLB)
MCU_EXP_SDA: R297.2 U7.35(PA7) U22.3(SDAA) U58.6(SDAB)
MCU_GPS_ENABLE: R433.1 U50.23(GPA2)
MCU_JTAG_TCK: R39.2 U7.80(PC0/TCK/SWCLK)
MCU_JTAG_TDI: R45.2 U7.78(PC2/TDI)
MCU_JTAG_TDO: R51.2 U7.77(PC3/TDO/SWO)
MCU_JTAG_TMS: R40.1 R46.2 U7.79(PC1/TMS/SWDIO)
MCU_PA0_U0RX: U7.26(PA0/U0RX) U12.5(Y)
MCU_PA1_U0TX: R129.2 U3.39(BDBUS1) U7.27(PA1/U0TX)
MCU_RESET_SWZ: C54.1 C827.1 R84.1 R91.2 U6.1(A)
MCU_RESETSTATZ: R41.2 U53.22(GPA1)
MCU_RESETZ: U6.4(Y) U7.64(R\S\T\)
MCU_SPI0_CLK: U7.28(PA2/SSI0CLK) U14.5(SCL/PIN4) U15.5(SCL/PIN4) U19.5(SCL/PIN4) U52.16(B4) U53.12(SCK)
MCU_SPI0_CLK_1V8: U47.12(SCK) U48.12(SCK) U50.12(SCK) U52.5(A4)
MCU_SPI0_CS0Z: U7.29(PA3/SSI0FSS) U14.4(SCS/AD1/PIN3)
MCU_SPI0_CS1Z: U7.25(PC4) U15.4(SCS/AD1/PIN3)
MCU_SPI0_CS2Z: U7.24(PC5) U19.4(SCS/AD1/PIN3)
MCU_SPI0_CS3Z: U7.23(PC6) U51.4(1A1)
MCU_SPI0_CS3Z_1V8: U48.11(C\S\) U51.13(1B1)
MCU_SPI0_CS4Z: U7.22(PC7) U51.5(1A2)
MCU_SPI0_CS4Z_1V8: U50.11(C\S\) U51.12(1B2)
MCU_SPI0_CS5Z: U7.60(PF2) U51.6(2A1)
MCU_SPI0_CS5Z_1V8: U47.11(C\S\) U51.11(2B1)
MCU_SPI0_CS6Z: U7.59(PF3) U53.11(C\S\)
MCU_SPI0_MISO: R131.2 U14.3(SDO/AD0/PIN2) U15.3(SDO/AD0/PIN2) U19.3(SDO/AD0/PIN2) U52.14(B6) U53.14(SO)
MCU_SPI0_MISO_1V8: U47.14(SO) U48.14(SO) U50.14(SO) U52.7(A6)
MCU_SPI0_MOSI: R130.2 U14.2(SDI/SDA/PIN1) U15.2(SDI/SDA/PIN1) U19.2(SDI/SDA/PIN1) U52.15(B5) U53.13(SI)
MCU_SPI0_MOSI_1V8: U47.13(SI) U48.13(SI) U50.13(SI) U52.6(A5)
MCU_SPI1_CLK: LCD1.14(SCL) U7.74(PE0)
MCU_SPI1_CS0Z: LCD1.17(CS1B) U7.75(PE1)
MCU_SPI1_MISO: TP7.1 U7.95(PE2)
MCU_SPI1_MOSI: LCD1.13(SDA) R515.2
MCU_SRSTN_R: C42.1 R52.2 R59.2 U6.2(B)
MCU_U0RX: R123.2 U12.1(A)
MCU_U1RX: R524.2 U7.66(PB0)
MCU_U1TX: TP9.1 U7.67(PB1)
MCU_UART0_DETECT: MCU.1 R232.2 U12.6(A\/B)
MCU_UART_RX: R123.1 U56.9(ROUT)
MCU_UART_TX: R129.1 R578.1 U56.11(DIN)
MCU_WAKEZ: CN8.2 U7.50(W\A\K\E\)
MCUOSC0: C70.1 U7.48(OSC0) Y2.1
MCUOSC1: C71.2 U7.49(OSC1) Y2.2
MCUXOSC0: R100.1 U7.52(XOSC0)
MCUXOSC0_R: OSC1.3(OUT) R100.2
MMC_BLUE_LED: R494.1 U7.15(PH7)
MMC_ENABLE_N: AMC1.41(E\N\A\B\L\E\) R98.2
MMC_GA0: AMC1.5(GA0) R489.1 R501.1 U7.92(PB4)
MMC_GA1: AMC1.17(GA1) R488.1 R500.1 U7.91(PB5)
MMC_GA2: AMC1.26(GA2) R487.1 R499.1 U7.90(PB6)
MMC_GAPU: R499.2 R500.2 R501.2 U7.89(PB7)
MMC_PS_N0: AMC1.83(P\S\0\) D10.2(CATHODE) R528.2 U7.63(PH5)
MMC_PS_N1: AMC1.3(P\S\1\) D10.1(ANODE)
MMC_RED_LED: R31.1 U7.62(PH6)
NAND_WPZ: NAND1.C3(W\P\) R29.2 U50.1(GPB0)
NOR_HD#: NOR1.1(H\O\L\D/DQ3) R733.1
NOR_SSPCS: NOR1.7(S\) U24.F25(SPI0SCS0)
NOR_WPZ: NOR1.9(W\/VPP/DQ2) R530.2 U7.18(PG1)
P0_CLKSEL: PHY1.H8(SEL_FREQ) R726.1 R735.2
P0_COL_PD: PHY1.B6(COL) R709.2
P0_CONFIG0: PHY1.D8(CONFIG0) R730.2
P0_CONFIG1: PHY1.E9(CONFIG1) R738.2
P0_CONFIG2: PHY1.F8(CONFIG2) R728.2
P0_CONFIG3: PHY1.G7(CONFIG3) R729.2
P0_CONFIG4: PHY1.F9(CONFIG4) R737.2
P0_CONFIG5: PHY1.G9(CONFIG5) R736.2
P0_CONFIG6: PHY1.G8(CONFIG6) R727.2
P0_RSET: PHY1.M2(RSET) R678.1
P1_CLKSEL: PHY2.H8(SEL_FREQ) R643.1 R652.2
P1_COL_PD: PHY2.B6(COL) R631.2
P1_CONFIG0: PHY2.D8(CONFIG0) R647.2
P1_CONFIG1: PHY2.E9(CONFIG1) R655.2
P1_CONFIG2: PHY2.F8(CONFIG2) R645.2
P1_CONFIG3: PHY2.G7(CONFIG3) R646.2
P1_CONFIG4: PHY2.F9(CONFIG4) R654.2
P1_CONFIG5: PHY2.G9(CONFIG5) R653.2
P1_CONFIG6: PHY2.G8(CONFIG6) R644.2
P1_RSET: PHY2.M2(RSET) R602.1
PAPLLOBSCLKN: TP92.1 U24.AT34(PAPLLOBSCLKN)
PAPLLOBSCLKP: TP90.1 U24.AU34(PAPLLOBSCLKP)
PASS_CLKN: C312.1 U14.21(Y2_N)
PASS_CLKP: C309.1 U14.20(Y2_P)
PASSCLKN_C: C312.2 U24.AV34(PASSCLKN)
PASSCLKP_C: C309.2 U24.AV33(PASSCLKP)
PCIE_CLKN: C167.1 U19.25(Y4_N)
PCIE_CLKN_R: C167.2 R295.2 R296.1 U20.6(D\I\F\_\I\N\2\)
PCIE_CLKP: C166.1 U19.26(Y4_P)
PCIE_CLKP_R: C166.2 R292.2 R295.1 U20.5(DIF_IN2)
PCIE_REF_CLK_N: AMC1.81(FCLKA-) R282.1 U20.3(D\I\F\_\I\N\1\)
PCIE_REF_CLK_P: AMC1.80(FCLKA+) R282.2 U20.2(DIF_IN1)
PCIECLK_MCU_PD: R86.2 R274.1 U20.4(P\D\)
PCIECLK_MUX_SEL: R275.1 R276.2 U7.76(PH4) U20.16(SEL)
PCIECLK_OE: R75.2 R304.1 U20.7(OE)
PCIECLKN_C: C307.2 U24.AW32(PCIECLKN)
PCIECLKN_M: C307.1 R286.1 R287.1 R288.1
PCIECLKN_MR: R286.2 U20.14(D\I\F\_\0\)
PCIECLKP_C: C302.2 U24.AW31(PCIECLKP)
PCIECLKP_M: C302.1 R278.1 R279.1 R288.2
PCIECLKP_MR: R278.2 U20.15(DIF_0)
PHY1_INT#: PHY1.L1(I\N\T\) R568.2 R679.1
PHY2_INT#: PHY2.L1(I\N\T\) R603.1 R801.2
PHY_P0_XTAL1: PHY1.H9(XTAL1) R725.2
PHY_P0_XTAL1_R: C719.1 R725.1 Y4.1
PHY_P0_XTAL2: C718.1 PHY1.J9(XTAL2) Y4.2
PHY_P1_XTAL1: PHY2.H9(XTAL1) R642.2
PHY_P1_XTAL1_R: C570.1 R642.1 Y3.1
PHY_P1_XTAL2: C569.1 PHY2.J9(XTAL2) Y3.2
PHY_RSTZ: R588.2 R589.2 R659.2 R660.2 U7.1(PE7)
PHYSYNC: AMC1.154(RX19+) CN17.8 R617.1 U24.AP34(PHYSYNC)
PLL_LOCK1: U14.46(STATUS0) U53.4(GPB3)
PLL_LOCK2: U15.46(STATUS0) U53.5(GPB4)
PLL_LOCK3: U19.46(STATUS0) U53.6(GPB5)
PLLLOCK_LED: R504.1 U50.26(GPA5)
PMBUS_ALERT: PMBUS1.3 R179.1 R270.2 U7.40(PG5) U16.27(PMBUS_ALERT) U25.27(PMBUS_ALERT)
PMBUS_CLK: PMBUS1.1 R248.2 R580.2 U13.8(PMBUS_CLK) U16.15(PMBUS_CLK) U25.15(PMBUS_CLK)
PMBUS_CTL: PMBUS1.4 R162.1 U7.41(PG4)
PMBUS_DAT: PMBUS1.2 R249.2 R579.2 U13.9(PMBUS_DATA) U16.16(PMBUS_DATA) U25.16(PMBUS_DATA)
PW_SEQ_I2C_EN: U7.5(PE5) U22.5(EN)
PW_SEQ_RSTZ: C131.2 R581.1 U7.2(PE6) U13.3(R\E\S\E\T\)
PW_SEQ_SCL: R580.1 U22.7(SCLB)
PW_SEQ_SDA: R579.1 U22.6(SDAB)
R_P0_LAN_RSTZ: PHY1.K3(R\E\S\E\T\) R660.1
R_P1_LAN_RSTZ: PHY2.K3(R\E\S\E\T\) R589.1
RADSYNC: AMC1.153(RX19-) CN17.6 R616.1 U24.AM30(RADSYNC)
REFCK_N: C139.1 U14.28(Y5_N)
REFCK_N_C: C139.2 R240.1 U15.9(PRI_REFN)
REFCK_P: C138.1 U14.29(Y5_P)
REFCK_P_C: C138.2 R239.1 U15.8(PRI_REFP)
REFCLK1_PD#: R815.1 U14.43(PDN) U53.1(GPB0)
REFCLK2_PD#: R816.1 U15.43(PDN) U53.2(GPB1)
REFCLK3_PD#: R817.1 U19.43(PDN) U53.3(GPB2)
RP1CLKN_C: C499.2 U24.AP2(RP1CLKN)
RP1CLKP_C: C500.2 U24.AR2(RP1CLKP)
RP1FBN: C184.2 R319.2 R321.1 U24.AT1(RP1FBN)
RP1FBP: C170.2 R307.2 R308.1 U24.AR1(RP1FBP)
RS232_RX: MCU.4 U56.8(RIN)
RS232_TX: MCU.3 U56.13(DOUT)
RSV_CLKN: CN3.110 U14.22(Y3_N)
RSV_CLKP: CN3.112 U14.23(Y3_P)
SIM_CLK: SIM1.C3 U33.11(SIM_CLK)
SIM_EN: C338.1 R430.2 SIM1.SW2 U33.1(EN)
SIM_IO: R408.1 SIM1.C7 U33.8(SIM_I/O)
SIM_RST: SIM1.C2 U33.9(SIM_RST)
SIM_SEL: CN21.2 U33.2(SEL)
SIM_VCC: C322.1 C329.1 R408.2 SIM1.C1 U33.7(VSIM)
SMB_SCL_IPMBL: AMC1.56(SCL_L) R518.1 U7.72(PB2/I2C0SCL)
SMB_SDA_IPMBL: AMC1.71(SDA_L) R526.1 U7.65(PB3/I2C0SDA)
SOC_BOOTCOMPLETE: U24.AF5(BOOTCOMPLETE) U47.27(GPA6)
SOC_CORECLKSEL: R622.2 U47.21(GPA0)
SOC_CORESEL0: U24.F24(CORESEL0) U47.1(GPB0)
SOC_CORESEL1: U24.E24(CORESEL1) U47.2(GPB1)
SOC_CORESEL2: U24.D24(CORESEL2) U47.3(GPB2)
SOC_CORESEL3: U24.G24(CORESEL3) U47.4(GPB3)
SOC_DDR3A_EA0: DIMM1.107(A0) U24.E8(DDR3AA00)
SOC_DDR3A_EA1: DIMM1.105(A1) U24.G9(DDR3AA01)
SOC_DDR3A_EA2: DIMM1.106(A2) U24.G8(DDR3AA02)
SOC_DDR3A_EA3: DIMM1.103(A3) U24.G10(DDR3AA03)
SOC_DDR3A_EA4: DIMM1.104(A4) U24.F9(DDR3AA04)
SOC_DDR3A_EA5: DIMM1.99(A5) U24.F8(DDR3AA05)
SOC_DDR3A_EA6: DIMM1.100(A6) U24.C9(DDR3AA06)
SOC_DDR3A_EA7: DIMM1.98(A7) U24.D9(DDR3AA07)
SOC_DDR3A_EA8: DIMM1.97(A8) U24.B9(DDR3AA08)
SOC_DDR3A_EA9: DIMM1.92(A9) U24.D8(DDR3AA09)
SOC_DDR3A_EA10: DIMM1.117(A10/AP) U24.F10(DDR3AA10)
SOC_DDR3A_EA11: DIMM1.96(A11) U24.A9(DDR3AA11)
SOC_DDR3A_EA12: DIMM1.95(A12/B\C\) U24.E10(DDR3AA12)
SOC_DDR3A_EA13: DIMM1.130(A13) U24.A10(DDR3AA13)
SOC_DDR3A_EA14: DIMM1.90(A14) U24.B10(DDR3AA14)
SOC_DDR3A_EA15: DIMM1.88(A15) U24.D10(DDR3AA15)
SOC_DDR3A_EBA_0: DIMM1.119(BA0) U24.B11(DDR3ABA0)
SOC_DDR3A_EBA_1: DIMM1.108(BA1) U24.C11(DDR3ABA1)
SOC_DDR3A_EBA_2: DIMM1.91(BA2) U24.G11(DDR3ABA2)
SOC_DDR3A_ECAS#: DIMM1.125(C\A\S\) U24.C13(D\D\R\3\A\C\A\S\)
SOC_DDR3A_ECC0: DIMM1.69(CB0) U24.A16(DDR3ACB00)
SOC_DDR3A_ECC1: DIMM1.71(CB1) U24.C15(DDR3ACB01)
SOC_DDR3A_ECC2: DIMM1.81(CB2) U24.B16(DDR3ACB02)
SOC_DDR3A_ECC3: DIMM1.83(CB3) U24.F15(DDR3ACB03)
SOC_DDR3A_ECC4: DIMM1.72(CB4) U24.D15(DDR3ACB04)
SOC_DDR3A_ECC5: DIMM1.74(CB5) U24.F14(DDR3ACB05)
SOC_DDR3A_ECC6: DIMM1.80(CB6) U24.D14(DDR3ACB06)
SOC_DDR3A_ECC7: DIMM1.82(CB7) U24.G15(DDR3ACB07)
SOC_DDR3A_ECKE_0: DIMM1.87(CKE0) U24.G12(DDR3ACKE0)
SOC_DDR3A_ECKE_1: DIMM1.89(CKE1) U24.A11(DDR3ACKE1)
SOC_DDR3A_ECKN_0: DIMM1.113(C\K\0\) U24.B12(DDR3ACLKOUTN0)
SOC_DDR3A_ECKN_1: DIMM1.114(C\K\1\) U24.B13(DDR3ACLKOUTN1)
SOC_DDR3A_ECKP_0: DIMM1.111(CK0) U24.A12(DDR3ACLKOUTP0)
SOC_DDR3A_ECKP_1: DIMM1.112(CK1) U24.A13(DDR3ACLKOUTP1)
SOC_DDR3A_ECS_0#: DIMM1.127(C\S\0\) U24.D11(D\D\R\3\A\C\E\0\)
SOC_DDR3A_ECS_1#: DIMM1.129(C\S\1\) U24.F11(D\D\R\3\A\C\E\1\)
SOC_DDR3A_EDM_0: DIMM1.11(DM0) U24.C2(DDR3ADQM0)
SOC_DDR3A_EDM_1: DIMM1.28(DM1) U24.F3(DDR3ADQM1)
SOC_DDR3A_EDM_2: DIMM1.44(DM2) U24.A6(DDR3ADQM2)
SOC_DDR3A_EDM_3: DIMM1.59(DM3) U24.E6(DDR3ADQM3)
SOC_DDR3A_EDM_4: DIMM1.140(DM4) U24.C17(DDR3ADQM4)
SOC_DDR3A_EDM_5: DIMM1.157(DM5) U24.A18(DDR3ADQM5)
SOC_DDR3A_EDM_6: DIMM1.172(DM6) U24.D21(DDR3ADQM6)
SOC_DDR3A_EDM_7: DIMM1.189(DM7) U24.A22(DDR3ADQM7)
SOC_DDR3A_EDM_8: DIMM1.76(DM8) U24.E14(DDR3ADQM8)
SOC_DDR3A_EDQ0: DIMM1.5(DQ0) U24.G1(DDR3AD00)
SOC_DDR3A_EDQ1: DIMM1.7(DQ1) U24.H2(DDR3AD01)
SOC_DDR3A_EDQ2: DIMM1.13(DQ2) U24.F1(DDR3AD02)
SOC_DDR3A_EDQ3: DIMM1.15(DQ3) U24.G2(DDR3AD03)
SOC_DDR3A_EDQ4: DIMM1.4(DQ4) U24.H1(DDR3AD04)
SOC_DDR3A_EDQ5: DIMM1.6(DQ5) U24.E2(DDR3AD05)
SOC_DDR3A_EDQ6: DIMM1.16(DQ6) U24.F2(DDR3AD06)
SOC_DDR3A_EDQ7: DIMM1.18(DQ7) U24.D2(DDR3AD07)
SOC_DDR3A_EDQ8: DIMM1.19(DQ8) U24.E4(DDR3AD08)
SOC_DDR3A_EDQ9: DIMM1.21(DQ9) U24.F4(DDR3AD09)
SOC_DDR3A_EDQ10: DIMM1.31(DQ10) U24.G3(DDR3AD10)
SOC_DDR3A_EDQ11: DIMM1.33(DQ11) U24.A4(DDR3AD11)
SOC_DDR3A_EDQ12: DIMM1.22(DQ12) U24.B4(DDR3AD12)
SOC_DDR3A_EDQ13: DIMM1.24(DQ13) U24.H3(DDR3AD13)
SOC_DDR3A_EDQ14: DIMM1.34(DQ14) U24.D3(DDR3AD14)
SOC_DDR3A_EDQ15: DIMM1.36(DQ15) U24.D4(DDR3AD15)
SOC_DDR3A_EDQ16: DIMM1.37(DQ16) U24.G4(DDR3AD16)
SOC_DDR3A_EDQ17: DIMM1.39(DQ17) U24.H5(DDR3AD17)
SOC_DDR3A_EDQ18: DIMM1.49(DQ18) U24.D5(DDR3AD18)
SOC_DDR3A_EDQ19: DIMM1.51(DQ19) U24.F5(DDR3AD19)
SOC_DDR3A_EDQ20: DIMM1.40(DQ20) U24.G5(DDR3AD20)
SOC_DDR3A_EDQ21: DIMM1.42(DQ21) U24.D6(DDR3AD21)
SOC_DDR3A_EDQ22: DIMM1.48(DQ22) U24.C5(DDR3AD22)
SOC_DDR3A_EDQ23: DIMM1.50(DQ23) U24.B6(DDR3AD23)
SOC_DDR3A_EDQ24: DIMM1.55(DQ24) U24.C7(DDR3AD24)
SOC_DDR3A_EDQ25: DIMM1.57(DQ25) U24.F7(DDR3AD25)
SOC_DDR3A_EDQ26: DIMM1.63(DQ26) U24.F6(DDR3AD26)
SOC_DDR3A_EDQ27: DIMM1.65(DQ27) U24.A8(DDR3AD27)
SOC_DDR3A_EDQ28: DIMM1.54(DQ28) U24.B8(DDR3AD28)
SOC_DDR3A_EDQ29: DIMM1.56(DQ29) U24.G6(DDR3AD29)
SOC_DDR3A_EDQ30: DIMM1.66(DQ30) U24.G7(DDR3AD30)
SOC_DDR3A_EDQ31: DIMM1.68(DQ31) U24.D7(DDR3AD31)
SOC_DDR3A_EDQ32: DIMM1.133(DQ32) U24.E16(DDR3AD32)
SOC_DDR3A_EDQ33: DIMM1.135(DQ33) U24.G16(DDR3AD33)
SOC_DDR3A_EDQ34: DIMM1.145(DQ34) U24.F16(DDR3AD34)
SOC_DDR3A_EDQ35: DIMM1.147(DQ35) U24.G17(DDR3AD35)
SOC_DDR3A_EDQ36: DIMM1.134(DQ36) U24.D16(DDR3AD36)
SOC_DDR3A_EDQ37: DIMM1.136(DQ37) U24.D17(DDR3AD37)
SOC_DDR3A_EDQ38: DIMM1.142(DQ38) U24.F17(DDR3AD38)
SOC_DDR3A_EDQ39: DIMM1.144(DQ39) U24.E18(DDR3AD39)
SOC_DDR3A_EDQ40: DIMM1.151(DQ40) U24.C19(DDR3AD40)
SOC_DDR3A_EDQ41: DIMM1.153(DQ41) U24.D19(DDR3AD41)
SOC_DDR3A_EDQ42: DIMM1.159(DQ42) U24.G18(DDR3AD42)
SOC_DDR3A_EDQ43: DIMM1.161(DQ43) U24.F19(DDR3AD43)
SOC_DDR3A_EDQ44: DIMM1.148(DQ44) U24.G19(DDR3AD44)
SOC_DDR3A_EDQ45: DIMM1.150(DQ45) U24.B18(DDR3AD45)
SOC_DDR3A_EDQ46: DIMM1.160(DQ46) U24.D18(DDR3AD46)
SOC_DDR3A_EDQ47: DIMM1.162(DQ47) U24.F18(DDR3AD47)
SOC_DDR3A_EDQ48: DIMM1.165(DQ48) U24.A20(DDR3AD48)
SOC_DDR3A_EDQ49: DIMM1.167(DQ49) U24.B20(DDR3AD49)
SOC_DDR3A_EDQ50: DIMM1.177(DQ50) U24.D20(DDR3AD50)
SOC_DDR3A_EDQ51: DIMM1.179(DQ51) U24.G20(DDR3AD51)
SOC_DDR3A_EDQ52: DIMM1.166(DQ52) U24.C21(DDR3AD52)
SOC_DDR3A_EDQ53: DIMM1.168(DQ53) U24.E20(DDR3AD53)
SOC_DDR3A_EDQ54: DIMM1.174(DQ54) U24.F20(DDR3AD54)
SOC_DDR3A_EDQ55: DIMM1.176(DQ55) U24.G21(DDR3AD55)
SOC_DDR3A_EDQ56: DIMM1.183(DQ56) U24.C23(DDR3AD56)
SOC_DDR3A_EDQ57: DIMM1.185(DQ57) U24.G22(DDR3AD57)
SOC_DDR3A_EDQ58: DIMM1.191(DQ58) U24.D23(DDR3AD58)
SOC_DDR3A_EDQ59: DIMM1.193(DQ59) U24.F22(DDR3AD59)
SOC_DDR3A_EDQ60: DIMM1.180(DQ60) U24.E22(DDR3AD60)
SOC_DDR3A_EDQ61: DIMM1.182(DQ61) U24.B22(DDR3AD61)
SOC_DDR3A_EDQ62: DIMM1.192(DQ62) U24.F21(DDR3AD62)
SOC_DDR3A_EDQ63: DIMM1.194(DQ63) U24.D22(DDR3AD63)
SOC_DDR3A_EDQSN_0: DIMM1.10(D\Q\S\0\) U24.D1(DDR3ADQS0N)
SOC_DDR3A_EDQSN_1: DIMM1.25(D\Q\S\1\) U24.C3(DDR3ADQS1N)
SOC_DDR3A_EDQSN_2: DIMM1.43(D\Q\S\2\) U24.B5(DDR3ADQS2N)
SOC_DDR3A_EDQSN_3: DIMM1.60(D\Q\S\3\) U24.A7(DDR3ADQS3N)
SOC_DDR3A_EDQSN_4: DIMM1.139(D\Q\S\4\) U24.B17(DDR3ADQS4N)
SOC_DDR3A_EDQSN_5: DIMM1.154(D\Q\S\5\) U24.A19(DDR3ADQS5N)
SOC_DDR3A_EDQSN_6: DIMM1.171(D\Q\S\6\) U24.B21(DDR3ADQS6N)
SOC_DDR3A_EDQSN_7: DIMM1.186(D\Q\S\7\) U24.B23(DDR3ADQS7N)
SOC_DDR3A_EDQSN_8: DIMM1.75(D\Q\S\8\) U24.A15(DDR3ADQS8N)
SOC_DDR3A_EDQSP_0: DIMM1.12(DQS0) U24.E1(DDR3ADQS0P)
SOC_DDR3A_EDQSP_1: DIMM1.27(DQS1) U24.B3(DDR3ADQS1P)
SOC_DDR3A_EDQSP_2: DIMM1.45(DQS2) U24.A5(DDR3ADQS2P)
SOC_DDR3A_EDQSP_3: DIMM1.62(DQS3) U24.B7(DDR3ADQS3P)
SOC_DDR3A_EDQSP_4: DIMM1.141(DQS4) U24.A17(DDR3ADQS4P)
SOC_DDR3A_EDQSP_5: DIMM1.156(DQS5) U24.B19(DDR3ADQS5P)
SOC_DDR3A_EDQSP_6: DIMM1.173(DQS6) U24.A21(DDR3ADQS6P)
SOC_DDR3A_EDQSP_7: DIMM1.188(DQS7) U24.A23(DDR3ADQS7P)
SOC_DDR3A_EDQSP_8: DIMM1.77(DQS8) U24.B15(DDR3ADQS8P)
SOC_DDR3A_EMRESETN: DIMM1.30(R\E\S\E\T\) R648.1 U24.B14(D\D\R\3\A\R\E\S\E\T\)
SOC_DDR3A_EODT_0: DIMM1.126(ODT0) U24.E12(DDR3AODT0)
SOC_DDR3A_EODT_1: DIMM1.128(ODT1) U24.G13(DDR3AODT1)
SOC_DDR3A_ERAS#: DIMM1.122(R\A\S\) U24.A14(D\D\R\3\A\R\A\S\)
SOC_DDR3A_EWE#: DIMM1.121(W\E\) U24.F12(D\D\R\3\A\W\E\)
SOC_DDR3B_EA0: R464.1 U24.AA32(DDR3BA00) U39.N3(A0) U40.N3(A0) U41.N3(A0) U42.N3(A0) U43.N3(A0)
SOC_DDR3B_EA1: R790.1 U24.W33(DDR3BA01) U39.P7(A1) U40.P7(A1) U41.P7(A1) U42.P7(A1) U43.P7(A1)
SOC_DDR3B_EA2: R782.1 U24.W32(DDR3BA02) U39.P3(A2) U40.P3(A2) U41.P3(A2) U42.P3(A2) U43.P3(A2)
SOC_DDR3B_EA3: R462.1 U24.Y34(DDR3BA03) U39.N2(A3) U40.N2(A3) U41.N2(A3) U42.N2(A3) U43.N2(A3)
SOC_DDR3B_EA4: R781.1 U24.W34(DDR3BA04) U39.P8(A4) U40.P8(A4) U41.P8(A4) U42.P8(A4) U43.P8(A4)
SOC_DDR3B_EA5: R792.1 U24.V34(DDR3BA05) U39.P2(A5) U40.P2(A5) U41.P2(A5) U42.P2(A5) U43.P2(A5)
SOC_DDR3B_EA6: R463.1 U24.W36(DDR3BA06) U39.R8(A6) U40.R8(A6) U41.R8(A6) U42.R8(A6) U43.R8(A6)
SOC_DDR3B_EA7: R467.1 U24.W37(DDR3BA07) U39.R2(A7) U40.R2(A7) U41.R2(A7) U42.R2(A7) U43.R2(A7)
SOC_DDR3B_EA8: R788.1 U24.AA33(DDR3BA08) U39.T8(A8) U40.T8(A8) U41.T8(A8) U42.T8(A8) U43.T8(A8)
SOC_DDR3B_EA9: R795.1 U24.Y32(DDR3BA09) U39.R3(A9) U40.R3(A9) U41.R3(A9) U42.R3(A9) U43.R3(A9)
SOC_DDR3B_EA10: R455.1 U24.Y38(DDR3BA10) U39.L7(A10/AP) U40.L7(A10/AP) U41.L7(A10/AP) U42.L7(A10/AP) U43.L7(A10/AP)
SOC_DDR3B_EA11: R789.1 U24.AA39(DDR3BA11) U39.R7(A11) U40.R7(A11) U41.R7(A11) U42.R7(A11) U43.R7(A11)
SOC_DDR3B_EA12: R458.1 U24.Y35(DDR3BA12) U39.N7(A12/B\C\) U40.N7(A12/B\C\) U41.N7(A12/B\C\) U42.N7(A12/B\C\) U43.N7(A12/B\C\)
SOC_DDR3B_EA13: R794.1 U24.Y39(DDR3BA13) U39.T3(A13) U40.T3(A13) U41.T3(A13) U42.T3(A13) U43.T3(A13)
SOC_DDR3B_EA14: R466.1 U24.AA38(DDR3BA14) U39.T7(A14) U40.T7(A14) U41.T7(A14) U42.T7(A14) U43.T7(A14)
SOC_DDR3B_EA15: R444.1 U24.Y36(DDR3BA15) U39.M7(NC_5) U40.M7(NC_5) U41.M7(NC_5) U42.M7(NC_5) U43.M7(NC_5)
SOC_DDR3B_EBA_0: R775.1 U24.AA37(DDR3BBA0) U39.M2(BA0) U40.M2(BA0) U41.M2(BA0) U42.M2(BA0) U43.M2(BA0)
SOC_DDR3B_EBA_1: R465.1 U24.AA34(DDR3BBA1) U39.N8(BA1) U40.N8(BA1) U41.N8(BA1) U42.N8(BA1) U43.N8(BA1)
SOC_DDR3B_EBA_2: R454.1 U24.AB35(DDR3BBA2) U39.M3(BA2) U40.M3(BA2) U41.M3(BA2) U42.M3(BA2) U43.M3(BA2)
SOC_DDR3B_ECAS#: R457.1 U24.AC36(D\D\R\3\B\C\A\S\) U39.K3(C\A\S\) U40.K3(C\A\S\) U41.K3(C\A\S\) U42.K3(C\A\S\) U43.K3(C\A\S\)
SOC_DDR3B_ECC0: U24.AF32(DDR3BCB00) U41.E3(DQL0)
SOC_DDR3B_ECC1: U24.AF34(DDR3BCB01) U41.F7(DQL1)
SOC_DDR3B_ECC2: U24.AE32(DDR3BCB02) U41.F2(DQL2)
SOC_DDR3B_ECC3: U24.AF35(DDR3BCB03) U41.F8(DQL3)
SOC_DDR3B_ECC4: U24.AE33(DDR3BCB04) U41.H3(DQL4)
SOC_DDR3B_ECC5: U24.AE36(DDR3BCB05) U41.H8(DQL5)
SOC_DDR3B_ECC6: U24.AD36(DDR3BCB06) U41.G2(DQL6)
SOC_DDR3B_ECC7: U24.AE34(DDR3BCB07) U41.H7(DQL7)
SOC_DDR3B_ECKE_0: R772.1 U24.AB39(DDR3BCKE0) U39.K9(CKE) U40.K9(CKE) U41.K9(CKE) U42.K9(CKE) U43.K9(CKE)
SOC_DDR3B_ECKN_0: R443.1 U24.AD39(DDR3BCLKOUTN0) U39.K7(C\K\) U40.K7(C\K\) U41.K7(C\K\) U42.K7(C\K\) U43.K7(C\K\)
SOC_DDR3B_ECKP_0: R445.1 U24.AD38(DDR3BCLKOUTP0) U39.J7(CK) U40.J7(CK) U41.J7(CK) U42.J7(CK) U43.J7(CK)
SOC_DDR3B_ECS_0#: R786.1 U24.AB34(D\D\R\3\B\C\E\0\) U39.L2(C\S\) U40.L2(C\S\) U41.L2(C\S\) U42.L2(C\S\) U43.L2(C\S\)
SOC_DDR3B_EDM_0: U24.N39(DDR3BDQM0) U43.E7(DML)
SOC_DDR3B_EDM_1: U24.P34(DDR3BDQM1) U43.D3(DMU)
SOC_DDR3B_EDM_2: U24.U39(DDR3BDQM2) U42.E7(DML)
SOC_DDR3B_EDM_3: U24.U32(DDR3BDQM3) U42.D3(DMU)
SOC_DDR3B_EDM_4: U24.AG33(DDR3BDQM4) U40.E7(DML)
SOC_DDR3B_EDM_5: U24.AG39(DDR3BDQM5) U40.D3(DMU)
SOC_DDR3B_EDM_6: U24.AK34(DDR3BDQM6) U39.E7(DML)
SOC_DDR3B_EDM_7: U24.AM39(DDR3BDQM7) U39.D3(DMU)
SOC_DDR3B_EDM_8: U24.AE37(DDR3BDQM8) U41.E7(DML)
SOC_DDR3B_EDQ0: U24.L38(DDR3BD00) U43.E3(DQL0)
SOC_DDR3B_EDQ1: U24.N34(DDR3BD01) U43.F7(DQL1)
SOC_DDR3B_EDQ2: U24.M37(DDR3BD02) U43.F2(DQL2)
SOC_DDR3B_EDQ3: U24.L39(DDR3BD03) U43.F8(DQL3)
SOC_DDR3B_EDQ4: U24.N33(DDR3BD04) U43.H3(DQL4)
SOC_DDR3B_EDQ5: U24.N37(DDR3BD05) U43.H8(DQL5)
SOC_DDR3B_EDQ6: U24.N36(DDR3BD06) U43.G2(DQL6)
SOC_DDR3B_EDQ7: U24.N38(DDR3BD07) U43.H7(DQL7)
SOC_DDR3B_EDQ8: U24.T32(DDR3BD08) U43.D7(DQU0)
SOC_DDR3B_EDQ9: U24.R32(DDR3BD09) U43.C3(DQU1)
SOC_DDR3B_EDQ10: U24.P35(DDR3BD10) U43.C8(DQU2)
SOC_DDR3B_EDQ11: U24.R39(DDR3BD11) U43.C2(DQU3)
SOC_DDR3B_EDQ12: U24.R38(DDR3BD12) U43.A7(DQU4)
SOC_DDR3B_EDQ13: U24.N32(DDR3BD13) U43.A2(DQU5)
SOC_DDR3B_EDQ14: U24.R33(DDR3BD14) U43.B8(DQU6)
SOC_DDR3B_EDQ15: U24.P36(DDR3BD15) U43.A3(DQU7)
SOC_DDR3B_EDQ16: U24.T34(DDR3BD16) U42.E3(DQL0)
SOC_DDR3B_EDQ17: U24.R34(DDR3BD17) U42.F7(DQL1)
SOC_DDR3B_EDQ18: U24.T35(DDR3BD18) U42.F2(DQL2)
SOC_DDR3B_EDQ19: U24.R37(DDR3BD19) U42.F8(DQL3)
SOC_DDR3B_EDQ20: U24.R36(DDR3BD20) U42.H3(DQL4)
SOC_DDR3B_EDQ21: U24.U37(DDR3BD21) U42.H8(DQL5)
SOC_DDR3B_EDQ22: U24.T36(DDR3BD22) U42.G2(DQL6)
SOC_DDR3B_EDQ23: U24.U38(DDR3BD23) U42.H7(DQL7)
SOC_DDR3B_EDQ24: U24.V35(DDR3BD24) U42.D7(DQU0)
SOC_DDR3B_EDQ25: U24.U36(DDR3BD25) U42.C3(DQU1)
SOC_DDR3B_EDQ26: U24.U34(DDR3BD26) U42.C8(DQU2)
SOC_DDR3B_EDQ27: U24.W38(DDR3BD27) U42.C2(DQU3)
SOC_DDR3B_EDQ28: U24.W39(DDR3BD28) U42.A7(DQU4)
SOC_DDR3B_EDQ29: U24.U33(DDR3BD29) U42.A2(DQU5)
SOC_DDR3B_EDQ30: U24.V32(DDR3BD30) U42.B8(DQU6)
SOC_DDR3B_EDQ31: U24.V36(DDR3BD31) U42.A3(DQU7)
SOC_DDR3B_EDQ32: U24.AG37(DDR3BD32) U40.E3(DQL0)
SOC_DDR3B_EDQ33: U24.AF36(DDR3BD33) U40.F7(DQL1)
SOC_DDR3B_EDQ34: U24.AG38(DDR3BD34) U40.F2(DQL2)
SOC_DDR3B_EDQ35: U24.AG34(DDR3BD35) U40.F8(DQL3)
SOC_DDR3B_EDQ36: U24.AG36(DDR3BD36) U40.H3(DQL4)
SOC_DDR3B_EDQ37: U24.AH34(DDR3BD37) U40.H8(DQL5)
SOC_DDR3B_EDQ38: U24.AH35(DDR3BD38) U40.G2(DQL6)
SOC_DDR3B_EDQ39: U24.AG32(DDR3BD39) U40.H7(DQL7)
SOC_DDR3B_EDQ40: U24.AH32(DDR3BD40) U40.D7(DQU0)
SOC_DDR3B_EDQ41: U24.AJ33(DDR3BD41) U40.C3(DQU1)
SOC_DDR3B_EDQ42: U24.AH36(DDR3BD42) U40.C8(DQU2)
SOC_DDR3B_EDQ43: U24.AJ34(DDR3BD43) U40.C2(DQU3)
SOC_DDR3B_EDQ44: U24.AJ36(DDR3BD44) U40.A7(DQU4)
SOC_DDR3B_EDQ45: U24.AH39(DDR3BD45) U40.A2(DQU5)
SOC_DDR3B_EDQ46: U24.AH38(DDR3BD46) U40.B8(DQU6)
SOC_DDR3B_EDQ47: U24.AJ37(DDR3BD47) U40.A3(DQU7)
SOC_DDR3B_EDQ48: U24.AK39(DDR3BD48) U39.E3(DQL0)
SOC_DDR3B_EDQ49: U24.AK38(DDR3BD49) U39.F7(DQL1)
SOC_DDR3B_EDQ50: U24.AK36(DDR3BD50) U39.F2(DQL2)
SOC_DDR3B_EDQ51: U24.AK35(DDR3BD51) U39.F8(DQL3)
SOC_DDR3B_EDQ52: U24.AL34(DDR3BD52) U39.H3(DQL4)
SOC_DDR3B_EDQ53: U24.AL36(DDR3BD53) U39.H8(DQL5)
SOC_DDR3B_EDQ54: U24.AL37(DDR3BD54) U39.G2(DQL6)
SOC_DDR3B_EDQ55: U24.AL33(DDR3BD55) U39.H7(DQL7)
SOC_DDR3B_EDQ56: U24.AN34(DDR3BD56) U39.D7(DQU0)
SOC_DDR3B_EDQ57: U24.AN36(DDR3BD57) U39.C3(DQU1)
SOC_DDR3B_EDQ58: U24.AN33(DDR3BD58) U39.C8(DQU2)
SOC_DDR3B_EDQ59: U24.AM34(DDR3BD59) U39.C2(DQU3)
SOC_DDR3B_EDQ60: U24.AM35(DDR3BD60) U39.A7(DQU4)
SOC_DDR3B_EDQ61: U24.AM38(DDR3BD61) U39.A2(DQU5)
SOC_DDR3B_EDQ62: U24.AM36(DDR3BD62) U39.B8(DQU6)
SOC_DDR3B_EDQ63: U24.AN37(DDR3BD63) U39.A3(DQU7)
SOC_DDR3B_EDQSN_0: U24.M39(DDR3BDQS0N) U43.G3(D\Q\S\L\)
SOC_DDR3B_EDQSN_1: U24.P38(DDR3BDQS1N) U43.B7(D\Q\S\U\)
SOC_DDR3B_EDQSN_2: U24.T38(DDR3BDQS2N) U42.G3(D\Q\S\L\)
SOC_DDR3B_EDQSN_3: U24.V38(DDR3BDQS3N) U42.B7(D\Q\S\U\)
SOC_DDR3B_EDQSN_4: U24.AF39(DDR3BDQS4N) U40.G3(D\Q\S\L\)
SOC_DDR3B_EDQSN_5: U24.AJ38(DDR3BDQS5N) U40.B7(D\Q\S\U\)
SOC_DDR3B_EDQSN_6: U24.AL38(DDR3BDQS6N) U39.G3(D\Q\S\L\)
SOC_DDR3B_EDQSN_7: U24.AN39(DDR3BDQS7N) U39.B7(D\Q\S\U\)
SOC_DDR3B_EDQSN_8: U24.AE38(DDR3BDQS8N) U41.G3(D\Q\S\L\)
SOC_DDR3B_EDQSP_0: U24.M38(DDR3BDQS0P) U43.F3(DQSL)
SOC_DDR3B_EDQSP_1: U24.P39(DDR3BDQS1P) U43.C7(DQSU)
SOC_DDR3B_EDQSP_2: U24.T39(DDR3BDQS2P) U42.F3(DQSL)
SOC_DDR3B_EDQSP_3: U24.V39(DDR3BDQS3P) U42.C7(DQSU)
SOC_DDR3B_EDQSP_4: U24.AF38(DDR3BDQS4P) U40.F3(DQSL)
SOC_DDR3B_EDQSP_5: U24.AJ39(DDR3BDQS5P) U40.C7(DQSU)
SOC_DDR3B_EDQSP_6: U24.AL39(DDR3BDQS6P) U39.F3(DQSL)
SOC_DDR3B_EDQSP_7: U24.AN38(DDR3BDQS7P) U39.C7(DQSU)
SOC_DDR3B_EDQSP_8: U24.AE39(DDR3BDQS8P) U41.F3(DQSL)
SOC_DDR3B_EMRESETN: R470.1 U24.AC32(D\D\R\3\B\R\E\S\E\T\) U39.T2(R\E\S\E\T\) U40.T2(R\E\S\E\T\) U41.T2(R\E\S\E\T\) U42.T2(R\E\S\E\T\) U43.T2(R\E\S\E\T\)
SOC_DDR3B_EODT_0: R765.1 U24.AC33(DDR3BODT0) U39.K1(ODT) U40.K1(ODT) U41.K1(ODT) U42.K1(ODT) U43.K1(ODT)
SOC_DDR3B_ERAS#: R763.1 U24.AD32(D\D\R\3\B\R\A\S\) U39.J3(R\A\S\) U40.J3(R\A\S\) U41.J3(R\A\S\) U42.J3(R\A\S\) U43.J3(R\A\S\)
SOC_DDR3B_EWE#: R779.1 U24.AC37(D\D\R\3\B\W\E\) U39.L3(W\E\) U40.L3(W\E\) U41.L3(W\E\) U42.L3(W\E\) U43.L3(W\E\)
SOC_EMIFA00: CN3.6 U63.2(1Y1)
SOC_EMIFA01: CN3.8 U63.3(1Y2)
SOC_EMIFA02: CN3.10 U63.5(1Y3)
SOC_EMIFA03: CN3.12 U63.6(1Y4)
SOC_EMIFA04: CN3.14 U63.8(2Y1)
SOC_EMIFA05: CN3.16 U63.9(2Y2)
SOC_EMIFA06: CN3.18 U63.11(2Y3)
SOC_EMIFA07: CN3.20 U63.12(2Y4)
SOC_EMIFA08: CN3.22 U63.13(3Y1)
SOC_EMIFA09: CN3.24 U63.14(3Y2)
SOC_EMIFA10: CN3.26 U63.16(3Y3)
SOC_EMIFA11: CN3.28 U63.17(3Y4)
SOC_EMIFA12: CN3.30 U63.19(4Y1)
SOC_EMIFA13: CN3.32 U63.20(4Y2)
SOC_EMIFA14: CN3.34 U63.22(4Y3)
SOC_EMIFA15: CN3.36 U63.23(4Y4)
SOC_EMIFA16: CN3.38 U64.2(1Y1)
SOC_EMIFA17: CN3.40 U64.3(1Y2)
SOC_EMIFA18: CN3.42 U64.5(1Y3)
SOC_EMIFA19: CN3.44 U64.6(1Y4)
SOC_EMIFA20: CN3.46 U64.8(2Y1)
SOC_EMIFA21: CN3.48 U64.9(2Y2)
SOC_EMIFA22: CN3.50 U64.11(2Y3)
SOC_EMIFA23: CN3.52 U64.12(2Y4)
SOC_EMIFBE0Z: CN3.49 U64.13(3Y1)
SOC_EMIFBE1Z: CN3.51 U64.14(3Y2)
SOC_EMIFCE0Z: NAND1.C6(C\E\) R27.1 U69.2(A)
SOC_EMIFCE1Z: CN3.43 U64.16(3Y3)
SOC_EMIFCE2Z: CN3.45 U64.17(3Y4)
SOC_EMIFCE3Z: CN3.47 U64.19(4Y1)
SOC_EMIFD0: CN3.9 U65.18(B1)
SOC_EMIFD1: CN3.11 U65.17(B2)
SOC_EMIFD2: CN3.13 U65.16(B3)
SOC_EMIFD3: CN3.15 U65.15(B4)
SOC_EMIFD4: CN3.17 U65.14(B5)
SOC_EMIFD5: CN3.19 U65.13(B6)
SOC_EMIFD6: CN3.21 U65.12(B7)
SOC_EMIFD7: CN3.23 U65.11(B8)
SOC_EMIFD8: CN3.25 U68.18(B1)
SOC_EMIFD9: CN3.27 U68.17(B2)
SOC_EMIFD10: CN3.29 U68.16(B3)
SOC_EMIFD11: CN3.31 U68.15(B4)
SOC_EMIFD12: CN3.33 U68.14(B5)
SOC_EMIFD13: CN3.35 U68.13(B6)
SOC_EMIFD14: CN3.37 U68.12(B7)
SOC_EMIFD15: CN3.39 U68.11(B8)
SOC_EMIFOEZ: CN3.53 U64.22(4Y3)
SOC_EMIFRNW: CN3.65 U64.20(4Y2)
SOC_EMIFWAIT1: CN3.69 U67.2(A)
SOC_EMIFWEZ: CN3.55 U64.23(4Y4)
SOC_EMU_00: U24.AA2(EMU00) U49.17(A5)
SOC_EMU_01: U24.AB2(EMU01) U49.21(A6)
SOC_EMU_02: R47.1 U24.Y3(EMU02)
SOC_EMU_02_R: EMU1.13(PTH_17) R47.2
SOC_EMU_03: R53.2 U24.Y4(EMU03)
SOC_EMU_03_R: EMU1.17(PTH_21) R53.1
SOC_EMU_04: R520.2 U24.W3(EMU04)
SOC_EMU_04_R: EMU1.23(PTH_27) R520.1
SOC_EMU_05: R66.1 U24.W4(EMU05)
SOC_EMU_05_R: EMU1.25(PTH_29) R66.2
SOC_EMU_06: R523.1 U24.V4(EMU06)
SOC_EMU_06_R: EMU1.27(PTH_31) R523.2
SOC_EMU_07: R527.1 U24.U4(EMU07)
SOC_EMU_07_R: EMU1.29(PTH_33) R527.2
SOC_EMU_08: R71.1 U24.U3(EMU08)
SOC_EMU_08_R: EMU1.31(PTH_35) R71.2
SOC_EMU_09: R78.1 U24.T3(EMU09)
SOC_EMU_09_R: EMU1.33(PTH_37) R78.2
SOC_EMU_10: R529.1 U24.AB4(EMU10)
SOC_EMU_10_R: EMU1.35(PTH_39) R529.2
SOC_EMU_11: R532.1 U24.AA3(EMU11)
SOC_EMU_11_R: EMU1.37(PTH_41) R532.2
SOC_EMU_12: R535.1 U24.U5(EMU12)
SOC_EMU_12_R: EMU1.39(PTH_43) R535.2
SOC_EMU_13: R87.1 U24.T4(EMU13)
SOC_EMU_13_R: EMU1.41(PTH_45) R87.2
SOC_EMU_14: R539.1 U24.AB3(EMU14)
SOC_EMU_14_R: EMU1.43(PTH_47) R539.2
SOC_EMU_15: R94.1 U24.R3(EMU15)
SOC_EMU_15_R: EMU1.45(PTH_49) R94.2
SOC_EMU_16: R103.1 U24.T5(EMU16)
SOC_EMU_16_R: EMU1.47(PTH_51) R103.2
SOC_EMU_17: R109.1 U24.R4(EMU17)
SOC_EMU_17_R: EMU1.49(PTH_53) R109.2
SOC_EMU_18: R542.1 U24.AA4(EMU18)
SOC_EMU_18_R: EMU1.51(PTH_55) R542.2
SOC_EMU_19: R157.1 U24.A32(GPIO17/EMU19)
SOC_EMU_19_R: EMU1.53(PTH_57) R157.2
SOC_EMU_20: R158.1 U24.C31(GPIO18/EMU20)
SOC_EMU_20_R: EMU1.55(PTH_59) R158.2
SOC_EMU_21: R63.2 U24.B32(GPIO19/EMU21)
SOC_EMU_21_R: EMU1.18 R63.1
SOC_EMU_22: R64.1 U24.A33(GPIO20/EMU22)
SOC_EMU_22_R: EMU1.20 R64.2
SOC_EMU_23: R67.2 U24.D33(GPIO21/EMU23)
SOC_EMU_23_R: EMU1.22 R67.1
SOC_EMU_24: R68.2 U24.D31(GPIO22/EMU24)
SOC_EMU_24_R: EMU1.24 R68.1
SOC_EMU_25: R72.1 U24.B35(GPIO23/EMU25)
SOC_EMU_25_R: EMU1.26 R72.2
SOC_EMU_26: R73.1 U24.B33(GPIO24/EMU26)
SOC_EMU_26_R: EMU1.28 R73.2
SOC_EMU_27: R79.1 U24.E31(GPIO25/EMU27)
SOC_EMU_27_R: EMU1.30 R79.2
SOC_EMU_28: R80.1 U24.A34(GPIO26/EMU28)
SOC_EMU_28_R: EMU1.32 R80.2
SOC_EMU_29: R89.1 U24.D32(GPIO27/EMU29)
SOC_EMU_29_R: EMU1.34 R89.2
SOC_EMU_30: R90.1 U24.C33(GPIO28/EMU30)
SOC_EMU_30_R: EMU1.36 R90.2
SOC_EMU_31: R96.1 U24.C34(GPIO29/EMU31)
SOC_EMU_31_R: EMU1.38 R96.2
SOC_EMU_32: R97.1 U24.B36(GPIO30/EMU32)
SOC_EMU_32_R: EMU1.40 R97.2
SOC_EMU_33: R104.1 U24.B34(GPIO31/EMU33)
SOC_EMU_33_R: EMU1.42 R104.2
SOC_GPIO_00: CN3.54 R374.1 U48.21(GPA0)
SOC_GPIO_01: CN3.56 R388.1 U48.22(GPA1)
SOC_GPIO_02: CN3.66 R703.1 U48.23(GPA2)
SOC_GPIO_03: CN3.68 R396.1 U48.24(GPA3)
SOC_GPIO_04: CN3.70 R383.1 U48.25(GPA4)
SOC_GPIO_05: CN3.72 R697.1 U48.26(GPA5)
SOC_GPIO_06: CN3.74 R712.1 U48.27(GPA6)
SOC_GPIO_07: CN3.76 R387.1 U48.28(GPA7)
SOC_GPIO_08: CN3.78 R384.1 U21.6(A\/B) U48.1(GPB0)
SOC_GPIO_09: CN3.80 R708.1 U17.6(A\/B) U48.2(GPB1)
SOC_GPIO_10: CN3.82 R724.1 U30.6(A\/B) U48.3(GPB2)
SOC_GPIO_11: CN3.84 R718.1 U26.1(A) U48.4(GPB3)
SOC_GPIO_12: CN3.86 R522.1 R722.1 U48.5(GPB4)
SOC_GPIO_13: CN3.88 R391.1 R510.1 U48.6(GPB5)
SOC_GPIO_14: CN3.90 R525.1 R732.1 U48.7(GPB6)
SOC_GPIO_15: CN3.92 R76.1 R393.1 U48.8(GPB7)
SOC_GPIO_16: CN3.94 R398.1 U50.25(GPA4)
SOC_GPIO_R00: R374.2 R701.2 U24.F29(GPIO00)
SOC_GPIO_R01: R388.2 R713.2 U24.B30(GPIO01)
SOC_GPIO_R02: R702.2 R703.2 U24.D29(GPIO02)
SOC_GPIO_R03: R396.2 R734.2 U24.A35(GPIO03)
SOC_GPIO_R04: R383.2 R707.2 U24.B29(GPIO04)
SOC_GPIO_R05: R696.2 R697.2 U24.E29(GPIO05)
SOC_GPIO_R06: R389.2 R712.2 U24.D30(GPIO06)
SOC_GPIO_R07: R387.2 R711.2 U24.C30(GPIO07)
SOC_GPIO_R08: R384.2 R706.2 U24.A30(GPIO08)
SOC_GPIO_R09: R385.2 R708.2 U24.G30(GPIO09)
SOC_GPIO_R10: R723.2 R724.2 U24.F31(GPIO10)
SOC_GPIO_R11: R718.2 R720.2 U24.E30(GPIO11)
SOC_GPIO_R12: R721.2 R722.2 U24.F30(GPIO12)
SOC_GPIO_R13: R390.2 R391.2 U24.A31(GPIO13)
SOC_GPIO_R14: R731.2 R732.2 U24.E32(GPIO14)
SOC_GPIO_R15: R393.2 R394.2 U24.B31(GPIO15)
SOC_GPIO_R16: R398.2 R739.2 U24.A36(GPIO16)
SOC_HOUT: U24.AE5(HOUT) U47.23(GPA2)
SOC_I2C_EN: U7.6(PE4) U58.5(EN)
SOC_LRESETNMIENZ: U24.AD4(L\R\E\S\E\T\N\M\I\E\N\) U47.26(GPA5)
SOC_LRESETZ: U24.AE4(L\R\E\S\E\T\) U47.25(GPA4)
SOC_MDC: R405.2 U24.AP31(MDCLK) U31.3(SCL1)
SOC_MDC_3V3: J2.B9(MDCLK) PHY1.L3(MDC) PHY2.L3(MDC) R400.1 U31.6(SCL2)
SOC_MDIO: R404.2 U24.AR32(MDIO) U31.4(SDA1)
SOC_MDIO_3V3: J2.A9(MDIO) PHY1.M1(MDIO) PHY2.M1(MDIO) R399.1 U31.5(SDA2)
SOC_NMIZ: U24.AD5(N\M\I\) U47.24(GPA3)
SOC_PACLKSEL: U24.AN30(PACLKSEL) U47.22(GPA1)
SOC_PLLLOCK: U24.AK5(RSV012) U50.27(GPA6)
SOC_PORZ: C802.1 C803.1 C804.2 R629.2 U24.AK4(P\O\R\) U47.8(GPB7)
SOC_POWER_GOOD: R165.1 U7.13(PD3)
SOC_POWER_GOOD_R: R165.2 U13.25(GPIO16)
SOC_POWER_START: R192.2 U7.12(PD2)
SOC_POWER_START_R: CN7.6 R192.1 U13.23(PWM2/GPI2)
SOC_RESETFULLZ: C811.1 C812.1 C813.2 R625.2 U24.AD3(R\E\S\E\T\F\U\L\L\) U47.6(GPB5)
SOC_RESETSTATZ: R533.1 U24.AC5(R\E\S\E\T\S\T\A\T\) U47.28(GPA7)
SOC_RESETZ: C808.1 C809.1 C810.2 R620.2 U24.AD2(R\E\S\E\T\) U47.7(GPB6)
SOC_RS232_RX: SOC.4 U18.8(RIN)
SOC_RS232_TX: SOC.3 U18.13(DOUT)
SOC_SCL0: EEPROM1.6(SCL) R610.2 U24.N1(SCL0) U58.2(SCLA)
SOC_SCL1: R429.2 U24.N4(SCL1) U34.2(SCLA) U50.7(GPB6)
SOC_SCL2: R570.2 U24.P4(SCL2) U54.2(SCLA)
SOC_SCL_RTM: J1.D2(SCL) R536.1
SOC_SDA0: EEPROM1.5(SDA) R604.2 U24.P3(SDA0) U58.3(SDAA)
SOC_SDA1: R422.2 U24.N2(SDA1) U34.3(SDAA) U50.8(GPB7)
SOC_SDA2: R572.2 U24.N3(SDA2) U54.3(SDAA)
SOC_SDA_RTM: J1.D1(SDA) R541.1
SOC_SGMII0_RXN: C668.1 PHY1.A8(S_OUT-)
SOC_SGMII0_RXN_C: C668.2 U24.AW28(SGMII0RXN)
SOC_SGMII0_RXP: C686.1 PHY1.A7(S_OUT+)
SOC_SGMII0_RXP_C: C686.2 U24.AW29(SGMII0RXP)
SOC_SGMII0_TXN: C675.2 U24.AU28(SGMII0TXN)
SOC_SGMII0_TXN_C: C675.1 PHY1.A4(S_IN-)
SOC_SGMII0_TXP: C666.2 U24.AU29(SGMII0TXP)
SOC_SGMII0_TXP_C: C666.1 PHY1.A3(S_IN+)
SOC_SGMII1_RXN: C717.1 PHY2.A8(S_OUT-)
SOC_SGMII1_RXN_C: C717.2 U24.AV27(SGMII1RXN)
SOC_SGMII1_RXP: C716.1 PHY2.A7(S_OUT+)
SOC_SGMII1_RXP_C: C716.2 U24.AV28(SGMII1RXP)
SOC_SGMII1_TXN: C512.2 U24.AT27(SGMII1TXN)
SOC_SGMII1_TXN_C: C512.1 PHY2.A4(S_IN-)
SOC_SGMII1_TXP: C507.2 U24.AT28(SGMII1TXP)
SOC_SGMII1_TXP_C: C507.1 PHY2.A3(S_IN+)
SOC_SIM_CLK: U24.AN32(USIMCLK) U33.13(CLK)
SOC_SIM_IO: R714.1 U24.AP33(USIMIO) U33.15(I/O)
SOC_SIM_RST: U24.AP32(USIMRST) U33.14(RST)
SOC_SSP0_CLK: NOR1.16(SCK) R364.1
SOC_SSP0_MISO: R363.1 R558.1 U24.A26(SPI0DIN)
SOC_SSP0_MOSI: NOR1.15(DQ0) R368.1
SOC_SSP1_CLK: R402.1 U24.C28(SPI1CLK)
SOC_SSP1_CS0: R367.1 U32.12(1B2)
SOC_SSP1_MOSI: R401.1 U24.A28(SPI1DOUT)
SOC_SSP2_CLK: CN3.91 R369.2
SOC_SSP2_CS0: CN3.83 R372.2
SOC_SSP2_CS1: CN3.85 R691.2
SOC_SSP2_CS2: CN3.87 R373.2
SOC_SSP2_CS3: CN3.89 R690.2
SOC_SSP2_MISO: R55.1 U24.F28(SPI2DIN)
SOC_SSP2_MOSI: R60.1 R692.2
SOC_SSPCK_R: R364.2 U24.B26(SPI0CLK)
SOC_SSPMOSI_3.3V: U29.7(DIN) U32.7(2A2)
SOC_SSPMOSI_R: R368.2 U24.A27(SPI0DOUT)
SOC_TCK: C797.1 R798.2 U24.AE1(TCK) U49.10(A3)
SOC_TDI: U24.AG1(TDI) U49.2(A0)
SOC_TDO: U24.AF1(TDO) U49.15(A4)
SOC_TEMP1: Q6.3(VOUT) U13.48(MON10)
SOC_TIMI0: R313.1 U24.M2(TIMI0) U28.6
SOC_TIMI0_B: U28.2 U30.5(Y)
SOC_TIMI1: R312.1 U24.M1(TIMI1) U28.3(6)
SOC_TIMI1_B: U17.5(Y) U28.5(2)
SOC_TIMO0: CN3.71 R311.1 R740.1
SOC_TIMO0_R: R311.2 U24.M3(TIMO0)
SOC_TIMO1: CN3.75 CN17.4 R314.1
SOC_TIMO1_R: R314.2 U24.M4(TIMO1)
SOC_TMS: U24.AE2(TMS) U49.4(A1)
SOC_TRST#: C805.1 C806.1 C807.2 U24.AD1(T\R\S\T\) U49.8(A2)
SOC_TVD: EMU1.1(PTH_5) EMU1.12 R33.2
SOC_UART0_DETECT: R220.2 SOC.1 U55.6(A\/B)
SOC_UART0_RXD_3V3: R587.1 U55.5(Y) U57.7(2A2)
SOC_UART0_RXD_V1P8: U24.K4(UART0RXD) U57.10(2B2)
SOC_UART0_TXD_3V3: R289.1 R524.1 U3.17(ADBUS1) U18.11(DIN) U57.5(1A2)
SOC_UART0_TXD_V1P8: R315.2 U57.12(1B2)
SOC_UART1_CTS_3V3: CN3.99 U57.6(2A1)
SOC_UART1_CTS_V1P8: U24.K1(UART1CTS) U57.11(2B1)
SOC_UART1_RTS_3V3: CN3.97 U57.4(1A1)
SOC_UART1_RTS_V1P8: R619.2 U57.13(1B1)
SOC_UART1_RXD_1V8: U21.1(A) U51.10(2B2)
SOC_UART1_TXD_1V8: R316.2 U26.3(E\)
SOC_URX_3V3: U18.9(ROUT) U55.1(A)
SOC_VPPB_EN: Q2.5(EN) R28.1 U50.24(GPA3)
SOC_XFI_CLKN: R669.1 U15.16(Y1_N)
SOC_XFI_CLKN_R: R669.2 U24.AU20(XFICLKN)
SOC_XFI_CLKP: R658.1 U15.17(Y1_P)
SOC_XFI_CLKP_R: R658.2 U24.AU19(XFICLKP)
SOC_XFI_MDIO: R425.2 U24.AT33(XFIMDIO) U36.4(SDA1)
SOC_XFI_MDIO_3V3: J2.C9(XFIMDIO) R438.1 U36.5(SDA2)
SOC_XFI_RX_DN0: C241.1 J2.D2(RX0_4-)
SOC_XFI_RX_DN1: C237.1 J2.D4(RX1_4-)
