# Allegro board 19C2830503-01-JOB.brd (continued)
## Nets (continued)
SOC_XFI_RX_DP0: C238.1 J2.C2(RX0_4+)
SOC_XFI_RX_DP1: C234.1 J2.C4(RX1_4+)
SOC_XFI_RXN0_C: C241.2 U24.AV19(XFIRXN0)
SOC_XFI_RXN1_C: C237.2 U24.AW20(XFIRXN1)
SOC_XFI_RXP0_C: C238.2 U24.AV18(XFIRXP0)
SOC_XFI_RXP1_C: C234.2 U24.AW19(XFIRXP1)
SOC_XFI_TX_DN0: J2.D1(TX0_4-) U24.AT19(XFITXN0)
SOC_XFI_TX_DN1: J2.D3(TX1_4-) U24.AR20(XFITXN1)
SOC_XFI_TX_DP0: J2.C1(TX0_4+) U24.AT18(XFITXP0)
SOC_XFI_TX_DP1: J2.C3(TX1_4+) U24.AR19(XFITXP1)
SOC_XFIMD_CLK: R426.2 U24.AR34(XFIMDCLK) U36.3(SCL1)
SOC_XFIMD_CLK_3V3: J2.D9(XFIMDCLK) R439.1 U36.6(SCL2)
SOCCLKSEL_R: R622.1 U24.AL4(CORECLKSEL)
SPI1DIN: TP83.1 U24.F27(SPI1DIN)
SPI_GPIO_INT0: U7.58(PF4) U52.20(B1)
SPI_GPIO_INT0_1V8: U48.20(INTA) U52.1(A1)
SPI_GPIO_INT1: U7.46(PF5) U52.18(B2)
SPI_GPIO_INT1_1V8: U50.20(INTA) U52.3(A2)
SPI_GPIO_INT2: U7.43(PF6) U52.17(B3)
SPI_GPIO_INT2_1V8: U47.20(INTA) U52.4(A3)
SPI_GPIO_INT3: U7.42(PF7) U53.20(INTA)
SPI_GPIO_RESET: U7.37(PG6) U52.13(B7) U53.18(R\E\S\E\T\)
SPI_GPIO_RESET_1V8: U47.18(R\E\S\E\T\) U48.18(R\E\S\E\T\) U50.18(R\E\S\E\T\) U52.8(A7)
SRIO_SGMII_CLKN: C319.1 U15.15(Y0_N)
SRIO_SGMII_CLKP: C317.1 U15.14(Y0_P)
SRIOSGMIICLKN_C: C319.2 U24.AW35(SRIOSGMIICLKN)
SRIOSGMIICLKP_C: C317.2 U24.AW34(SRIOSGMIICLKP)
SW7-P1: ATT.2 R233.1
SW8-P1: PWR.2 R152.1
SW10-P1: R91.1 RST_MCU1.2
SYS_CLKN: C179.1 U14.15(Y0_N)
SYS_CLKP: C178.1 U14.14(Y0_P)
SYSCLKN_C: C179.2 U24.AK3(SYSCLKN)
SYSCLKP_C: C178.2 U24.AL3(SYSCLKP)
T_TDIS: EMU1.15(PTH_19) R54.1
TCLKB_N: AMC1.78(TCLKB-) C147.1
TCLKB_N_C: C147.2 R272.1 U19.9(PRI_REFN)
TCLKB_P: AMC1.77(TCLKB+) C149.1
TCLKB_P_C: C149.2 R273.1 U19.8(PRI_REFP)
TCLKC_N: AMC1.135(TCLKC-) R740.2
TCLKC_P: AMC1.136(TCLKC+) R742.1
TCLKD_N: AMC1.138(TCLKD-) C142.1
TCLKD_N_C: C142.2 R257.1 U14.9(PRI_REFN)
TCLKD_P: AMC1.139(TCLKD+) C141.1
TCLKD_P_C: C141.2 R256.1 U14.8(PRI_REFP)
TETRISPLLOBSCLKN: TP51.1 U24.D38(ARMPLLOBSCLKN)
TETRISPLLOBSCLKP: TP52.1 U24.C38(ARMPLLOBSCLKP)
TIMI_MUX_OEZ: U28.1 U28.7(1) U47.5(GPB4)
TRGRSTZ: EMU1.6 R56.1 U7.39(PJ2)
TRIP1: ESD1.1 ESD1.4 R2.1 R5.2 R6.2
TRIP2: ESD1.2 R1.1
TRIP3: ESD1.3 R2.2
TSCOMPOUT_E: CN3.113 CN3.116 CN17.5 CN17.7 U24.AB1(TSCOMPOUT)
TSPUSHEVT0: CN3.114 CN17.3
TSPUSHEVT0_E: CN3.109 U24.AC2(TSPUSHEVT0)
TSPUSHEVT1_E: CN3.111 U24.AC1(TSPUSHEVT1)
TSRX_CLK0N: CN3.101 U24.AP1(TSRXCLKOUT0N)
TSRX_CLK0P: CN3.103 U24.AN1(TSRXCLKOUT0P)
TSRX_CLK1N: CN3.105 U24.AP3(TSRXCLKOUT1N)
TSRX_CLK1P: CN3.107 U24.AN3(TSRXCLKOUT1P)
TSSYNCEVT_E: CN3.115 U24.AC3(TSSYNCEVT)
TX_CLK: PHY2.D1(TX_CLK) R601.2
TX_CLK_0: PHY1.D1(TX_CLK) R677.2
TX_EN: PHY2.E1(TX_EN) R600.2
TX_EN_0: PHY1.E1(TX_EN) R676.2
TX_ER: PHY2.F2(TX_ER) R591.2
TX_ER_0: PHY1.F2(TX_ER) R662.2
TXD0: PHY2.F1(TXD0) R599.2
TXD0_0: PHY1.F1(TXD0) R675.2
TXD1: PHY2.G2(TXD1) R598.2
TXD1_0: PHY1.G2(TXD1) R674.2
TXD2: PHY2.G3(TXD2) R595.2
TXD2_0: PHY1.G3(TXD2) R666.2
TXD3: PHY2.H2(TXD3) R593.2
TXD3_0: PHY1.H2(TXD3) R664.2
TXD4: PHY2.H1(TXD4) R597.2
TXD4_0: PHY1.H1(TXD4) R673.2
TXD5: PHY2.H3(TXD5) R594.2
TXD5_0: PHY1.H3(TXD5) R665.2
TXD6: PHY2.J1(TXD6) R596.2
TXD6_0: PHY1.J1(TXD6) R672.2
TXD7: PHY2.J2(TXD7) R590.2
TXD7_0: PHY1.J2(TXD7) R661.2
UART0_TXD_R: R315.1 U24.K2(UART0TXD)
UART1_RTS_R: R619.1 U24.M5(UART1RTS)
UART1_RXD_M: U21.5(Y) U24.L2(UART1RXD)
UART1_TXD_R: R316.1 U24.K3(UART1TXD)
UCD9244_EN: R245.1 R267.2
UCD9244_EN_R: R245.2 U13.4(GPIO1)
UCD_PWR_MON: R244.1 R582.2 U13.2(MON2)
UCD_PWR_OK: R244.2 R359.1 U25.24(POWER_GOOD)
URTM_PS#: R555.2 R557.1 U53.28(GPA7)
URTM_PS#_R: J1.C1(PS#) R555.1
USB0V85: B28.3(OUTPUT) C208.1 C522.1 U24.AA12(VP) U24.Y11(VPTX)
USB_CLKN: R608.1 U19.28(Y5_N)
USB_CLKN_R: R608.2 U24.V2(USBCLKM)
USB_CLKP: R607.1 U19.29(Y5_P)
USB_CLKP_R: R607.2 U24.W2(USBCLKP)
USB_DM1: D1.2(D-) FTDI_USB.2(DATA-) U3.7(DM)
USB_DP1: D1.1(D+) FTDI_USB.3(DATA+) U3.8(DP)
USB_RXN: B22.1(L1) U24.Y1(USBRX0M)
USB_RXN_R: B22.4(L4) SOC_USB.5(STDA_SSRX-)
USB_RXP: B22.2(L2) U24.W1(USBRX0P)
USB_RXP_R: B22.3(L3) SOC_USB.6(STDA_SSRX+)
USB_TXN: C839.2 U24.V1(USBTX0M)
USB_TXN_R: C839.1 SOC_USB.8(STDA_SSTX-)
USB_TXP: C840.2 U24.U1(USBTX0P)
USB_TXP_R: C840.1 SOC_USB.9(STDA_SSTX+)
USBDN: B24.2(L2) U24.T2(USBDM)
USBDN_R: B24.3(L3) D14.2(D-) SOC_USB.2(D-)
USBDP: B24.1(L1) U24.U2(USBDP)
USBDP_R: B24.4(L4) D14.1(D+) SOC_USB.3(D+)
USBDRVVBUS: R809.1 U24.L3(USBDRVVBUS)
USBDRVVBUS_R: R809.2 R813.1 U70.2(IN)
USBVBUS: R799.1 R800.2 U24.T1(USBVBUS)
USBVDD3V3: B29.3(OUTPUT) C225.1 C558.1 U24.Y13(VPH)
VCTCXO_19.2M: CN13.2 OSC3.3(OUT) TP37.1
VCTCXO_19.2M_R: CN13.1 U14.11(SEC_REFP)
VCTCXO_25M_CLKN: C121.2 CN11.2 R229.2 TP36.1
VCTCXO_25M_CLKN_C: C121.1 OSC2.5(O\U\T\)
VCTCXO_25M_CLKN_R: CN11.1 U19.12(SEC_REFN)
VCTCXO_25M_CLKP: C122.2 CN12.2 R229.1 TP34.1
VCTCXO_25M_CLKP_C: C122.1 OSC2.4(OUT)
VCTCXO_25M_CLKP_R: CN12.1 U19.11(SEC_REFP)
VID_OEZ: R262.1 R407.1 U37.14(2O\E\) U37.15(1O\E\)
VPHY1: B6.2 C25.1 C26.1 U3.4(VPHY)
VPLL1: B5.2 C20.1 C21.1 U3.9(VPLL)
VPP1V8: C23.1 C392.1 C632.1 Q2.9(OUT_1) Q2.10(OUT_2) R23.1 R234.2 TP5.1 U24.L22(VPP_01) U24.M21(VPP_02)
VPP1V8_MON: R234.1 U13.46(MON9)
WARM_RESETZ: C120.1 R217.1 R233.2 U7.14(PJ0)
ZD3_AIF0_RXN: C233.2 J2.E1(RX0_5-)
ZD3_AIF0_RXP: C235.2 J2.F1(RX0_5+)
ZD3_AIF0_TXN: J2.E2(TX0_5-) U24.AP17(AIFTXN0)
ZD3_AIF0_TXP: J2.F2(TX0_5+) U24.AP18(AIFTXP0)
ZD3_AIF1_RXN: C577.2 J2.E3(RX1_5-)
ZD3_AIF1_RXP: C589.2 J2.F3(RX1_5+)
ZD3_AIF1_TXN: J2.E4(TX1_5-) U24.AR16(AIFTXN1)
ZD3_AIF1_TXP: J2.F4(TX1_5+) U24.AR17(AIFTXP1)
ZD3_AIF2_RXN: C590.2 J2.E5(RX2_5-)
ZD3_AIF2_RXP: C596.2 J2.F5(RX2_5+)
ZD3_AIF2_TXN: J2.E6(TX2_5-) U24.AT15(AIFTXN2)
ZD3_AIF2_TXP: J2.F6(TX2_5+) U24.AT16(AIFTXP2)
ZD3_AIF3_RXN: C227.2 J2.E7(RX3_5-)
ZD3_AIF3_RXP: C229.2 J2.F7(RX3_5+)
ZD3_AIF3_TXN: J2.E8(TX3_5-) U24.AP14(AIFTXN3)
ZD3_AIF3_TXP: J2.F8(TX3_5+) U24.AP15(AIFTXP3)
N863951: PB1.2 SOC_USB.4(GND) SOC_USB.7(GND_DRAIN) SOC_USB.H1(PTH_1) SOC_USB.H2(PTH_2)
N7232080: C364.2 R443.2 R445.2
N12619718: C27.1 FTDI_USB.1(+5V) R26.2
N12619936: C33.2 U3.2(OSCI) Y1.2
N12619940: C28.2 U3.3(OSCO) Y1.1
N12620028: U3.63(EECS) U46.1(CS)
N12620040: U3.62(EECLK) U46.2(SK)
N12620052: R482.2 U3.61(EEDATA) U46.3(DI)
N12620068: R482.1 R484.1 U46.4(DO)
N12620356: R483.2 U3.6(REF)
N12620364: TP6.1 U3.60(P\W\R\E\N\)
N12620368: TP1.1 U3.36(S\U\S\P\E\N\D\)
N12620494: R477.2 U46.6(ORG)
N12681623: R577.2 U56.12(FORCEON)
N12681645: C490.2 U56.3(V+)
N12681649: C492.2 U56.5(C2+)
N12681653: C492.1 U56.6(C2-)
N12681665: C491.2 U56.2(C1+)
N12681669: C491.1 U56.4(C1-)
N12681685: C493.2 U56.7(V-)
N12681693: R576.2 U56.16(F\O\R\C\E\O\F\F\)
N12824739: R317.2 U22.8(VCCB)
N12868999: PHY1.A6(S_CLK-) R715.1
N12869003: PHY1.A5(S_CLK+) R704.1
N12869377: PHY1.K2(125CLK) TP75.1
N12934666: CN22.1 R531.1
N12948447: DBG_D1.1(ANODE) R70.1
N12950191: DBG_D3.2(ANODE) R111.1
N12966915: DBG_D2.2(ANODE) R534.1
N13012268: R515.1 U7.96(PE3)
N13251183: R134.2 R145.2 R553.2
N13254474: C80.1 R146.2 R159.1 U16.59(CS1A)
N13254570: B13.1(IN) C100.1 U16.46(V33A)
N13254578: C91.1 U16.47(BPCAP)
N13254654: R172.2 U16.61(ADDR0)
N13254658: R151.2 U16.60(ADDR1)
N13254770: C84.1 R140.2 R150.1 U16.50(EAP1)
N13255208: C99.1 R201.2 R202.1 U16.3(CS2A)
N13255844: C78.1 R170.2 R171.1 U16.1(CS4A)
N13256024: C90.1 R195.2 R196.1 U16.2(CS3A)
N13256156: R216.1 U16.9(R\E\S\E\T\)
N13256184: R224.2 U16.40(J\T\A\G\_\T\R\S\T\)
N13256738: C83.1 R139.2 R149.1 U16.52(EAP2)
N13256834: C82.1 R138.2 R148.1 U16.54(EAP3)
N13257002: C81.1 R137.2 R147.1 U16.56(EAP4)
N13262989: R755.2 R760.2 R766.2
N13263083: C791.2 R468.1
N13263091: C775.2 C830.2 R461.1 U44.30(SRE_MD) U44.37(BP3)
N13263135: C749.1 R760.1 R761.2 R767.2
N13263447: R469.1 U44.28(HS_SNS)
N13268166: C423.2 U9.22(BP3)
N13268176: L6.2 U9.14(SWA)
N13268184: C51.2 U9.3(BST_B)
N13268196: C57.1 U9.5(VGG)
N13268208: C51.1 U9.4(BSW_B)
N13268280: L5.2 U9.13(SWB)
N13268308: C50.1 U9.24(BST_A)
N13268312: C50.2 U9.23(BSW_A)
N13662493: CN22.2 R485.2
N13662497: CN22.4 R491.2
N13662501: CN22.6 R493.2
N13662505: CN22.8 R506.2
N13662509: CN22.10 R513.2
N14285737: R671.1 U24.AM21(RIOREFRES)
N14285795: TP76.1 U24.AM23(RSV021)
N14335140: R360.2 U25.60(ADDR1)
N14335250: C236.1 R342.2 R343.1 U25.50(EAP1)
N14335646: C663.1 R693.2 R694.1 U25.3(CS2A)
N14335696: L7.2 U23.14(SWA)
N14335704: C221.2 U23.3(BST_B)
N14335716: C226.1 U23.5(VGG)
N14335728: C221.1 U23.4(BSW_B)
N14335800: L8.2 U23.13(SWB)
N14335828: C182.1 U23.24(BST_A)
N14335832: C182.2 U23.23(BSW_A)
N14336022: C653.1 R683.2 R687.1 U25.1(CS4A)
N14336112: C652.1 R682.2 R686.1 U25.2(CS3A)
N14336172: R377.2 U25.9(R\E\S\E\T\)
N14336192: R336.2 U25.40(J\T\A\G\_\T\R\S\T\)
N14336826: C239.1 R345.2 R347.1 U25.52(EAP2)
N14336882: C244.1 R349.2 R353.1 U25.54(EAP3)
N14336954: C260.1 R365.1 R370.2 U25.59(CS1A)
N14336966: C252.1 R356.2 R358.1 U25.56(EAP4)
N14337048: B31.1(IN) C228.1 U25.46(V33A)
N14340048: R114.2 R545.2 R547.2
N14340304: C430.1 R115.2 R538.2 R545.1
N14340850: R116.2 U8.5(BOOT)
N14340854: C63.2 R116.1
N14340862: R85.1 U8.28(HS_SNS)
N14344366: C232.1 U25.47(BPCAP)
N14344442: R361.2 U25.61(ADDR0)
N14416450: C363.1 R441.2 R442.1 U38.1(REFIN)
N14462583: R685.1 U24.AM24(SGMIIREFRES)
N14462617: TP79.1 U24.AM25(RSV023)
N14463052: R698.1 U24.AM26(PCIEREFRES)
N14463097: TP86.1 U24.AM28(RSV022)
N14463586: R635.1 U24.AM9(HYPLNK0REFRES)
N14463676: TP68.1 U24.AN10(RSV019)
N14464320: R632.1 U24.AM6(HYPLNK1REFRES)
N14464350: TP67.1 U24.AM7(RSV020)
N14466276: R667.2 U24.AM19(XFIREFRES1)
N14466300: R656.2 U24.AN16(XFIREFRES0)
N14466676: TP43.1 U24.R1(USBID0)
N14466840: R310.1 U24.AA1(USBRESREF)
N14469420: R640.1 U24.H10(DDR3ARZQ1)
N14469428: R684.1 U24.H22(DDR3ARZQ2)
N14469440: R657.1 U24.H16(DDR3ARZQ0)
N14469681: TP69.1 U24.D12(RSV027)
N14469715: TP72.1 U24.D13(RSV028)
N14470453: R716.1 U24.AA31(DDR3BRZQ0)
N14470457: R719.1 U24.P32(DDR3BRZQ1)
N14470652: TP56.1 U24.AC38(DDR3BCLKOUTN1)
N14470656: TP54.1 U24.AC39(DDR3BCLKOUTP1)
N14470900: TP91.1 U24.AD35(RSV030)
N14470904: TP89.1 U24.AC34(RSV031)
N14479849: R409.2 U34.5(EN) U34.8(VCCB)
N14481980: TP73.1 U24.AM16(RSV024)
N14482014: TP70.1 U24.AM14(RSV025)
N14482176: R649.1 U24.AM15(AIFREFRES0)
N14482239: R638.1 U24.AM11(AIFREFRES1)
N14625100: C293.1 U27.5(VGG)
N14634249: C292.2 U27.1(BST)
N14638052: C314.1 U27.9(BP3)
N14711749: B7.2 C76.1 C87.2 U13.34(V33A)
N14715464: R179.2 U13.19(PMBUS_ALERT)
N14715500: R162.2 U13.20(PMBUS_CNTRL)
N14716011: R174.2 TP14.1 U13.31(T\R\S\T\)
N14719575: R212.2 U13.43(PMBUS_ADDR1)
N14809841: C764.1 R769.2 R770.1 U60.1(REFIN)
N14810291: Q13.1(REF) R505.2 R508.1
N14872798: C117.1 R221.1 R227.2
N14873463: C123.1 R219.1
N14876495: R183.1 TP19.1
N14876513: R182.1 TP18.1
N14876577: R181.1 TP12.1
N14876581: R180.1 TP24.1
N14876667: R181.2 U15.35(Y7_P)
N14876671: R180.2 U15.36(Y7_N)
N14876735: R183.2 U15.32(Y6_P)
N14876739: R182.2 U15.33(Y6_N)
N14994125: B39.3(OUT) C315.1 C318.2 U29.1(VDD)
N14997851: B15.3(OUT) C140.1 C146.2 OSC2.1(OE) OSC2.6(VCC)
N15094693: C74.2 C829.2 R122.1 U10.30(SRE_MD) U10.37(BP3)
N15442351: C408.1 LCD1.1(V0)
N15442395: C407.1 LCD1.2(V1)
N15442399: C406.2 LCD1.3(V2)
N15442403: C405.1 LCD1.4(V3)
N15442407: C404.2 LCD1.5(V4)
N15443451: C412.1 LCD1.6(C2-)
N15443455: C412.2 LCD1.7(C2+)
N15443549: C411.2 LCD1.8(C1+)
N15443557: C411.1 LCD1.9(C1-)
N15443902: C410.1 LCD1.10(VOUT)
N15556145: TP66.1 U24.L4(UART0RTS)
N15556149: TP44.1 U24.L1(UART0CTS)
N15571799: CN2.1 R83.1
N15576101: Q1.3(FB) R19.2 R20.2
N15576385: Q1.5(EN) R3.1 R4.2
N15613486: R367.2 U24.B27(SPI1SCS0)
N15624378: TP40.1 U19.45(STATUS1/PIN0)
N15625166: R277.1 U19.6(REF_SEL)
N15625345: C172.1 R299.2
N15626537: C169.2 U19.40(REG_CAP)
N15627377: R285.1 U19.1(SI_MODE0)
N15627381: R301.1 U19.47(SI_MODE1)
N15633874: R200.2 U15.23(Y3_P)
N15633892: R204.2 U15.22(Y3_N)
N15633910: R200.1 TP27.1
N15633914: R204.1 TP28.1
N15634110: R184.2 U15.29(Y5_P)
N15634114: R185.2 U15.28(Y5_N)
N15634136: R184.1 TP20.1
N15634140: R185.1 TP17.1
N15634384: R215.1 TP30.1
N15634388: R210.1 TP29.1
N15634420: R215.2 U15.20(Y2_P)
N15634424: R210.2 U15.21(Y2_N)
N15783905: R262.2 U13.10(FPWM1/GPIO5)
N15783945: R263.2 U13.11(FPWM2/GPIO6)
N15994751: C360.2 R440.1 U36.7(VREF2) U36.8(EN)
N15995652: TP74.1 U24.AN19(RSV026)
N15996235: RR1.1 U24.AK32(DDR3BRZQ2)
N16003549: TP78.1 U24.E23(RSV014)
N16003553: TP77.1 U24.F23(RSV013)
N16007057: NOR1.8(DQ1) R558.2
N16018876: CN20.1 U24.E33(RSV015)
N16018889: CN20.2 U24.F26(RSV017)
N16018895: CN20.3 U24.F32(RSV016)
N16018907: CN20.4 U24.G26(RSV018)
N16053779: R98.1 U7.19(PG0)
N16114816: R574.2 U13.14(FPWM5/GPIO9)
N16169033: R193.1 TP26.1
N16169055: R190.1 TP16.1
N16169087: R193.2 U14.32(Y6_P)
N16169091: R190.2 U14.33(Y6_N)
N16169113: R189.2 U14.35(Y7_P)
N16169117: R188.2 U14.36(Y7_N)
N16169139: R189.1 TP23.1
N16169161: R188.1 TP22.1
N16188479: R39.1 U4.6
N16257033: TP42.1 U24.AK1(SYSCLKOUT)
N16257361: TP41.1 U24.P1(RSV001)
N16294811: R586.2 U54.5(EN) U54.8(VCCB)
N16297458: DBG_D1.3(CATHODE2) Q14.3(C)
N16299090: DBG_D2.1(CATHODE) Q16.3(C)
N16301183: DBG_D3.1(CATHODE) Q5.3(C)
N16301445: TP62.1 U24.P2(RSV000)
N16305012: U45.14(1Y3) U49.42(2B1)
N16305018: U45.16(1Y2) U49.47(1B1)
N16305024: U45.18(1Y1) U49.48(0B1)
N16307332: C246.2 R680.1 R681.1
N16307607: C644.2 R689.1 R695.1
N16307811: C294.2 R700.1 R705.1
N16308017: C714.2 R710.1 R717.1
N16308726: C201.2 R618.1 R624.1
N16308822: C209.2 R626.1 R630.1
N16308918: C214.2 R633.1 R636.1
N16309014: C572.2 R637.1 R641.1
N16316172: R86.1 U7.17(PG2)
N16319325: R514.1 U7.61(PF1)
N16321956: R521.2 U52.10(OE)
N16474415: D6.1(ANODE) R110.1
N16474431: D6.2(CATHODE) Q18.3(C)
N16572263: R75.1 U7.16(PG3)
N16574652: R9.1 U45.1(1\O\E\) U45.19(2\O\E\)
N16576068: R472.2 U45.15(2A3) U45.17(2A4)
N16577490: R480.1 U49.41(3B1)
N16755452: R691.1 U24.D28(SPI2SCS1)
N16755456: R373.1 U24.A29(SPI2SCS2)
N16755460: R690.1 U24.E25(SPI2SCS3)
N16755464: R692.1 U24.G28(SPI2DOUT)
N16755468: R369.1 U24.D25(SPI2CLK)
N16757437: Q16.1(B) R525.2
N16758697: Q5.1(B) R76.2
N16759046: TP84.1 U24.C27(SPI1SCS1)
N16759085: TP85.1 U24.D27(SPI1SCS2)
N16759125: TP87.1 U24.E27(SPI1SCS3)
N16759185: TP80.1 U24.C25(SPI0SCS1)
N16759219: TP82.1 U24.E26(SPI0SCS2)
N16759253: TP81.1 U24.D26(SPI0SCS3)
N16761112: Q14.1(B) R522.2
N16761155: DBG_D1.2(CATHODE1) Q4.3(C)
N16761582: Q4.1(B) R510.2
N16762531: R12.2 U45.9(2Y1)
N16762648: R480.2 U45.12(1Y4)
N16762689: R490.1 U49.38(3B2)
N16762695: R490.2 U5.5(A4)
N16784180: C134.1 R256.2 R257.2 R258.2 R259.1
N16787536: C137.1 R239.2 R240.2 R241.1 R584.2
N16789476: C168.1 R272.2 R273.2 R302.2 R303.1
N16800870: Q18.1(B) R533.2
N16809810: CN3.79 R60.2
N16809812: CN3.81 R55.2
N16815045: R372.1 U24.B28(SPI2SCS0)
N16822090: R575.1 U16.33(VID3S)
N16822339: R573.1 U16.35(VID4S)
N16822637: R331.1 U25.41(VID1A)
N16822639: R330.1 U25.42(VID1B)
N16822641: R366.1 U25.18(VID1C)
N16822643: R379.1 U25.12(VID1S)
N16822690: R688.1 U25.20(VID2A)
N16822692: R362.1 U25.22(VID2B)
N16822705: R344.1 U25.29(VID2C)
N16822707: R381.1 U25.14(VID2S)
N16822989: R341.1 U25.30(VID3A)
N16822991: R340.1 U25.31(VID3B)
N16822993: R334.1 U25.32(VID3C)
N16822995: R339.1 U25.33(VID3S)
N16823042: R337.1 U25.36(VID4A/JTAG_TCK)
N16823044: R332.1 U25.37(VID4B/JTAG_TDO)
N16823057: R650.1 U25.39(VID4C/JTAG_TMS)
N16823059: R651.1 U25.35(VID4S)
N16825201: R8.2 U1.1(RT/CLK)
N16825817: B1.2 C10.1 C11.1 U1.4(PVIN1) U1.5(PVIN2)
N16826413: C16.1 U1.9(SS/TR)
N16826793: C387.1 R17.1 U1.8(COMP)
N16826901: C13.1 U1.13(BOOT)
N16827286: C13.2 L1.1 U1.11(PH1) U1.12(PH2)
N16827414: R7.2 R10.1 U1.7(VSENSE)
N16865403: Q12.1(B) R504.2
N16865412: D4.1(ANODE) R492.1
N16865430: D4.2(CATHODE) Q12.3(C)
N16865801: Q3.1(B) R494.2
N16865808: D3.2(ANODE) R30.1
N16865818: D3.1(CATHODE) Q11.3(C)
N16865822: D5.2(ANODE) R507.1
N16865834: D5.1(CATHODE) Q3.3(C)
N16865898: Q11.1(B) R31.2
N16869469: C113.1 R213.1
N16870184: C108.1 R207.1
N16870591: C169.1 R305.1
N16876414: C181.2 U23.22(BP3)
N16969569: Q2.8(FB) R23.2 R481.1
N16996048: C18.1 Q2.7(SS)
N17000861: B2.2 C4.1 C8.1 Q10.3(VIN)
N17007218: J1.C2(MP) R549.1
N17260565: C32.1 R32.1
N17261802: R218.1 U13.44(PMBUS_ADDR0)
N17515515: C61.2 R93.1 U8.30(SRE_MD) U8.37(BP3)
N17759045: R568.1 U53.21(GPA0)
N17761475: C348.1 C351.1 C354.1 D8.3(CATHODE) DC_IN1.1 Q19.1(S1) Q19.2(S2) Q19.3(S3) R434.1 R436.1
N18200913: PHY1.M9(T\R\S\T\) R796.2
N18201367: PHY2.M9(T\R\S\T\) R797.2
N18454569: R468.2 U44.5(BOOT)
N18458097: C796.1 R798.1
N18489905: R801.1 U53.8(GPB7)
N18495173: B25.3(OUT) C162.2 C163.1 OSC3.4(VCC)
N18495232: C135.2 OSC3.1(VC) R260.2 R261.1
N18495858: B47.3(OUT) C798.1 C799.2 U61.2(VIN)
N18495910: C800.1 U61.5(TRIM/NR)
N18495926: C801.1 U29.2(VREF) U61.6(VOUT)
N18628275: R13.2 R14.1 U2.7(VSENSE)
N18719819: B48.1 U24.AB13(VDDUSB)
N18823007: C815.1 R803.2
N18823875: C814.1 R802.2
N18899244: NAND1.G5(LOCK) R804.1 R805.2
N19339535: R777.2 U43.L8(ZQ)
N19350255: R784.2 U40.L8(ZQ)
N19351108: R771.2 U39.L8(ZQ)
N19356481: R776.2 U42.L8(ZQ)
N19359494: R758.1 U41.C7(DQSU)
N19359500: R745.1 U41.B7(D\Q\S\U\)
N19359630: R754.1 U41.D3(DMU)
N19359646: R778.2 U41.L8(ZQ)
N19643635: R812.1 U50.21(GPA0)
N20001256: R813.2 R814.1 U59.4(EN) U70.4(OUT)
N20002440: C9.1 R17.2
N36253337: Q7.3(FB) R280.2 R281.2
N36291863: Q8.3(FB) R283.2 R284.1
N39781722: PHY2.K2(125CLK) TP61.1
N41034021: C325.2 R403.1 U31.7(VREF2) U31.8(EN)
N43929945: R290.2 U18.12(FORCEON)
N43929982: C130.2 U18.3(V+)
N43929984: C128.2 U18.5(C2+)
N43929986: C128.1 U18.6(C2-)
N43930002: C129.2 U18.2(C1+)
N43930004: C129.1 U18.4(C1-)
N43930022: C127.2 U18.7(V-)
N43930050: R291.2 U18.16(F\O\R\C\E\O\F\F\)
N44510100: C22.2 L2.1 U2.11(PH1) U2.12(PH2)
N44510146: B3.2 C6.1 C385.1 C386.1 U2.4(PVIN1) U2.5(PVIN2)
N44510176: C22.1 U2.13(BOOT)
N44510178: R15.2 U2.1(RT/CLK)
N44510240: R22.1 U2.8(COMP)
N44510256: C14.1 R22.2
N44510258: C391.1 U2.9(SS/TR)
N56424980: C351.2 Q19.4(GATE) R431.1 R434.2
N56425114: D8.1(ANODE) R435.1
N56425122: Q20.3(DRAIN) R431.2
N56425140: C745.1 Q9.3(C) Q20.1(GATE) R427.1 R436.2
N56425144: Q9.1(B) R435.2 R437.1
N59999809: R611.2 U58.8(VCCB)
N60785066: PHY2.A6(S_CLK-) R634.1
N60785068: PHY2.A5(S_CLK+) R627.1
N60820080: R749.2 U41.C3(DQU1)
N60820095: R752.2 U41.C8(DQU2)
N60820110: R747.2 U41.A7(DQU4)
N60820114: R744.2 U41.A2(DQU5)
N60820127: R753.2 U41.C2(DQU3)
N60820155: R746.2 U41.A3(DQU7)
N60820166: R748.2 U41.B8(DQU6)
N63574595: EEPROM1.2(E1) R325.2 R326.1
N63574605: EEPROM1.3(E2) R322.1 R323.2
N65094088: C60.2 R117.1
N65094092: R117.2 U10.5(BOOT)
N65094154: R106.1 U10.28(HS_SNS)
N65094220: C434.1 R135.2 R551.2 R553.1
N65832500: C382.2 GPS1.E1(VDD) R471.2
N66015127: C370.2 C375.1 L11.1
N66015725: C370.1 CN18.1(RF_IN) L10.1
N66065896: R419.2 SIM1.SW1
N66414815: GPS1.C2(TCXO_CLK) TP95.1
N67021867: U5.6(A5) U49.32(4B2)
N67021870: U5.4(A3) U49.39(2B2)
N67021873: U5.1(A1) U49.45(0B2)
N67021879: U5.3(A2) U49.44(1B2)
N67021882: R511.1 U49.31(5B2)
N67021897: R519.1 U49.26(6B2)
N67022560: R48.2 U5.10(OE)
N68010936: R402.2 U32.11(2B1)
N68010938: R401.2 U32.10(2B2)
N68025719: R130.1 U7.31(PA5/SSI0TX)
N68025736: R131.1 U7.30(PA4/SSI0RX)
N68027970: R476.2 SW1.8
N68027994: R475.2 SW1.7
N68028184: R474.2 SW1.6
N68028192: R473.2 SW1.5
N68035165: C72.1 C414.2 C415.2 U7.7(LDO) U7.38(VDDC_1) U7.88(VDDC_2)
N68049827: TP32.1 U15.45(STATUS1/PIN0)
N68049869: R265.1 U15.6(REF_SEL)
N68049909: C108.2 U15.40(REG_CAP)
N68057675: R252.1 U14.1(SI_MODE0)
N68057679: TP35.1 U14.45(STATUS1/PIN0)
N68057721: R253.1 U14.6(REF_SEL)
N68057761: C113.2 U14.40(REG_CAP)
N68057795: R235.1 U14.47(SI_MODE1)
N68067792: R264.1 U15.1(SI_MODE0)
N68067794: R225.1 U15.47(SI_MODE1)
N68073129: R546.2 U7.51(H\I\B\)
N151708088: TP33.1 U16.38(SYNC_IN/JTAG_TDI)
N151794428: TP45.1 U25.38(SYNC_IN/JTAG_TDI)
N1517080885: TP31.1 U16.10(JTAG_RCK)
N1517944285: TP48.1 U25.10(JTAG_RCK)
N1627346115: R298.1 U20.9(IREF)

Pads without a net: AMC1 6 8 29 30 32 33 35 36 38 39 59 60 62 63 65 66 68 69 74 75 111 112 114 115 117 118 120 121 123 124 126 127 129 130 132 133; ATT 3 4; CN1 1; CN3 41 67; CN17 2; CN22 7; D1 3 5; D8 2; DIMM1 118 120 198; EEPROM1 1; EMU1 9 10 11 14 44 46 48 50 52 54 56 59 60; FAN1 3; FM1 1; FM2 1; FM3 1; FM4 1; GPS1 A3 A4 A5 A6 B4 B5 B6 C6 D1 D2 D3 D4 D5 D6 E3 E4 E5 F3 F4 F6; H1 1; H2 1; H8 1; J1 E1 E2 F1 F2 G1 G2 G3 G4 G5 G6 G7 G8 G9 G10 H1 H2 H3 H4 H5 H6 H7 H8 H9 H10; J2 A1 A2 A3 A4 A5 A6 A7 A8 A10 B1 B2 B3 B4 B5 B6 B7 B8 B10 C5 C6 C7 C8 C10 D5 D6 D7 D8 D10 E9 E10 F9 F10 G1 G2 G3 G4 G5 G6 G7 G8 G9 G10 H1 H2 H3 H4 H5 H6 H7 H8 H9 H10; NAND1 A1 A2 A9 A10 B1 B9 B10 D6 D7 D8 E3 E4 E5 E6 E7 E8 F3 F4 F5 F6 F8 G3 G6 G7 G8 H3 H5 H6 H7 J3 J5 L1 L2 L9 L10 M1 M2 M9 M10; NOR1 3 4 5 6 11 12 13 14; OSC2 2; PHY1 A1 A2 B1 B2 B3 B5 C1 C3 C4 C5 D2 D3 G1 K7 K8 L7 L8 L9 M5 M6; PHY2 A1 A2 B1 B2 B3 B5 C1 C3 C4 C5 D2 D3 G1 K7 K8 L7 L8 L9 M5 M6; PWR 3 4; Q1 2 6 7; Q2 3; Q6 1 5; Q7 2 6 7; Q8 2 6 7; Q15 1 5; Q17 1 5; Q21 1 5; SIM1 C6; U3 18 19 21 22 23 24 26 27 28 29 30 32 33 34 40 41 43 44 45 46 48 52 53 54 55 57 58 59; U4 3 5 7; U5 7 8 13 14; U7 47 53 70 71 73 97 98; U8 4 6 34; U10 4 6 34; U12 3; U13 12 37; U16 30 31 32 36 37 39 58; U17 3; U18 10; U21 3; U24 AA36 AB38 AD34 AR37 AT39 AU36 AV37; U25 58; U30 3; U32 4 13; U33 4 6 12 16; U39 J1 J9 L1 L9; U40 J1 J9 L1 L9; U41 J1 J9 L1 L9; U42 J1 J9 L1 L9; U43 J1 J9 L1 L9; U44 4 6 34; U45 3 5; U46 7; U47 19; U48 19; U49 14 23 25 28; U50 19 28; U53 19; U55 3; U56 10; U59 3; U61 1 3 7 8; U69 1; U70 1

## Via types
v1: diameter 0.508, hole 0.254, TOP to BOTTOM, 1954 vias
v2: diameter 0.457, hole 0.254, TOP to BOTTOM, 1725 vias
v3: diameter 0.61, hole 0.356, TOP to BOTTOM, 1208 vias
v4: diameter 0.559, hole 0.305, TOP to BOTTOM, 18 vias
v5: diameter 0.457, hole 0.457, L5 to BOTTOM, 2 vias
v6: diameter 0.508, hole 0.508, L5 to BOTTOM, 4 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
AVCC2V5A: length 4.2
  BOTTOM w0.127: v1(151.26,78.36) v1(151.89,78.36)
  BOTTOM w0.254: v2(138.73,72.52) PHY1.B7
  BOTTOM w0.381: PHY1.N5 150.17,74.1 v2(150.62,74.55) ; v2(149.53,76.51) 149.14,76.12 PHY1.M3 ; PHY1.M8 v2(149.61,71.56) ; PHY1.M4 149.14,75.1 149.48,75.44 149.48,75.44 v2(149.54,75.5) ; v2(149.54,72.49) PHY1.M7
AVCC2V5B: length 5.1
  TOP w0.381: v2(151.13,102.74) 150.88,102.49 B27.1 ; C202.1 150.11,98.43 150.56,98.87 v2(150.56,98.89)
  BOTTOM w0.381: PHY2.M8 149.54,95.88 149.54,95.88 v2(149.57,95.92) ; v2(149.61,100.97) 149.14,100.5 PHY2.M3 ; PHY2.M4 149.15,99.49 v2(149.61,99.95) ; v2(138.74,96.9) PHY2.B7 ; PHY2.M7 149.18,96.49 v2(149.56,96.87) ; v2(150.56,98.89) 150.54,98.89 PHY2.N5
  vias: v1(151.89,102.74)
AVDDA1: length 1.5
  TOP w0.381: U24.AF11 v2(66.04,91.9)
  BOTTOM w0.381: v2(65.99,96.95) 65.91,96.95 65.41,96.45 C816.1
  vias: v1(68.07,112.52)
AVDDA2: length 5.2
  TOP w0.381: v2(78.99,82.04) 79.12,82.04 79.5,82.42 U24.N20
  BOTTOM w0.381: B16.1 77.78,85.47 C817.1 C152.1 77.78,83 78.74,82.04 v2(78.99,82.04)
AVDDA3: length 7.5
  TOP w0.381: v2(78.99,73.79) 78.99,73.9 U24.N28
  BOTTOM w0.381: C818.1 77.82,76.4 77.95,76.53 78.91,76.53 B32.1 ; v2(78.99,73.79) 78.74,73.79 78.13,74.4 78.13,74.98 78.84,75.69 78.84,76.19 B32.1 ; C259.1 78.42,77.56 79.04,76.94 B32.1
AVDDA4: length 0.7
  TOP w0.381: v2(64.9,72.9) 64.52,73.28 U24.AH29
  vias: v1(40.51,69.6) v1(41.02,70.1)
AVDDA5: length 4.8
  TOP w0.381: v2(65.91,75.9) 65.91,76.03 65.84,76.1 65.84,76.1 U24.AG26
  BOTTOM w0.305: B38.1 64.17,75.63 64.54,76 65.81,76 v2(65.91,75.9) 66.39,75.42 C820.1 66.5,75.28 66.5,74.12 C303.1
AVDDAHV: length 37.9
  TOP w0.381: v2(62.99,86.94) 62.52,87.42 U24.AK15 U24.AL14 ; U24.AK17 U24.AL16 61.48,86.42 v2(60.96,85.9) ; U24.AL22 61.62,80.42 v2(62.13,79.92) 62.52,79.53 U24.AK23 ; U24.AK21 62.52,81.5 v2(62.02,81.99) 61.59,82.42 U24.AL20 ; U24.AK25 62.73,77.42 v2(63.14,77.01) ; U24.AL24 61.97,77.97 v2(61.98,77.97) ; U24.AK13 U24.AL12 61.49,90.42 v2(61.01,90.91) ; U24.AK19 62.4,83.42 v2(61.93,83.9) 61.52,84.3 U24.AL18 ; U24.AL10 61.53,92.42 v2(62,91.95) 62.52,91.43 U24.AK11
  BOTTOM w0.381: C580.1 59.17,86.62 59.4,86.39 60.47,86.39 v2(60.96,85.9) 60.34,85.29 C599.1 ; C699.1 59.76,75.44 60.5,75.44 v2(61.01,74.93) ; v2(62.02,81.99) 59.89,81.99 C626.1 ; C664.1 63.66,76.49 v2(63.14,77.01) ; v2(61.98,77.97) 60.84,76.84 C655.1 ; C616.1 60.57,83.38 61.09,83.9 v2(61.93,83.9) ; C637.1 60.58,79.38 61.12,79.92 v2(62.13,79.92) ; C553.1 60.47,91.2 61.21,91.95 v2(62,91.95) ; v2(61.01,90.91) 61.64,90.28 61.64,88.94 61.03,88.33 C566.1
  vias: v1(38.86,55.75) v1(38.86,54.99) v1(39.62,55.75) v1(39.62,54.99)
AVDDALV: length 36.1
  TOP w0.381: U24.AH25 64.52,77.46 v2(64.01,77.97) 63.55,78.42 U24.AJ24 ; U24.AF15 66.5,87.42 v2(66.01,87.91) 65.52,88.41 U24.AG14 65.42,88.42 v2(64.97,88.87) 64.52,89.33 U24.AH13 64.52,89.46 v2(64.03,89.94) 63.55,90.42 U24.AJ12 ; U24.AJ14 63.52,88.42 v2(64.01,87.93) 64.52,87.43 U24.AH15 64.55,87.42 v2(64.99,86.98) 65.52,86.45 U24.AG16 65.52,86.42 v2(66.01,85.93) 66.52,85.43 U24.AF17 ; U24.AJ20 63.52,82.42 v2(63.98,81.96) 64.52,81.43 U24.AH21 64.52,81.38 v2(64.97,80.92) ; U24.AG22 65.52,80.28 v2(65.98,79.82) 66.12,79.82 U24.AF23 ; U24.AH11 64.63,91.42 v2(65.02,91.03) 65.52,90.54 U24.AG12 66.01,89.93 v2(66.01,89.92) 66.51,89.42 U24.AF13 ; U24.AJ18 63.52,84.41 v2(64.03,83.9) 64.51,83.42 U24.AH19 64.52,83.39 v2(65,82.91) 65.48,82.42 U24.AG20 65.52,82.41 v2(66.01,81.91) 66.51,81.42 U24.AF21 ; U24.AJ16 63.52,86.42 v2(64.01,85.93) 64.51,85.42 U24.AH17 64.52,85.22 v2(64.97,84.77) 65.32,84.42 U24.AG18 65.52,84.42 v2(66.01,83.92) 66.51,83.42 U24.AF19 ; v2(65.02,79.13) 64.81,79.13 U24.AH23 64.52,79.42 64.14,79.8 v2(64.14,79.88) 64.06,79.88 U24.AJ22
  BOTTOM w0.381: v2(64.97,88.87) 65.42,89.32 C573.1 ; v2(65,82.91) 65.47,83.38 C624.1 ; v2(64.99,86.98) 65.47,86.5 C594.1 ; v2(65.02,79.13) 65.47,78.68 C643.1 ; v2(65.98,79.82) 65.47,80.32 C636.1 ; C613.1 v2(66.01,81.91) 66.04,81.91 66.55,81.41 ; v2(66.01,85.93) 66.57,86.48 C598.1 ; C601.1 65.47,85.27 v2(64.97,84.77) ; C588.1 65.99,87.88 v2(66.01,87.91) ; v2(65.02,91.03) 65.47,90.58 C564.1 ; C574.1 66.48,90.38 v2(66.01,89.92)
  vias: v1(39.24,83.57) v1(39.27,82.01) v1(48.33,81.21) v1(48.26,80.52)
GND: length 3769.1
  TOP w0.254: U65.10 43.51,132.93 43.2,133.24 43.2,133.21 v1(43.21,133.21) ; CN3.58 31.39,141.2 v3(30.73,141.86) ; v1(104.49,58.27) 104.5,58.27 104.5,58.27 104.6,58.17 U30.7 ; v1(141.61,137.75) 141.63,137.73 141.63,137.72 142.18,137.17 U12.4 ; v3(31.06,162.28) 31.06,161.54 31.39,161.2 CN3.118 ; v1(44.39,140.27) 44.39,140.15 44.18,139.94 U68.10 ; U15.12 63.25,121.28 v1(63.32,121.22) ; 115.24,125.71 U16.43 ; v3(79.96,145.67) 80.01,145.72 80.01,145.77 79.91,145.77 79.39,146.29 U9.6 ; CN3.117 39.41,161.2 39.88,161.67 v2(40.34,161.67) ; CN3.57 39.26,141.2 39.62,140.84 39.62,140.8 v1(39.72,140.71) ; v1(30.96,147.96) 31.21,147.7 CN3.64 ; v3(152.52,170.02) 152.5,170.02 152.5,170 152.4,170.1 U3.25 ; v1(121.62,132.43) 121.68,132.43 122.03,132.08 R173.1 ; v3(109.39,165.88) 109.33,165.82 Q2.6 ; U31.1 v1(138.59,60.3) ; U1.2 110.98,174.46 111.12,174.6 111.12,174.93 v1(111.08,174.98) 110.9,174.98 110.48,174.57 U1.3 ; v1(107.57,60.07) 107.57,59.3 107.7,59.17 U30.4 ; CN3.63 39.29,147.7 v1(39.72,148.13) ; 108.69,127.94 108.39,128.24 U16.64 ; U16.26 112.89,121.18 ; U28.4 105.39,60.11 105.72,59.79 v1(105.75,59.79) ; 108.74,124.71 U16.8 ; U9.21 84.41,146.29 83.82,145.69 v3(83.82,145.67)
  TOP w0.279: U7.4 v3(147.02,151.69) ; U14.12 55.73,127.86 55.32,128.27 v3(54.99,128.27) ; v3(17.17,96.49) 17.26,96.4 U23.6 ; U3.35 148.01,168.1 v3(148.09,168.19) ; v1(107.57,128.96) U16.64 ; v3(150.11,158.37) 149.9,158.58 U3.51 ; v3(162.69,150.37) 162.86,150.19 U7.69 ; v1(145.87,63.25) 145.77,63.35 145.24,63.35 145.03,63.14 U33.10 ; v3(18.3,94.44) 18.3,94.61 18.26,94.64 U23.8 ; U16.26 112.89,118.86 v1(112.95,118.8) ; v3(95.66,139.65) 95.19,139.18 EMU1.57 ; U4.1 166.89,156.31 v3(166.99,156.21) ; v3(162.56,143.64) 162.56,143.89 162.86,144.19 U7.57 ; v3(165.1,142.49) 164.9,142.69 U7.54 ; U16.48 116.64,128.83 v1(116.58,128.89) ; v1(77.8,145.62) 77.85,145.62 78.18,145.29 U9.8 ; U21.7 79.57,116.45 79.2,116.08 v1(79.2,115.5) ; v3(102.98,46.72) 103.1,46.61 U38.8 ; U25.48 23.55,86.17 23.24,86.49 22.49,86.49 v1(22.48,86.49) ; v3(159.47,138.25) 159.46,138.25 U7.45 ; v2(81.03,114.55) 80.63,114.16 U55.4 ; v3(152.83,156.16) 152.96,156.03 U7.94 ; v3(147.94,163.01) 147.85,162.92 147.85,162.39 147.57,162.1 U3.47 ; v3(153.9,138.02) 153.46,138.45 U7.33 ; U2.3 130.55,171.21 v3(130.84,171.5) 131.05,171.29 U2.2 ; EMU1.16 100.79,149.68 101.19,150.09 v3(101.19,150.39) ; C181.1 17.26,102.8 U23.21 ; v3(159.51,160.91) 159.38,161.04 159.38,161.41 159.2,161.6 U3.1 ; CN3.3 37.17,127.7 37.07,127.8 37.02,127.8 36.78,128.04 36.78,128.09 36.73,128.14 v1(36.63,128.14) ; U8.2 122.06,143.95 v3(122.3,143.71) 122.04,143.45 U8.1 ; U21.4 76.47,115.45 76.26,115.25 v1(76.26,114.94) ; U17.7 81.58,122.55 v3(82.06,123.03) ; U44.1 127.34,38.69 v3(127.13,38.48) 127.42,38.19 U44.2 ; U7.82 v3(158.96,153.72) ; U13.32 128.66,129.65 v3(128.91,129.9) ; v1(31.02,126.73) 30.99,126.77 30.99,127.36 31.33,127.7 CN3.4 ; v3(157.36,167.6) U3.13 ; U7.9 146.78,149.19 v3(146.58,149) ; v3(169.16,157.34) 169.03,157.21 U4.4 ; v1(76.07,113.03) 76.2,113.16 U55.7 ; U38.13 106.29,47.11 U38.4 ; U10.2 57.42,142.73 v3(57.66,142.49) 57.4,142.23 U10.1 ; U3.10 159.36,166.1 v3(159.63,166.37) 159.63,166.38 159.41,166.6 U3.11 ; v3(21.97,76.73) 21.97,77.19 22.31,77.53 U25.64 23.43,77.53 24.05,78.16 ; U7.21 146.95,143.19 v3(146.86,143.28) ; v1(32.73,82.14) 32.63,82.03 U25.26 ; v3(130.94,64.52) 131.4,64.05 U29.8 ; v3(145.03,137.79) 145.24,138 145.27,138 145.44,138.17 U12.7 ; U25.43 26.06,86.76 26.16,86.87 ; U17.4 76.9,120.99 76.66,120.75 v1(75.9,120.75) ; v3(157.36,168.6) U3.15 ; v3(157.23,163.6) U3.5
  TOP w0.305: v3(18.77,105.97) 19.49,105.97 19.71,106.2 U20.8 ; U40.G8 60.39,43.51 60.78,43.51 U40.G9 61.09,43.41 61.16,43.41 v2(61.44,43.69) 61.03,44.1 U40.F9 ; v2(90.82,47.74) 91.24,47.32 U43.B3 ; U20.12 26.8,109.15 v1(26.92,109.27) 26.92,109.35 26.5,109.77 26.5,109.77 26.47,109.8 U20.13
  TOP w0.356: U35.9 v3(32.37,49.15) ; v3(138.13,154.08) 137.73,153.68 U5.9 ; v3(123.47,66.78) 123.4,66.85 DIMM1.138 ; v3(123.32,58.8) 123.07,59.05 DIMM1.164 ; DIMM1.137 v3(111.95,67.15) ; U5.12 142.15,153.68 v3(141.81,153.34) 142.12,153.03 U5.11 ; DIMM1.3 v3(115.01,109.75) ; DIMM1.73 114.59,86.35 v1(114.84,86.6) ; DIMM1.163 112.22,59.35 v3(111.95,59.62) ; U32.8 132.14,60.73 v3(130.94,60.73) ; U35.3 29.12,43.47 v3(28.83,43.18) 28.47,43.54 U35.2 ; U18.1 158.49,117.07 158.13,116.71 v3(157.81,116.71) ; DIMM1.32 v3(123.16,101.05) ; U6.3 168.9,150.89 v3(168.66,151.13) ; DIMM1.20 122.94,104.65 123.04,104.76 v3(123.14,104.76) ; U67.3 40.29,148.3 40.58,148.01 41.26,148.01 41.59,148.35 U67.1 ; v1(120.13,52.99) 120.18,53.05 DIMM1.184 ; DIMM1.155 v3(112.02,61.75) ; v1(120.13,51.34) 120.22,51.25 DIMM1.190 ; DIMM1.152 119.34,62.65 v3(119.09,62.39) ; U35.8 v3(32.37,43.06) ; DIMM1.178 v3(123.3,54.85) ; v3(127.23,60.73) U32.9 ; v3(123.19,106.68) 122.96,106.45 DIMM1.14 ; v3(115.95,97.11) 115.95,96.83 115.67,96.55 DIMM1.47 ; U26.2 106.76,63.75 v1(107.01,64.01) ; DIMM1.146 v3(123.3,64.45) ; DIMM1.64 v3(123.37,91.45) ; DIMM1.8 v3(123.25,108.25) ; v3(123.22,96.42) 122.79,96.85 DIMM1.46 ; v3(119.18,61.01) 119.34,60.85 DIMM1.158 ; U37.9 38.09,49.61 37.63,49.15 v3(36.7,49.15) ; DIMM1.67 112.15,90.55 111.9,90.8 v3(111.9,92.44) 111.99,92.35 DIMM1.61 ; U37.2 34.19,43.54 v3(34.54,43.18) 34.84,43.47 U37.3 ; DIMM1.17 112.47,105.55 111.88,104.96 v3(111.88,104.89) ; v3(112.02,55.84) 112.12,55.75 DIMM1.175 ; DIMM1.195 115.05,49.75 115.19,49.89 116.12,49.89 v3(116.26,49.75) ; DIMM1.187 v3(112.02,52.15) ; v3(111.85,63.36) 112.04,63.55 DIMM1.149 ; U32.2 131.16,56.83 v3(130.84,57.15) 131.17,57.48 U32.3 ; v3(116.07,102.35) 115.61,101.89 114.68,101.89 114.62,101.95 DIMM1.29 ; DIMM1.169 v3(112.05,57.55) ; v3(123.24,95.07) 123.24,95.07 123.22,95.05 DIMM1.52 ; v3(116.01,97.9) 116.01,98.03 115.66,98.38 114.68,98.38 114.64,98.35 DIMM1.41 ; v3(115.23,107.95) DIMM1.9 ; U18.14 157.19,110.99 v1(156.94,110.75) ; DIMM1.35 v3(112.01,100.15) ; DIMM1.170 v3(123.3,57.25) ; DIMM1.23 114.78,103.75 114.93,103.89 115.46,103.89 v3(116.1,103.26) ; DIMM1.79 112.18,84.55 111.27,85.45 v3(111.27,86.32) ; v3(120.22,49.45) DIMM1.196 ; DIMM1.143 v3(111.91,65.35) ; DIMM1.53 112.11,94.75 111.09,95.78 v3(111.09,96.07) ; v3(123.32,89.65) DIMM1.70 ; U32.14 127,57.48 v3(127.25,57.23) 126.86,56.83 U32.15 ; DIMM1.26 v3(123.16,102.85) ; v3(120.18,110.05) DIMM1.2 ; DIMM1.38 v3(123.16,99.25) ; U37.8 v3(38.09,45.59) ; DIMM1.181 v3(112.02,53.95)
  TOP w0.381: U24.AW27 53.25,75.16 v2(52.78,75.16) ; C103.2 86.74,109.47 86.36,109.85 85.85,109.85 v3(85.83,109.83) 85.83,109.42 85.57,109.16 C102.1 C101.1 ; U24.D34 v2(89.02,67.92) ; C69.2 154.17,137.74 v3(153.9,138.02) ; U24.A38 91.52,64.42 91.52,64.69 91.54,64.71 91.54,65.4 U24.A37 ; U24.A38 91.52,64.39 v2(92,63.91) ; U24.A38 91.5,64.4 90.54,64.4 U24.B38 ; C331.2 67.86,56.58 69.03,57.76 v3(69.05,57.76) ; U24.AN23 59.52,79.5 59,80.01 59,80 58.95,80 58.95,80.05 v2(58.93,80.05) ; v2(78.33,36.49) 77.95,36.11 U42.T1 ; U24.AJ27 U24.AH26 ; U24.AH26 U24.AJ25 ; U24.AH26 U24.AG27 65.99,74.95 v2(65.99,74.88) 66.45,74.42 U24.AF28 ; U24.AT17 56.01,84.91 v2(55.98,84.91) 55.52,84.45 U24.AU18 ; U24.AB14 70.52,88.21 70.91,87.81 70.92,87.81 v2(70.93,87.8) 71.14,87.8 U24.AA15 U24.Y16 v2(73.02,85.92) U24.W17 U24.V18 v2(75.02,83.92) U24.U19 v2(76.02,82.92) U24.T20 76.96,81.98 v2(76.96,81.97) 76.97,81.97 U24.R21 ; C71.1 v3(163.04,135.64) ; 70.99,93.95 U24.AB8 69.98,94.96 ; 70.99,93.95 v2(70.99,93.98) ; 70.99,93.95 U24.AA9 U24.Y10 v2(72.92,92.02) U24.W11 ; C88.2 70.93,132.84 v1(70.87,132.78) 70.81,132.84 C95.1 ; v3(136.96,95.05) 136.96,95.91 137.19,96.14 C211.2 ; U24.AW6 v2(53.02,96.92) ; U24.AM12 60.52,90.36 v2(61.01,89.87) 60.99,89.87 60.54,89.42 U24.AM13 ; Q8.4 151.5,113.94 151.79,113.65 v3(151.79,113.51) ; v2(75.03,86.94) 74.52,86.43 U24.V16 U24.W15 U24.Y14 ; R20.1 167.2,167.22 v3(167.13,167.28) 166.71,167.71 Q1.4 ; v1(110.49,49.71) 110.17,49.38 R432.2 110.17,48.86 110.85,48.18 C336.1 ; U24.W9 v2(74.02,92.92) U24.V10 U24.U11 v2(76.02,90.92) U24.T12 v2(77.02,89.92) U24.R13 U24.P14 U24.N15 ; v3(130.33,133.08) 130.3,133.06 R174.1 ; C301.1 127.86,69.28 v3(127.33,68.76) ; C797.2 62.92,111.06 62.67,110.81 v1(62.67,110.55) ; C812.2 68.79,111.06 68.28,110.55 68.28,110.37 v1(68.28,110.37) ; v2(78.02,80.92) U24.P22 v2(79.02,79.92) U24.N23 v2(80.02,78.92) U24.M24 v2(81.02,77.92) U24.L25 v2(82.02,76.92) U24.K26 v2(83.02,75.92) U24.J27 ; C828.2 170.25,155.76 v3(169.8,156.21) ; U24.U35 75.52,67.42 v2(76.02,66.92) ; v1(103.53,137.9) 103.43,137.9 102.8,137.27 U11.3 ; C341.1 139.12,51.95 138.56,51.38 v3(138.56,51.36) ; v3(125.3,69.75) 124.91,69.36 C305.2 ; C338.2 v3(150.88,51.44) ; C366.2 v3(25.65,40.58) ; U24.AN29 59.52,73.24 v2(59.99,72.77) ; U24.V3 74.52,99.42 75.03,99.93 v2(75.03,99.95) ; C24.2 144.08,162.62 v3(143.89,162.43) ; v2(140.64,75.6) 140.72,75.67 C268.2 ; v1(105.66,68.45) 105.66,68.58 105.23,69.02 R394.1 ; C5.2 127.44,171.59 v3(127.28,171.42) ; v2(57,73.91) 57,73.9 ; 57,73.9 57.52,74.42 U24.AR28 ; 57,73.9 U24.AT29 ; v3(152.65,93.85) C217.2 ; v3(119.61,169.98) 120.14,170.51 C4.2 ; 62.99,81.95 U24.AJ21 64.03,80.91 ; 62.99,81.95 U24.AK20 U24.AL19 ; 62.99,81.95 v2(62.99,81.98) ; v2(57.92,69.03) 57.91,69.03 57.91,69.03 U24.AR33 ; 58.91,80.88 58.98,80.88 U24.AN21 ; 58.91,80.88 58.91,80.96 59.45,80.42 U24.AN22 ; 58.91,80.88 v2(58.91,80.88) ; U24.K5 82.52,97.42 v2(83.02,97.92) U24.J5 ; v2(95.61,41.32) 95.24,41.69 U43.J8 ; C374.2 103.07,39.63 v3(102.59,40.11) ; v1(113.41,115.27) 113.92,115.77 C145.2 ; v1(42.74,123.51) 43.08,123.85 B12.2 ; U24.AH6 v2(65.02,95.92) U24.AG7 65.8,95.14 65.88,95.14 v2(66.15,94.87) 66.37,94.65 66.37,94.57 U24.AF8 v2(67.02,93.92) U24.AE9 v2(68.02,92.92) U24.AD10 v2(69.02,91.92) U24.AC11 U24.AB12 ; R304.2 17.25,106.44 v1(17.64,106.05) ; GPS1.A1 v2(151.57,40.49) ; R241.2 59.62,119.9 CN10.1 58.04,119.13 v3(57.91,119) ; U40.E8 60.19,44.92 60.58,45.31 v2(60.58,45.34) 60.58,45.35 60.22,45.7 U40.D8 ; U24.AL25 61.58,77.42 v2(62.12,76.89) 62.12,76.82 62.36,76.58 62.36,76.58 U24.AK26 ; U24.V6 v2(74.02,96.92) U24.W5 ; U39.E2 43.7,44.94 v2(43.31,45.33) ; v1(67.39,110.39) 67.56,110.56 C811.2 ; U43.F9 96.04,44.12 v2(96.44,44.52) ; U41.B1 v2(65.82,47.7) ; U43.B9 v2(96.44,47.7) U43.A9 ; U24.AJ6 64.01,95.93 64.01,95.88 64.05,95.88 ; C78.2 104.96,132.66 v1(104.78,132.84) 104.59,132.66 R171.2 ; v2(61.02,95.92) U24.AL7 v2(62.02,94.92) U24.AK8 U24.AJ9 63.68,93.42 v2(64.14,92.96) 64.39,92.71 64.39,92.55 U24.AH10 65.02,91.92 ; U24.AN25 59.33,77.42 v2(59.02,77.73) ; U24.C18 v2(90.02,83.92) ; U24.J1 v2(84.02,100.92) 83.52,100.42 U24.J2 ; U43.E8 95.24,44.92 v2(95.65,45.33) 95.27,45.7 U43.D8 ; C192.2 140.72,100.06 v2(140.64,99.99) ; U40.P9 61.4,37.7 v1(61.59,37.9) ; 82.04,72.9 82.04,73.03 81.64,73.42 U24.L29 v2(81.02,73.92) U24.M28 v2(80.02,74.92) U24.N27 U24.P26 ; 82.04,72.9 v2(82.03,72.9) ; 82.04,72.9 82.05,72.9 82.31,72.64 82.31,72.63 U24.K30 v2(83.02,71.92) U24.J31 ; R357.2 16.99,80.46 v3(16.61,80.09) ; C35.1 150.05,156.9 v3(150.14,156.99) ; B25.2 45.53,122.3 44.91,121.68 v1(44.83,121.68) ; R389.1 105.23,71.54 v1(105.78,70.99) 105.74,70.99 105.24,70.48 R390.1 ; U24.C4 89.55,98.42 v2(90.03,98.91) ; v2(72.21,38.09) 72.23,38.09 U41.P9 ; v2(90.03,89.94) 89.54,90.42 U24.C12 ; U24.AH8 v2(65.02,93.92) U24.AG9 v2(66.02,92.92) U24.AF10 v2(67.02,91.92) U24.AE11 v2(68.02,90.92) U24.AD12 v2(69.02,89.92) U24.AC13 ; v2(59.02,94.97) 59.48,95.42 U24.AN7 ; v2(59.02,94.97) 59.52,94.48 U24.AN8 ; v2(59.02,94.97) 58.57,95.42 U24.AP7 ; U24.AA11 v2(71.02,91.92) U24.AB10 U24.AC9 U24.AD8 v2(68.02,94.92) U24.AE7 v2(67.02,95.92) U24.AF6 ; C195.2 138.11,100.42 v2(137.59,100.94) ; v1(93.85,122.89) 93.95,122.98 R817.2 ; v3(176.5,144.88) 176.23,145.16 Q5.2 ; U24.R31 v2(77.02,71.92) U24.T30 ; v2(55.02,38.09) 54.63,37.7 U40.P1 ; v3(144.65,113.16) 144.23,113.58 Q7.4 ; R172.1 v1(108.71,133.35) R151.1 ; U42.T9 84.35,36.09 83.82,35.56 v2(83.31,35.56) ; U24.U27 75.18,75.76 75.18,75.92 v2(75.18,75.92) 74.93,76.18 74.93,76.2 74.71,76.42 U24.V26 ; C285.2 109.65,73.71 v3(109.65,72.64) ; v2(57,99.87) 57.44,99.42 U24.AR3 U24.AP4 U24.AN5 59.47,97.38 59.47,96.47 U24.AN6 59.53,96.42 59.92,96.04 v2(59.99,96.04) ; U24.AW21 v2(52.87,81.42) ; v2(66.61,41.31) 66.61,41.31 67.01,41.7 U41.J2 ; v1(26.16,86.84) C230.2 ; Q6.2 121.28,120.17 v1(121.16,120.3) ; v2(143.64,75.6) 144.2,76.16 C270.2 ; U24.L13 v2(82.02,88.92) U24.K14 v2(83.02,87.92) U24.J15 v2(84.02,86.92) ; v3(161.93,38.86) 162.43,38.35 CN22.9 ; v2(64.14,94.92) 64.1,94.92 63.6,95.42 U24.AJ7 ; U39.D1 v2(42.5,46.1) ; R6.1 v3(155.32,173.04) ; C375.2 v3(171,40.64) ; U24.AD33 68.51,69.41 68.07,68.98 67.94,68.98 67.94,68.95 v2(67.97,68.95) ; DIMM1.78 v3(123.36,84.85) ; C181.1 18.05,103.57 19.13,104.65 v3(19.16,104.65) ; v3(32.33,72.72) 32.36,72.72 33.02,73.38 C284.2 ; v2(90.02,95.92) 89.52,96.42 U24.C6 ; R224.1 120.85,122.55 120.85,122.51 121.39,121.98 v1(121.39,121.75) 121.27,121.63 120.36,121.63 119.89,121.16 C125.2 ; U24.AN18 59.34,84.42 v2(58.93,84.84) 58.93,84.83 59.52,85.42 U24.AN17 ; v3(126.11,133.1) 126.62,132.59 C86.1 ; R207.2 67.74,134.82 v1(67.39,134.46) 67.03,134.82 C112.2 ; U24.AE3 67.03,99.91 v2(67.03,100.09) ; v1(176.91,157.02) 176.97,157.02 177.41,156.58 Q3.2 ; v3(142.54,171.75) 143.26,172.47 R9.2 ; v3(153.75,82.63) 153.35,82.23 C246.1 ; U41.M1 66.24,39.3 v2(66.62,39.69) ; U42.E8 v2(83.95,45.3) U42.D8 ; U24.AL11 U24.AK12 v2(63.01,89.93) U24.AJ13 v2(64.02,88.92) U24.AH14 U24.AG15 v2(66.02,86.92) U24.AF16 U24.AE17 v2(68.02,84.92) U24.AD18 ; v2(80.01,80.92) 80.01,80.93 U24.N21 ; U24.AL15 U24.AK16 62.97,85.97 62.97,85.94 v2(62.96,85.94) 63.48,85.42 U24.AJ17 v2(64.02,84.92) U24.AH18 v2(65.02,83.92) U24.AG19 v2(66.02,82.92) U24.AF20 v2(67.02,81.92) U24.AE21 U24.AD22 68.52,80.24 v2(69.01,79.74) 69.33,79.42 U24.AC23 69.92,79.02 69.92,78.81 v2(69.92,78.81) 70.31,78.42 U24.AB24 70.99,77.95 ; U24.AB30 69.98,72.96 v2(69.98,73.03) 69.58,73.42 U24.AC29 ; v2(54.97,35.7) 54.97,35.72 U40.T1 ; 108.74,124.71 108.99,124.46 U16.68 ; C25.2 162.16,163.39 v1(162.48,163.07) ; U24.AK30 62.02,71.92 v2(62.02,71.92) U24.AL31 ; v2(65.79,42.91) 66.19,43.3 U41.G1 ; C228.2 21.39,88.83 20.38,87.81 C232.2 20.38,87.7 21.58,86.49 v1(22.48,86.49) ; U42.B3 v2(79.95,47.7) ; v2(52.53,93.63) 52.73,93.42 U24.AW9 ; v3(162.36,103.56) C183.2 ; v2(69.98,94.82) 69.98,94.96 ; 69.98,94.96 U24.AC7 v2(69.02,95.92) U24.AD6 67.94,96.99 v2(67.9,96.99) ; v1(103.84,123.02) 103.88,123.02 104.04,122.86 104.63,122.86 C119.2 ; v2(60.03,80.89) 60.5,80.42 U24.AM22 ; U24.J4 83.52,98.63 v2(83.99,99.11) ; U39.G1 42.81,43.3 v1(42.45,43.66) ; v2(69.06,71.92) 69.05,71.92 68.55,72.42 U24.AD30 v2(68.02,72.92) U24.AE29 ; C231.2 31.5,88.33 v1(31.88,87.96) ; U39.B3 44.51,47.3 44.92,47.71 v2(44.92,47.75) ; U24.P5 v2(78.02,97.92) ; v3(10.41,59.44) 11.43,59.44 12.38,58.48 C729.2 ; v3(146.86,143.28) 146.81,143.28 146.38,142.85 146.14,142.85 C427.1 ; U24.J21 v2(83.02,81.92) U24.K20 v2(82.02,82.92) U24.L19 ; C133.2 149.42,119.58 v3(149.73,119.89) 149.99,119.63 R251.1 ; C109.2 105.05,125.66 v1(104.7,126.01) 104.35,125.66 R209.2 ; v2(49.76,38.89) 49.35,39.3 U39.M9 ; C168.2 R303.2 96.59,114.95 96.65,115.01 v3(96.8,115.01) ; U24.T24 v2(76.02,78.92) U24.U23 v2(75.02,79.92) U24.V22 v2(74.03,80.91) U24.W21 72.97,81.97 v2(72.84,81.97) ; C325.1 137.28,60.92 137.85,60.35 v1(137.85,60.33) ; U24.U13 v2(75.02,89.92) U24.V12 ; v2(96.52,38.88) 96.46,38.88 U43.M9 ; U24.AK37 v2(62.02,64.92) ; U24.P37 78.52,65.42 v2(79.02,64.92) ; C263.2 153.35,77.78 v3(153.8,78.23) ; SOCKET1.H3 47.73,109.73 50.83,106.63 v3(51.89,106.63) ; U42.B1 v2(77.55,47.7) ; v2(145.29,41.78) 145.29,41.72 GPS1.E2 ; v2(86.02,66.92) 85.52,67.42 U24.G35 ; v2(83.99,99.11) 83.68,99.42 U24.J3 ; v2(83.99,99.11) 84.52,98.59 U24.H4 ; 122.58,130.65 122.58,130.14 122.49,130.06 122.49,129.41 R197.1 ; 122.58,130.65 122.1,130.18 121.71,130.18 v1(121.25,130.63) ; 122.58,130.65 R191.1 ; GPS1.E6 144.91,47.24 v2(145.54,47.88) ; 67.06,77.88 U24.AF24 66.18,78.76 66.18,78.86 v2(65.96,79.08) 65.84,79.2 65.74,79.2 U24.AG23 65.47,79.42 65.24,79.65 65.13,79.65 65.04,79.74 v2(65.02,79.74) 65.02,79.92 U24.AH22 64.03,80.91 ; 67.06,77.88 v2(67.06,77.98) ; 67.06,77.88 U24.AE25 ; v2(144.02,46.48) 143.32,45.78 GPS1.F5 ; U24.AB33 70.52,69.42 v2(70.05,68.96) ; C62.1 121.51,139.15 v3(121.38,139.01) 120.94,139.01 R113.1 ; R442.2 107.64,44.27 v3(107.82,44.45) 108.27,44 C357.2 ; v2(60.01,76.16) 60.01,76.17 59.76,76.42 U24.AN26 ; v3(65.79,114.3) 65.28,114.3 64.9,113.92 64.9,112.71 65.65,111.96 C796.2 ; v1(73.41,43.3) U41.G9 72.5,43.43 71.94,43.43 U41.G8 ; C193.2 144.2,100.55 v2(143.64,99.99) ; U24.AU6 55.42,96.42 v2(54.94,96.9) 54.52,97.32 U24.AV5 ; U42.E1 77.95,44.92 78.34,45.31 ; v1(116.54,114.36) 116.54,114.6 116.97,115.03 R268.1 ; v2(70.02,96.92) U24.AB6 v2(71.02,95.92) U24.AA7 ; v3(59.03,140.34) 59.03,140.08 58.74,139.79 R136.1 ; R323.1 v3(135.89,100.84) ; C32.2 87.83,158.88 v3(87.45,158.5) ; U24.AN13 59.68,89.42 59.8,89.55 59.81,89.55 v2(60.03,89.76) 60.02,89.76 59.52,90.27 U24.AN12 ; U24.AN20 v2(59.02,82.92) 58.52,82.42 U24.AP20 ; v1(153.54,120.78) 153.98,120.34 C127.1 ; v2(72.95,94.87) 72.9,94.82 72.9,94.8 U24.Y8 ; U24.M33 80.52,69.42 v2(81.02,68.92) ; v3(124.79,66.83) 124.79,66.85 125.25,67.31 B39.2 ; 59.05,75.01 v2(59.05,75.06) ; 59.05,75.01 59.05,74.88 59.51,74.42 U24.AN28 ; 59.05,75.01 59.47,75.42 59.52,75.42 U24.AN27 ; v3(146.58,149) 146.23,148.65 C45.1 ; 49.06,123.88 R252.2 ; 49.06,123.88 R235.2 ; 49.06,123.88 49.57,123.37 v1(49.57,123.18) ; U24.AE27 v2(67.02,75.92) U24.AF26 ; R470.2 100.78,34.99 v3(100.33,34.54) ; C829.1 56.2,138.39 v3(55.83,138.76) 55.85,138.79 55.87,138.79 C74.1 ; R360.1 v3(18.8,77.98) R361.1 ; C251.2 36.14,80.12 36.73,79.53 v1(36.91,79.53) 36.91,80.85 37.28,81.22 37.28,82.54 R351.1 ; U41.M9 72.62,39.27 73.02,38.86 73.03,38.86 v1(73.1,38.79) ; U24.AD26 v2(69.02,75.92) U24.AC27 ; U24.AW12 53.49,90.42 v2(52.96,90.96) ; U24.AP37 v2(58.02,64.92) ; U24.AM3 60.52,99.58 v2(60.02,100.08) 59.67,100.42 U24.AN2 ; v2(69.09,87.88) 69.09,87.85 ; 69.09,87.85 U24.AC15 U24.AB16 70.94,86 v2(70.94,85.88) 71.06,85.88 U24.AA17 U24.Y18 v2(73.02,83.92) U24.W19 v2(74.02,82.92) U24.V20 ; 69.09,87.85 U24.AD14 v2(68.02,88.92) U24.AE13 U24.AF12 66.52,90.43 v2(65.92,91.03) 65.52,91.42 U24.AG11 65.02,91.92 ; U39.D8 48.5,45.7 v2(48.92,45.29) 48.9,45.27 48.83,45.27 48.5,44.95 U39.E8 ; U24.T14 v2(77.02,87.92) U24.R15 U24.P16 U24.N17 ; R58.1 107.64,152.52 v1(107.44,152.71) ; U24.C16 89.52,86.42 v2(90.02,85.92) ; v1(53.67,110.67) 53.67,110.38 C802.2 ; v1(77.99,109.79) 77.85,109.65 R313.2 R312.2 ; U24.B1 90.52,101.63 v2(90.04,102.11) 89.52,101.58 U24.C1 ; U24.AL29 v2(61.96,73.87) 62.52,74.42 U24.AK28 ; v3(99.42,44.27) 99.44,44.27 99.88,44.71 C356.2 ; U34.4 v3(130.73,53.4) ; C255.2 153.35,79.38 v3(153.73,79.76) ; v3(102.62,42.85) 102.62,43.13 103.07,43.58 C361.2 ; U24.AT20 56.59,82.42 v2(57.01,82) 57.52,81.49 U24.AR21 ; U24.V37 74.52,65.42 v2(75.02,64.92) ; C247.1 v3(124.33,80.47) ; v2(87.98,90.93) 87.88,91.03 87.88,91.03 87.52,91.4 U24.E11 ; R815.2 101.35,130.24 101.35,131.7 100.84,132.21 v1(100.58,132.21) ; OSC1.2 v3(165.99,139.12) ; C214.1 153.35,95.32 152.78,95.88 v3(152.78,95.88) 153.35,96.45 C209.1 ; C124.1 104.16,121.54 v1(103.89,121.27) ; U24.AM37 v2(60.02,64.92) ; U24.AW3 53.52,99.49 v2(53.04,99.97) 53.52,100.46 U24.AW2 ; v2(85.98,71.87) 85.98,71.89 U24.G31 ; U24.AE31 v2(67.02,71.92) U24.AF30 v2(66.02,72.92) U24.AG29 65.36,73.42 64.52,74.27 U24.AH28 64.52,74.42 64.25,74.16 64.22,74.16 63.52,73.45 U24.AJ29 64.11,72.83 ; v3(103.17,53.72) 101.78,55.12 SOCKET1.H2 ; 62.99,87.95 U24.AK14 U24.AL13 ; 62.99,87.95 v2(62.99,87.95) ; 62.99,87.95 U24.AJ15 v2(64.02,86.92) U24.AH16 v2(65.02,85.92) U24.AG17 U24.AF18 66.99,83.95 v2(67.06,83.95) ; U24.G23 85.38,79.42 v2(84.9,78.94) ; U24.N19 79.52,83.53 v2(79.18,83.87) 79.07,83.87 78.52,84.42 U24.P18 U24.R17 v2(77.02,85.92) U24.T16 U24.U15 v2(75.02,87.92) U24.V14 v2(74.02,88.92) U24.W13 v2(73.02,89.92) U24.Y12 ; U24.AL21 U24.AK22 v2(63.02,79.92) U24.AJ23 63.82,79.12 v2(64.01,79.12) 64.01,78.93 U24.AH24 U24.AG25 65.9,77.04 v2(65.9,76.95) ; U24.AP24 58.52,78.24 v2(59.02,77.73) ; v3(107.14,70.89) 107.24,70.79 108.03,70.79 C299.2 107.84,71.65 107.25,71.65 v3(107.22,71.63) ; U42.G8 83.56,43.3 v2(83.94,43.68) 83.96,43.68 84.33,43.3 U42.G9 ; 70.99,77.95 U24.AA25 72.01,76.93 72.01,76.96 v2(72,76.96) 72.25,76.72 72.25,76.69 U24.Y26 v2(73.02,75.92) U24.W27 ; 70.99,77.95 v2(70.99,77.85) ; v3(129.39,68.81) 129.39,69.09 129.65,69.35 C800.2 ; v3(160.91,166.88) 160.91,166.99 161.11,167.19 C17.2 ; U24.AL27 61.52,75.4 v2(62,74.92) ; v2(55.02,69.92) U24.AV32 54.52,70.42 U24.AW33 ; U43.B1 v2(89.24,47.7) ; SOCKET1.H1 43.79,55.12 v3(42.01,53.34) ; U24.H12 v2(84.02,90.92) U24.J11 v2(83.02,91.92) U24.K10 U24.L9 U24.M8 v2(80.02,94.92) U24.N7 U24.P6 v2(78.02,96.92) U24.R5 ; U24.AU30 55.44,72.42 v2(54.99,72.87) 54.52,73.35 U24.AV29 ; U42.J8 83.55,41.69 v2(83.92,41.32) ; v2(58.04,82.93) 58.04,82.95 58.52,83.42 U24.AP19 ; U24.H30 84.25,72.69 84.25,72.9 v2(84.24,72.91) 84.25,72.92 84.25,73.1 84.52,73.37 U24.H29 ; v3(133.2,102.74) 132.69,102.24 EEPROM1.4 ; U24.H18 v2(84.02,84.92) U24.J17 v2(83.02,85.92) U24.K16 v2(82.02,86.92) U24.L15 ; 64.03,80.91 v2(64.03,80.92) ; v2(142.56,96.12) 142.66,96.01 C212.2 ; R308.2 v1(61.72,107.57) ; C163.2 44.8,117.9 v1(44.54,117.9) 44.54,117.87 C118.2 ; U24.U31 v2(75.02,71.92) U24.V30 v2(74.02,72.92) U24.W29 ; v2(54,84.94) 54.44,85.37 54.47,85.37 U24.AV17 ; U24.AK24 62.15,78.79 62.15,78.84 v2(62,78.99) 61.82,79.17 61.77,79.17 U24.AL23 ; v1(105.8,73.27) 105.36,73.27 R385.1 ; C140.2 105.61,118.43 104.88,117.71 v1(104.88,117.48) ; U42.J2 78.75,41.7 78.36,41.32 78.36,41.29 78.34,41.29 v2(78.34,41.3) ; U24.AT5 56.52,97.41 56.11,97 v2(56.11,96.9) ; v2(54.97,41.32) 54.97,41.34 55.33,41.7 U40.J2 ; C16.2 107.2,167.59 v3(107.2,166.47) 107.19,166.47 107.19,166.5 C18.2 ; v3(38.3,67.61) 38.38,67.69 C819.2 ; 64.05,95.88 v2(64.09,95.88) ; 64.05,95.88 U24.AH7 ; U42.M9 84.35,39.29 v2(83.95,38.89) ; v2(81.18,81.92) 81.18,81.87 81.52,81.53 U24.L21 v2(82.02,80.92) U24.K22 v2(83.02,79.92) U24.J23 U24.H24 84.96,77.98 84.96,77.96 v2(84.98,77.96) U24.G25 U24.H26 ; R275.2 23.17,112.33 v1(22.86,112.01) ; U24.E28 87.07,73.98 v2(87,73.98) ; U39.T9 49.49,35.92 50.13,35.92 50.46,36.25 50.46,36.44 v2(50.47,36.45) ; C334.1 v3(130.61,55.75) ; U24.AV2 54.52,100.45 v2(53.87,101.09) 53.87,101.12 54.18,101.42 U24.AV1 ; R800.1 76.77,111.58 76.2,112.14 76.2,112.9 v1(76.07,113.03) ; U39.T1 42.42,36.1 41.66,36.87 v2(41.66,37.08) ; C72.2 v3(154.94,136.46) ; U24.AR15 v2(57.02,87.92) U24.AT14 ; C382.1 v3(145.61,37.15) ; U24.AL5 61.52,97.33 v2(61.95,96.9) 62.43,96.42 U24.AK6 ; v1(46.1,126.49) 46.67,125.93 C107.1 ; U24.M22 v2(81.02,79.92) U24.L23 v2(82.02,78.92) U24.K24 v2(83.02,77.92) ; C281.1 25.46,73.46 25.74,73.74 v3(25.74,73.83) 26.1,73.46 C282.2 ; v1(121.92,125.22) 121.54,124.84 120.27,124.84 120.02,125.09 B13.2 ; v1(97.93,126.66) 97.78,126.5 CN11.H1 ; v1(77.39,46.27) U42.D1 78.34,45.31 ; v2(72.19,41.32) 71.82,41.69 U41.J8 ; U41.E2 U41.D1 U41.E1 66.14,44.9 v2(65.77,44.53) ; 64.03,70.87 v2(64.14,70.87) ; 64.03,70.87 64.03,70.89 63.5,71.42 U24.AJ31 ; 64.03,70.87 63.96,70.87 U24.AJ32 ; C165.2 157.36,109.28 v1(157.68,109.6) ; U39.G9 49.28,43.3 v2(48.9,43.69) 48.51,43.3 U39.G8 ; C159.2 148.61,110.42 v3(148.92,110.11) ; R213.2 C117.2 41.08,118.18 42.14,117.11 v3(42.14,116.97) ; U24.N29 v2(80.02,72.92) U24.M30 ; v2(88.02,83.05) 87.65,83.42 U24.E19 ; v1(73.23,35.69) 72.81,36.1 U41.T9 ; C731.2 11.25,56.52 v3(11.1,56.36) ; U24.AR9 57.42,93.42 v2(56.92,93.92) 56.52,94.33 U24.AT8 ; v2(137.41,72.26) 137.6,72.08 C296.2 ; v1(110.32,131.13) 110.31,131.13 110.04,131.41 C80.2 ; v1(39.24,125.79) 39.81,125.79 40.01,125.98 B10.2 ; U24.AM8 v2(61.02,93.92) U24.AL9 v2(62.02,92.92) U24.AK10 U24.AJ11 v2(64.02,90.92) U24.AH12 U24.AG13 v2(66.02,88.92) U24.AF14 U24.AE15 ; v2(87.06,94.89) 87.06,94.97 U24.E7 ; U42.P1 78,37.7 v2(78.38,38.09) ; v2(60.99,82.93) 60.9,82.84 60.9,82.8 U24.AM20 ; v2(48.9,41.28) 48.89,41.28 48.5,41.67 U39.J8 ; U40.M9 60.98,39.3 v2(60.58,38.89) ; v2(88.02,86.92) 87.52,87.42 U24.E15 ; C131.1 125.93,118.8 v3(125.43,119.3) ; C283.2 29.08,73.43 29.59,72.92 v3(29.59,72.77) ; U40.E2 55.38,44.95 v2(54.99,45.34) 54.59,44.93 U40.E1 ; U24.AG35 v2(65.02,66.92) ; U24.AN31 59.94,71 59.94,70.97 v2(59.99,70.92) ; U24.AH33 64.04,68.95 v2(63.95,68.95) ; v1(49.89,43.99) 49.77,44.1 U39.F9 ; R29.1 44.27,159.18 44.54,158.9 v1(44.7,158.9) ; v1(109.63,54.05) 110.17,53.51 R410.2 ; U24.AN9 59.01,93.93 v2(59,93.93) ; C295.2 143.43,71.6 142.64,71.6 142.52,71.72 v2(142.56,71.72) ; U24.AM17 60.52,85.42 60.02,84.92 v2(60.02,84.72) 60.32,84.42 U24.AM18 ; v2(79.02,68.92) 78.52,69.42 U24.P33 ; C164.1 v1(155.57,108.71) ; C202.2 149.16,98.48 v2(148.64,98.99) ; C322.2 v1(151.7,60.63) ; U24.J7 83.99,94.95 v2(84,94.95) 84.52,94.43 U24.H8 ; U24.U17 v2(76.02,84.92) U24.T18 v2(77.04,83.9) U24.R19 U24.P20 ; 73.03,77.92 v2(73.03,77.98) ; 73.03,77.92 U24.W25 ; 73.03,77.92 U24.Y24 U24.AA23 71.32,79.42 v2(70.94,79.81) 70.52,80.23 U24.AB22 U24.AC21 69.52,81.5 v2(68.98,82.04) 68.59,82.42 U24.AD20 67.94,83 ; C805.2 67.76,113.99 v3(68.56,114.79) 68.96,114.39 C806.2 C807.1 ; U24.AA13 U24.Y14 ; U24.Y14 72.6,88.42 v2(72.97,88.8) ; U24.AT11 56.52,91.33 v2(56.97,90.87) 57.07,90.87 U24.AR12 ; U24.V33 74.52,69.42 v2(75.02,68.92) ; v3(21.82,45.27) R437.2 ; v2(57.02,80.88) 57.06,80.88 U24.AR22 ; U24.U7 v2(76.02,94.92) U24.T8 v2(77.02,93.92) U24.R9 U24.P10 ; R28.2 v1(109.35,158.45) ; C378.2 v3(103.69,35.18) ; 65.02,91.92 v2(65.02,92.08) ; U24.C20 v2(90.02,81.92) ; U24.V28 v2(75.02,73.92) U24.U29 ; U24.U21 v2(76.02,80.92) U24.T22 v2(77.02,79.92) U24.R23 v2(78.02,78.92) U24.P24 U24.N25 79.95,76.99 v2(80.04,76.99) 80.52,76.51 U24.M26 v2(81.02,75.92) U24.L27 v2(82.02,74.92) U24.K28 v2(83.02,73.92) U24.J29 83.52,73.48 v2(84.02,73.97) 84.46,74.42 U24.H28 ; GPS1.B2 v2(150.07,41.99) ; B14.2 89.13,108.03 v1(88.62,107.52) ; v1(43.81,125.62) C94.1 C93.2 ; v2(142.64,98.99) 143.13,98.51 C204.2 ; U42.B9 v2(84.75,47.7) U42.A9 ; U43.G9 96.03,43.3 v2(95.64,43.69) 95.26,43.3 U43.G8 ; U39.B9 49.3,47.35 v2(49.68,47.73) 49.66,47.75 49.66,47.75 49.3,48.1 U39.A9 ; v3(88.31,110.21) 88.22,110.12 C497.2 ; 67.94,83 v2(67.94,83.06) ; 67.94,83 U24.AE19 ; U24.AR25 U24.AT26 56.52,76.42 v2(56.02,75.92) U24.AU27 ; v2(54.13,45.36) 54.48,45.7 U40.D1 ; U24.T28 76.52,74.23 v2(76.96,73.79) 77.33,73.42 U24.R29 U24.P30 v2(79.02,71.92) U24.N31 ; C126.2 62.74,131.37 62.59,131.52 62.59,131.96 v3(62.59,131.97) 62.59,132.19 63.2,132.79 C123.2 64.81,132.79 v3(64.92,132.68) 64.92,132.69 64.14,131.91 R225.2 ; v2(78.05,91.97) 78.05,91.96 U24.R11 ; U41.B3 v2(67.42,47.7) ; U24.AK2 62.52,100.42 62.97,100.87 v2(62.97,100.91) ; v2(80.95,86.79) 81.52,87.36 U24.L15 ; v1(175.76,152.35) 175.52,152.59 Q4.2 ; 68.96,77.98 U24.AD24 68.07,78.87 v2(67.94,78.87) ; 68.96,77.98 v2(68.96,77.93) ; 68.96,77.98 U24.AC25 ; C304.2 v1(109.44,67.82) ; U24.AG31 v2(65.02,71.92) U24.AH30 64.11,72.83 ; U24.AV11 54.52,91.3 v2(54.86,90.96) 55.4,90.42 U24.AU12 ; C54.2 v3(168.2,40.89) ; U24.AJ35 v2(63.02,66.92) ; U24.C32 v2(90.02,69.92) ; v3(131.6,171.45) 131.6,171.7 131.39,171.91 C6.2 ; C21.2 v3(163.89,165.42) ; v2(90.02,36.49) 89.64,36.11 U43.T1 ; U24.AV8 55.04,93.9 ; 55.04,93.9 v2(55.04,93.91) ; 55.04,93.9 U24.AU9 ; U16.87 114.79,125.26 115.24,125.71 ; U40.M1 54.2,39.69 v2(54.18,39.69) ; U24.AP30 58.36,72.42 57.96,72.82 v2(57.96,73.04) 57.99,73.04 58.37,73.42 U24.AP29 ; v2(56.02,69.92) U24.AU33 ; U24.N13 U24.M14 U24.L15 ; v2(66.02,97.92) U24.AG4 ; C201.1 153.35,99.4 152.81,98.86 v1(152.77,98.86) ; C363.2 107.64,42.6 107.25,43 v1(107.25,43.05) ; C135.1 45.17,116.45 45.17,116.59 v1(45.06,116.71) 45.52,117.17 R260.1 ; C220.2 v3(152.65,92.46) ; R365.2 C260.2 14.45,77.98 14.02,78.41 v1(14.02,78.66) ; v3(170.94,152.78) C42.2 ; 78.34,45.31 U42.E2 ; v2(78.36,39.69) 77.97,39.3 U42.M1 ; B31.2 v3(24.51,88.59) ; R298.2 28.98,107.44 v1(29.01,107.47) ; C158.2 v3(141.48,110.24) ; U24.T33 76.9,69.04 v2(76.9,68.92) ; U24.Y37 72.51,65.41 v2(72.02,64.92) ; U24.AP28 58.29,74.42 v2(57.99,74.73) 57.99,74.89 U24.AP27 ; C106.2 45.27,125.93 v1(44.7,126.49) ; B4.1 v3(171.7,171.52) ; v3(32.82,71.57) R397.1 ; v2(84.95,72.85) U24.G29 ; U24.H14 v2(84.02,88.92) U24.J13 v2(83.02,89.92) U24.K12 U24.L11 ; v2(52.7,78.51) 52.79,78.42 U24.AW24 ; R352.2 16.78,82.49 v3(16.41,82.12) ; C269.1 18.5,76.45 v3(18.8,76.75) ; v2(88.01,92.91) 88.01,92.91 87.52,93.41 U24.E9 ; U24.M16 U24.L17 v2(82.02,84.92) U24.K18 U24.J19 v2(84.02,82.92) U24.H20 ; v1(105.79,114.93) 105.66,115.06 C146.1 ; CN3.H8 35.32,159.77 34.92,160.17 34.71,160.17 v2(34.7,160.16) ; v3(157.43,135.97) 157.5,135.97 C73.2 ; C804.1 C803.2 56.18,110.53 v1(56.26,110.62) ; C261.2 146.24,76.9 v2(146.56,76.58) ; CN6.1 v1(44.73,144.63) ; v2(56.71,47.44) 56.67,47.4 56.28,47.4 U40.B3 ; v2(60.99,92.97) 60.99,92.9 U24.AM10 ; v3(133.29,157.35) C34.1 ; v2(83.02,77.92) U24.J25 ; v2(83.02,77.92) U24.J24 ; CN5.3 48.09,137.06 48.7,137.67 v3(49.1,137.67) ; B47.2 v3(137.69,80.34) ; R289.2 153.21,109.28 153.52,109.59 v1(153.52,109.68) ; R255.1 143.44,119.38 v3(143.24,119.38) 143.05,119.58 C132.2 ; U24.AL17 U24.AK18 v2(62.93,84.01) U24.AJ19 v2(64.02,82.92) U24.AH20 U24.AG21 65.85,81.09 65.85,81.07 v2(66.06,80.86) 66.28,80.64 66.3,80.64 U24.AF22 v2(67.02,79.92) U24.AE23 ; CN13.H1 57.7,125.97 58.53,126.81 ; U43.D1 89.54,45.7 v2(89.19,45.36) 89.64,44.9 U43.E1 ; U43.M1 89.66,39.3 v2(90.04,39.69) ; C160.1 110.85,111.24 C161.1 109.21,111.46 v1(109.21,112.93) ; DIMM1.58 120.5,93.25 v3(120.2,92.95) ; U40.T9 60.98,36 v2(61.34,35.65) ; v2(55.93,102.11) 55.52,101.69 U24.AU1 55.52,101.4 56.5,100.42 U24.AT2 ; U24.AV20 v2(55.02,81.92) U24.AU21 ; U24.AU15 55.47,87.42 55.04,87.85 v2(55.01,87.85) 54.52,88.35 U24.AV14 ; U24.AP13 v2(59.02,88.92) U24.AN14 ; U42.G1 77.95,43.3 v2(77.55,43.7) ; U24.AL35 v2(61.02,66.92) ; v3(153.92,173.04) R5.1 ; v1(19.63,113.16) R274.2 ; C70.2 v3(159.85,135.64) ; C137.2 59.18,126.24 v3(58.85,125.91) ; v2(85.04,74.93) 85.04,74.95 U24.G27 ; U24.AA29 v2(72.02,72.92) U24.Y30 v2(73.02,71.92) U24.W31 ; B8.2 122.61,134.31 v1(122.62,134.32) ; U24.C26 89.03,76.91 v2(89.03,76.98) ; U24.R35 77.52,67.42 77.8,67.14 v2(78.02,66.92) ; 152.27,100.84 C194.2 ; C136.2 118.55,118.71 118.06,119.2 v1(118.06,119.29) ; C297.2 144.97,71.75 145.04,71.81 145.04,71.99 v2(145.64,72.6) ; U42.F9 84.56,44.1 v1(84.89,44.44) ; C29.2 v1(107.7,158.31) ; v2(56.98,84.91) 57.02,84.91 57.02,84.92 U24.AR18 ; C358.2 110.81,44 v3(111.18,43.64) 111.54,44 C359.2 ; v2(53.04,87.78) 53.39,87.42 U24.AW15 ; C278.2 149.16,74.09 v2(148.64,74.6) ; U24.H37 84.52,65.42 v2(85.02,64.92) ; C262.2 138.11,77.14 v2(138.64,76.6) 138.11,76.06 C273.2 ; v1(28.41,112.36) 28.45,112.4 29.51,112.4 30.17,111.74 R279.2 ; C37.2 156.89,156.9 v3(157,157.01) 157.11,157.12 C38.1 ; C114.2 119.18,123.95 v1(118.97,124.16) ; R159.2 110.04,132.89 v1(110.31,132.62) ; 42.22,148.82 42.22,148.83 42.21,148.83 42.21,148.82 43,148.03 C843.1 ; 42.22,148.82 v3(42.24,148.82) ; 42.22,148.82 42.22,148.82 42.14,148.9 41.62,148.9 U67.1 ; R218.2 122.61,123.84 v1(122.07,124.38) 122.61,124.92 R212.1 ; U24.T6 v2(77.02,95.92) U24.R7 U24.P8 U24.N9 U24.M10 ; 112.89,121.18 112.94,121.23 U16.85 ; v2(60.54,41.3) 60.19,41.66 U40.J8 ; U24.AU3 55.52,99.7 55.51,99.71 55.51,100.14 55.52,100.14 U24.AU2 55.46,100.42 54.94,100.94 v2(54.94,100.99) ; U24.Y33 v2(72.02,68.92) ; U24.N5 v2(80.02,96.92) U24.M6 U24.L7 U24.K8 v2(83.02,93.92) U24.J9 ; SOCKET1.H4 98.27,109.73 v3(96.39,107.85) ; U24.AM32 60.44,70.42 v2(59.94,69.93) 60.52,69.35 U24.AM33 ; v3(164.01,163.09) 163.71,163.39 C26.2 ; v1(92.72,111.37) 92.33,111.76 R301.2 ; v2(90.04,38.11) 90.04,38.11 U43.P1 ; C2.2 v3(105.98,174.81) ; v3(90.81,152.63) 90.81,152.34 R54.2 ; C3.2 146.79,173.68 v3(146.1,174.37) ; v3(99.62,46.36) C355.2 ; C33.1 v3(161.47,160.21) ; U24.R11 U24.P12 ; U24.R11 U24.T10 U24.U9 U24.V8 v2(74.02,94.92) U24.W7 v2(73.02,95.92) U24.Y6 v2(72.02,96.92) U24.AA5 v2(71.02,97.92) ; C274.2 142.2,75.16 v2(142.64,75.6) ; R24.1 v3(172.78,154.11) ; 64.11,72.83 v2(64.11,72.82) ; C58.2 86.87,144.15 87.25,143.76 v3(87.25,143.69) ; U24.AC35 v2(69.02,66.92) ; U43.P9 95.97,37.7 95.63,38.04 v2(95.63,38.09) ; U24.E5 v2(87.99,97.89) ; v2(42.2,37.22) 42.42,37.22 U39.P1 ; v2(42.42,47.75) 42.42,47.75 42.87,47.3 U39.B1 ; CN13.H2 56.1,124.75 55.38,125.46 v1(55.37,125.46) ; v2(52.91,72.29) 53.04,72.42 U24.AW30 ; U24.R2 77.52,100.42 v2(78.02,100.92) ; U41.A9 v2(73.02,48.5) ; U24.AR6 58.01,95.93 v2(58.01,95.81) ; C19.2 144.08,165.88 144.61,165.35 v3(144.65,165.35) ; v2(59.02,77.73) 59.52,78.23 U24.AN24 ; v3(123.19,97.59) 123.39,97.79 C205.1 ; C7.2 v3(159.89,171.07) ; v1(14.35,107.37) 15.09,107.37 R296.2 ; v2(90.02,91.95) 89.54,92.42 U24.C10 ; v2(89.21,42.91) 89.22,42.92 89.25,42.92 89.64,43.3 U43.G1 ; C213.2 144.97,96.32 v2(145.64,96.99) ; v1(138.15,55.73) 139.12,54.76 C337.1 ; U24.L37 81.52,65.42 v2(82.02,64.92) ; R321.2 v1(60.2,107.57) ; U24.J33 83.52,69.45 83.81,69.74 83.98,69.91 84,69.91 v2(84.04,69.95) ; v1(99.19,126.66) 99.23,126.62 CN12.H2 CN12.H1 ; v2(140.64,73.6) 140.19,73.14 C290.2 ; v2(88.02,88.92) 87.52,89.42 U24.E13 ; v2(83.04,69.95) 82.57,70.42 U24.K32 U24.L31 ; C28.1 v3(164.41,160.09) ; U24.AT23 56.52,79.42 56.04,78.94 v2(56.04,78.92) ; v3(136.88,36.63) 136.83,36.63 136.79,36.67 C383.2 ; v2(59.99,86.91) 59.94,86.91 59.94,86.91 59.52,87.34 U24.AN15 ; U24.N35 79.52,67.42 v2(80.02,66.92) ; R15.1 133.74,169.07 v3(134.06,169.39) ; v2(55.07,77.87) 55.04,77.87 55.04,77.95 55.52,78.42 U24.AU24 ; U39.P9 49.66,38.06 49.66,38.08 v2(49.67,38.09) ; U24.C24 v2(90.02,77.92) ; C151.2 v3(13.78,112.17) ; U41.B9 v2(73.02,47.7) ; CN11.H2 96.18,124.55 96.52,124.21 97.28,124.21 v1(97.43,124.05) ; C89.1 v1(70.87,131.44) C96.2 ; U42.P9 84.45,37.7 84.86,38.11 v2(84.86,38.11) ; v2(89.99,93.93) 89.52,94.4 U24.C8 ; U24.T37 76.52,65.42 v2(77.02,64.92) ; U24.AV35 v2(54.02,67.92) ; U24.AB26 70.99,75.95 ; 70.99,75.95 U24.AA27 ; 70.99,75.95 v2(70.99,76.07) ; v2(62.05,68.94) 62.1,68.99 62.1,69.01 U24.AK33 ; v3(158.24,121.03) C130.1 ; U24.AN35 v2(59.02,66.92) ; U61.4 v3(130.02,78.97) ; R202.2 104.34,128.59 v1(104.78,129.03) 105.21,128.59 C99.2 ; U43.E2 90.44,44.96 90.05,45.34 v2(90.04,45.34) ; U24.H6 v2(85.02,95.92) ; v1(44.46,119.89) 44.46,119.89 45.07,119.89 45.07,119.89 45.4,119.89 C162.1 ; C55.1 v3(169.75,142.75) ; C798.2 v3(133.25,81.17) ; v1(28.19,89.15) 28.19,88.59 R336.1 ; U24.AA35 v2(71.02,66.92) ; U24.AF33 66.51,69.42 v2(66.03,68.95) ; U24.AP21 58.04,80.94 v2(58.04,80.88) ; v3(102.62,34.47) 103.07,34.02 C379.2 ; v2(43.31,42.04) 43.64,41.7 U39.J2 ; v2(54.16,42.91) 54.17,42.92 54.2,42.92 54.58,43.3 U40.G1 ; C87.1 128.85,129.97 v3(128.91,129.9) ; v1(88.57,113.87) 88.57,113.18 C172.2 ; C340.1 26.54,51.31 v3(25.91,51.94) 25.78,51.82 25.78,51.76 R427.2 ; v3(170.81,147.96) 171.27,147.5 C827.2 ; C348.2 21.28,48.9 v3(21.28,48.9) ; C180.1 135.64,104.52 v3(135.89,104.78) ; U43.T9 96.04,35.54 96.46,35.12 v2(96.56,35.12) ; U24.AT36 v2(57.02,66.92) ; v3(96.52,116.26) 96.47,116.21 R285.2 ; U22.4 132.59,108.2 132.97,107.82 v3(132.97,107.57) ; U24.AD16 v2(69.02,85.92) U24.AC17 70.05,84.89 70.05,84.92 v2(70.06,84.92) 70.06,84.88 U24.AB18 v2(71.02,83.92) U24.AA19 v2(72.02,82.92) U24.Y20 ; U41.P1 66.22,37.7 66.26,37.7 v2(66.65,38.09) ; U24.AE35 v2(67.02,66.92) ; v1(62.99,118.36) 62.87,118.24 62.23,118.24 61.85,118.62 CN10.3 ; v2(81.02,89.92) U24.M12 U24.N11 ; v3(25.78,44.83) 26.35,45.4 Q9.2 ; v2(42.17,39) 42.17,39 42.59,39 U39.M1 ; v3(167.44,133.6) 167.51,133.6 167.95,134.04 C77.2 ; v3(135.89,99.44) R325.1 ; GPS1.F2 143.76,41.69 v2(143.76,41.78) ; U41.E8 71.82,44.95 72.2,45.34 v2(72.21,45.34) 72.21,45.36 71.87,45.7 U41.D8 ; U24.AF37 66.52,65.42 66.02,64.92 v2(66.02,64.92) ; U24.E17 v2(88.02,84.92) ; v1(30.48,109.29) 30.17,109.6 R287.2 ; U24.E21 v2(88.02,80.92) ; U40.A9 v2(61.38,48.5) ; U24.AN11 59.5,91.42 59.11,91.82 v2(59,91.82) 59,91.94 U24.AP10 ; R264.2 59.54,129.01 v1(58.42,129.01) ; C287.2 143.13,74.11 v2(142.64,74.6) ; 108.69,127.94 110.54,126.09 U16.66 ; U24.Y2 72.52,100.42 v2(73.02,100.92) ; GPS1.A2 v2(151.57,41.99) ; v3(161.54,166.24) 161.67,166.12 C20.2 ; B9.2 v1(72.01,135.38) B11.2 ; v2(142.64,99.99) 142.2,99.55 C198.2 ; U24.L5 81.62,97.42 v2(82.03,97.02) 82.03,97.01 82.04,97.01 82.52,96.53 U24.K6 ; C316.2 v1(38.92,69.98) ; R196.2 104.34,130.63 v1(104.78,131.06) 105.21,130.63 C90.2 ; 120.62,40.13 C371.1 ; C206.2 140.19,97.54 v2(140.64,97.99) ; C85.2 125.22,132.46 v3(124.59,133.1) 125.29,133.79 C76.2 ; v2(83.02,66.92) 82.52,67.42 U24.K35 ; v3(144.27,110.24) R281.1 ; U24.R25 v2(77.02,77.92) ; U24.AD37 v2(68.02,64.92) ; U24.P28 U24.R27 v2(77.02,75.92) U24.T26 v2(76.02,76.92) U24.U25 75.52,77.55 v2(75.14,77.93) 74.64,78.42 U24.V24 74.29,78.65 74.29,78.67 v2(74.04,78.91) 74.02,78.91 73.76,79.17 73.76,79.18 U24.W23 v2(73.02,79.92) U24.Y22 U24.AA21 v2(71.02,81.92) U24.AB20 v2(70.02,82.92) U24.AC19 ; U24.AR31 57.52,71.42 v2(57.02,70.92) 57,70.92 56.54,70.46 56.48,70.46 U24.AT32 ; R14.2 126.24,171.53 v3(125.86,171.91) ; v2(88.04,99.95) 87.52,99.43 U24.E3 ; R305.2 84.07,112.34 v3(83.54,111.81) 82.42,110.69 C498.2 82.1,110.69 81.92,110.87 81.92,111.48 v3(82.27,111.84) ; v2(89.02,64.92) 88.52,65.42 U24.D37 ; v1(108.76,117.48) 108.37,117.09 B15.2 ; v2(54.02,76.92) U24.AV26 ; B23.2 17.91,112.27 17.76,112.12 v1(17.3,112.12) ; C799.1 v3(133.35,80.41) ; U39.E1 42.49,45.31 v2(42.49,45.31) ; U24.C29 v2(90.02,72.92) ; U24.C22 v2(90.02,79.92) ; U24.AW37 53.52,65.43 53.92,65.02 v2(53.98,65.02) ; v1(73.56,109.91) 73.41,109.75 R310.2 ; U24.B39 90.32,63.22 v2(90.02,62.92) 89.52,63.42 U24.C39 ; v1(69.82,110.57) 70.31,111.06 C813.1 ; C36.2 152.83,156.6 v3(152.83,156.16) ; C369.2 v3(172.41,38.46) ; v2(74.02,66.92) 73.52,67.42 U24.W35 ; C367.2 v3(32.64,40.58) ; C12.2 145.55,170.47 v3(145.77,170.26) ; C330.2 v1(152.6,57.51) ; C294.1 v3(152.55,71.88) ; v2(70.02,65.92) U24.AB36 ; U43.J2 90.39,41.7 90,41.31 v2(89.96,41.31) ; U24.AV23 v2(54.02,79.92) ; U24.AW18 53.52,84.42 v2(53.02,83.92) ; v2(90.02,87.92) 89.52,88.42 U24.C14 ; v2(66.6,36.49) 66.22,36.11 U41.T1 ; C189.2 v2(137.54,101.98) ; C40.1 v3(170.87,154.18) ; v3(136.07,48.34) 135.38,49.02 C347.1 ; C332.1 v3(124.33,57.33) ; C730.1 v1(146.99,57.86) ; U24.B2 v2(91.02,100.92) ; U24.AP16 v2(58.02,86.92) ; CN22.3 v3(158.62,38.99) ; CN22.5 v3(159.89,38.99) ; C329.2 v3(148.66,60.05) ; U24.AB37 v2(70.02,64.92) ; v2(73.11,44.59) 73.11,44.59 72.63,44.1 U41.F9 ; U24.AH37 v2(64.02,64.92) ; U40.B9 v2(61.38,47.7) ; U40.B1 v2(54.19,47.7) ; U24.H32 v2(85.02,70.92) ; v1(107.31,133.35) C79.1
  TOP w0.457: 54.02,63.95 54.49,64.42 U24.AV38 ; 54.02,63.95 53.54,64.42 U24.AW38 ; 54.02,63.95 v2(54.02,63.92) ; v2(91.93,99.87) 91.52,99.46 U24.A3 ; v2(55.02,62.92) 55.52,63.42 U24.AU39 ; v2(54.02,62.92) 54.52,63.42 U24.AV39 ; v2(91.02,100.92) U24.A2
  TOP w0.483: AMC1.25 8.25,52.46 8.28,52.43 v3(8.41,52.43) ; v3(8.82,81.42) 6.28,83.96 AMC1.67 ; v3(8.53,94.59) 7.47,94.59 6.85,95.21 AMC1.82 ; v3(8.41,85.12) 7.32,86.21 7.1,86.21 7.1,86.21 AMC1.70 ; AMC1.28 7.89,54.71 v3(8.32,54.28) ; v3(10.46,91.57) 10.64,91.74 10.64,92.08 9.87,92.85 5.5,92.85 5.38,92.96 AMC1.79 ; AMC1.64 5.3,81.71 v3(8.47,78.53) ; AMC1.19 5.89,47.96 6.35,47.5 7.5,47.5 v3(8.64,47.5) ; AMC1.16 5.72,45.71 6.58,44.86 8.46,44.86 v3(8.51,44.81) ; v3(8.33,57.91) 8.33,57.94 7.35,56.96 AMC1.31 ; v3(8.51,96.95) 8.46,96.95 7.95,97.46 AMC1.85 ; v3(8.4,37.29) 6.91,37.29 5.24,38.96 AMC1.7 ; v3(8.41,76.77) 5.72,79.46 AMC1.61 ; AMC1.55 5.96,74.96 7.01,73.91 v3(8.38,73.91) ; v3(8.38,62.71) 7.13,61.46 AMC1.37 ; v3(8.38,65.96) AMC1.43 ; AMC1.10 5.15,41.21 6.55,39.8 v3(8.43,39.8) ; v3(8.38,41.78) 7.09,41.78 5.41,43.46 AMC1.13 ; v3(8.41,59.69) 7.93,59.21 AMC1.34 ; AMC1.1 8.81,34.46 9.4,35.05 v3(9.4,35.18) ; AMC1.40 v3(8.38,63.71) ; AMC1.22 7.28,50.21 8.2,51.13 v3(8.41,51.13) ; AMC1.58 6.48,77.21 7.75,75.95 v3(8.41,75.95) ; v3(8.37,90.24) 7.09,90.24 6.62,90.71 AMC1.76 ; AMC1.52 5.52,72.71 6.02,72.21 v3(8.38,72.21) ; AMC1.73 7.72,88.46 7.97,88.71 8.56,88.71 8.56,88.68 v3(8.59,88.68) ; AMC1.49 8.24,70.46 v3(8.44,70.26) ; AMC1.46 v3(8.57,68.21)
  TOP w0.508: 16.64,37.79 DC_IN1.2 ; DC_IN1.2 18.64,39.62 ; DC_IN1.2 18.64,37.79 ; DC_IN1.2 14.63,39.62 ; DC_IN1.2 16.64,39.62 ; DC_IN1.2 14.63,38.71 ; DC_IN1.2 14.63,37.79 ; DC_IN1.2 18.64,38.71 ; v3(36.16,146.36) 36.13,146.39 CN3.H10 ; DC_IN1.3 22.35,41.96 ; DC_IN1.3 21.44,39.95 ; DC_IN1.3 20.52,41.96 ; DC_IN1.3 20.98,39.95 ; DC_IN1.3 20.52,39.95 ; DC_IN1.3 22.35,39.95 ; DC_IN1.3 22.35,43.97 ; DC_IN1.3 21.44,43.97 ; v3(119.51,140.08) 118.72,139.29 C61.1 ; C23.2 103.15,164.85 v3(102.26,163.96) ; v3(34.56,131.99) 34.56,132.02 34.99,132.02 35.32,131.68 CN3.H3 ; CN3.H7 36.21,151.28 v1(36.51,151.58) ; v3(36.13,133.73) 35.32,134.54 CN3.H4 ; C30.2 145.45,160.46 v3(145.92,160.93) ; C333.2 32.64,55.25 31.88,56.01 v3(31.88,56.04) ; EMU1.H3 v3(96.77,146.05) ; EMU1.H6 v3(96.77,152.15) ; v3(153.29,101.73) 152.4,100.84 152.27,100.84 ; v3(112.73,174.84) 112.75,174.82 R8.1 ; v3(125.98,167.89) 126.43,168.34 C14.2 ; v3(162.05,169.16) 162.05,168.78 162.5,168.34 C15.2 ; CN3.H9 v3(35.32,164.32) ; C31.2 106.05,158.33 v3(106.53,157.85) ; R10.2 v3(103.25,172.34) ; SIM1.C5 v3(156.62,58.65) ; v3(145.49,104.27) 145.87,103.89 C185.2 ; C254.2 147.08,80.72 v3(147.24,80.72) ; v3(107.7,169.42) 106.93,169.42 106.55,169.04 C9.2 ; FTDI_USB.4 v3(170.88,166.19) ; v3(137.26,40.94) 137.08,40.94 136.72,40.58 R456.1 ; C188.2 146.24,101.41 v2(146.69,100.97) ; v3(34.34,139.88) 34.34,140.3 35.32,141.28 35.32,141.75 CN3.H5 ; v3(151.94,74.68) 151.94,75.17 151.96,75.18 C271.2 ; v3(34.29,124.82) 34.62,124.82 35.32,125.52 CN3.H6 ; v3(151.51,108.97) R284.2 ; C120.2 v3(172.47,122.56) ; v3(115.16,141.27) 115.16,141.25 114.69,140.78 R105.1 ; EMU1.H4 v3(96.77,139.57) ; FTDI_USB.5 v3(170.81,166.99) ; EMU1.H5 v3(96.77,136.14)
  TOP w1.016: CN18.2 CN18.5 ; CN18.4 CN18.3
  L2_GND w0.508: 20.4,131.42 J1.GF7 20.4,130.2 ; 161.2,77.42 CN16.A6 ; CN16.A6 161.2,78.73 ; CN16.A6 162.5,78.73 ; CN16.A6 162.5,77.42 ; 10.92,140.33 J2.GB1 10.92,141.29 ; J1.GH10 25.4,138.81 ; J1.GH10 25.4,137.81 ; J1.GH10 24.4,137.81 ; J1.GH10 24.4,138.81 ; 10.92,156.29 J2.GB7 10.92,155.33 ; 16.8,140.2 J2.GE1 16.8,141.42 ; 10.92,160.33 J2.GB9 10.92,161.29 ; CN3.H11 37.06,121.86 ; CN3.H11 33.58,118.38 ; CN3.H11 37.06,118.38 ; CN3.H11 33.58,121.86 ; 21.78,142.83 J2.GG2 21.78,143.79 ; 10.92,163.79 J2.GB10 10.92,162.83 ; 21.78,160.33 J2.GG9 21.78,161.29 ; J1.GH8 25.4,133.81 ; J1.GH8 24.4,132.81 ; J1.GH8 25.4,132.81 ; J1.GH8 24.4,133.81 ; 12.78,151.29 J2.GC5 12.78,150.33 ; 24.4,147.81 J2.GH4 ; J2.GH4 24.4,148.81 ; J2.GH4 25.4,148.81 ; J2.GH4 25.4,147.81 ; 24.4,118.81 J1.GH2 ; J1.GH2 25.4,118.81 ; J1.GH2 25.4,117.81 ; J1.GH2 24.4,117.81 ; 12.78,125.33 J1.GC5 12.78,126.29 ; 24.4,142.81 J2.GH2 ; J2.GH2 25.4,142.81 ; J2.GH2 25.4,143.81 ; J2.GH2 24.4,143.81 ; ATT.1 177.45,122.61 ; ATT.1 177.45,121.21 ; ATT.1 176.05,121.21 ; ATT.1 176.05,122.61 ; 10.92,151.29 J2.GB5 10.92,150.33 ; 17.28,160.33 J2.GE9 17.28,161.29 ; 7.9,121.21 J1.GA3 8.4,122.35 ; 10.92,148.79 J2.GB4 10.92,147.83 ; 16.8,146.42 J2.GE3 16.8,145.2 ; 8.4,141.35 J2.GA1 8.4,142.35 ; 20.4,127.7 J1.GF6 20.4,128.92 ; 7.9,136.21 J1.GA9 8.4,137.35 ; 24.4,140.31 J2.GH1 ; J2.GH1 25.4,140.31 ; J2.GH1 24.4,141.31 ; J2.GH1 25.4,141.31 ; 19.92,162.83 J2.GF10 19.92,163.79 ; 15.42,163.79 J2.GD10 15.42,162.83 ; 20.4,158.92 J2.GF8 20.4,157.7 ; 21.78,132.83 J1.GG8 21.78,133.79 ; 11.4,121.42 J1.GB3 11.4,120.2 ; 24.4,116.31 J1.GH1 ; J1.GH1 24.4,115.31 ; J1.GH1 25.4,116.31 ; J1.GH1 25.4,115.31 ; 10.92,116.29 J1.GB1 10.92,115.33 ; J1.GH4 25.4,122.81 ; J1.GH4 24.4,123.81 ; J1.GH4 25.4,123.81 ; J1.GH4 24.4,122.81 ; J1.GH6 25.4,127.81 ; J1.GH6 25.4,128.81 ; J1.GH6 24.4,128.81 ; J1.GH6 24.4,127.81 ; CN18.3 175.53,37.2 ; CN18.3 175.53,39.14 ; CN18.3 173.59,39.14 ; CN18.3 173.59,37.2 ; 164.02,126.3 SOC.2 ; SOC.2 164.02,124.91 ; SOC.2 165.42,124.91 ; SOC.2 165.42,126.3 ; J2.GH3 25.4,145.31 ; J2.GH3 25.4,146.31 ; J2.GH3 24.4,145.31 ; J2.GH3 24.4,146.31 ; 16.8,158.92 J2.GE8 16.8,157.7 ; 21.78,152.83 J2.GG6 21.78,153.79 ; 8.4,151.35 J2.GA5 8.4,152.35 ; 11.4,133.92 J1.GB8 11.4,132.7 ; 8.4,163.85 J2.GA10 8.4,164.85 ; 16.8,136.42 J1.GE9 16.8,135.2 ; 15.76,54.96 FAN1.1 ; FAN1.1 17.12,53.6 ; FAN1.1 17.12,54.96 ; FAN1.1 15.76,53.6 ; 12.78,118.79 J1.GC2 12.78,117.83 ; 24.4,152.81 J2.GH6 ; J2.GH6 24.4,153.81 ; J2.GH6 25.4,153.81 ; J2.GH6 25.4,152.81 ; 12.3,141.42 J2.GC1 12.3,140.2 ; 33.58,167.04 CN3.H12 ; CN3.H12 33.58,170.52 ; CN3.H12 37.06,167.04 ; CN3.H12 37.06,170.52 ; 7.9,133.71 J1.GA8 8.4,134.85 ; 17.28,162.83 J2.GE10 17.28,163.79 ; 12.78,160.33 J2.GC9 12.78,161.29 ; 21.78,141.29 J2.GG1 21.78,140.33 ; 15.42,132.83 J1.GD8 15.42,133.79 ; J1.GH7 25.4,131.31 ; J1.GH7 24.4,131.31 ; J1.GH7 24.4,130.31 ; J1.GH7 25.4,130.31 ; 15.42,135.33 J1.GD9 15.42,136.29 ; 16.8,138.92 J1.GE10 16.8,137.7 ; 7.9,128.71 J1.GA6 8.4,129.85 ; 8.4,124.85 J1.GA4 7.9,123.71 ; 11.4,131.42 J1.GB7 11.4,130.2 ; 12.78,130.33 J1.GC7 12.78,131.29 ; J2.GH10 25.4,163.81 ; J2.GH10 25.4,162.81 ; J2.GH10 24.4,162.81 ; J2.GH10 24.4,163.81 ; 24.4,120.31 J1.GH3 ; J1.GH3 25.4,120.31 ; J1.GH3 24.4,121.31 ; J1.GH3 25.4,121.31 ; 16.8,147.7 J2.GE4 16.8,148.92 ; 19.92,118.79 J1.GF2 19.92,117.83 ; 24.4,126.31 J1.GH5 ; J1.GH5 25.4,126.31 ; J1.GH5 25.4,125.31 ; J1.GH5 24.4,125.31 ; 8.4,132.35 J1.GA7 7.9,131.21 ; 21.78,146.29 J2.GG3 21.78,145.33 ; 176.05,131.21 PWR.1 ; PWR.1 177.45,131.21 ; PWR.1 177.45,132.61 ; PWR.1 176.05,132.61 ; CN8.3 167.63,149.2 ; CN8.3 167.63,150.45 ; CN8.3 166.38,150.45 ; CN8.3 166.38,149.2 ; 21.78,150.33 J2.GG5 21.78,151.29 ; 161.2,91.39 CN16.B6 ; CN16.B6 162.5,92.7 ; CN16.B6 162.5,91.39 ; CN16.B6 161.2,92.7 ; 12.78,163.79 J2.GC10 12.78,162.83 ; 12.78,132.83 J1.GC8 12.78,133.79 ; LCD1.11 69.73,152.46 ; LCD1.11 69.73,151.09 ; LCD1.11 68.1,151.09 ; LCD1.11 68.1,152.46 ; 24.4,161.31 J2.GH9 ; J2.GH9 25.4,160.31 ; J2.GH9 24.4,160.31 ; J2.GH9 25.4,161.31 ; 21.78,123.79 J1.GG4 21.78,122.83 ; 11.4,127.7 J1.GB6 11.4,128.92 ; DC_IN1.3 22.35,39.95 ; DC_IN1.3 20.52,39.95 ; DC_IN1.3 22.35,43.97 ; DC_IN1.3 20.52,43.97 ; 16.8,133.92 J1.GE8 16.8,132.7 ; 8.4,148.85 J2.GA4 8.4,149.85 ; 20.4,155.2 J2.GF7 20.4,156.42 ; 15.42,138.79 J1.GD10 15.42,137.83 ; 15.42,131.29 J1.GD7 15.42,130.33 ; 11.4,125.2 J1.GB5 11.4,126.42 ; MCU.2 158.56,126.35 ; MCU.2 158.56,124.96 ; MCU.2 157.16,126.35 ; MCU.2 157.16,124.96 ; 17.28,116.29 J1.GE1 17.28,115.33 ; 15.42,152.83 J2.GD6 15.42,153.79 ; 16.8,142.7 J2.GE2 16.8,143.92 ; 12.78,116.29 J1.GC1 12.78,115.33 ; 11.4,135.2 J1.GB9 11.4,136.42 ; 20.4,145.2 J2.GF3 20.4,146.42 ; 15.42,156.29 J2.GD7 15.42,155.33 ; 81.85,152.83 LCD1.K ; LCD1.K 84.57,154.61 ; LCD1.K 81.85,154.61 ; LCD1.K 84.57,152.83 ; 21.78,130.33 J1.GG7 21.78,131.29 ; 12.3,145.2 J2.GC3 12.3,146.42 ; 15.42,128.79 J1.GD6 15.42,127.83 ; 12.78,137.83 J1.GC10 12.78,138.79 ; J2.GH8 25.4,157.81 ; J2.GH8 24.4,157.81 ; J2.GH8 24.4,158.81 ; J2.GH8 25.4,158.81 ; DC_IN1.2 18.64,37.79 ; DC_IN1.2 18.64,39.62 ; DC_IN1.2 14.63,37.79 ; DC_IN1.2 14.63,39.62 ; 8.4,153.85 J2.GA6 8.4,154.85 ; 12.78,122.83 J1.GC4 12.78,123.79 ; 146.13,124.91 CN9.2 ; CN9.2 147.49,124.91 ; CN9.2 147.49,126.27 ; CN9.2 146.13,126.27 ; 15.42,158.79 J2.GD8 15.42,157.83 ; 16.8,156.42 J2.GE7 16.8,155.2 ; 10.92,146.29 J2.GB3 10.92,145.33 ; 149.12,134.85 PMBUS1.5 ; PMBUS1.5 150.6,134.85 ; PMBUS1.5 150.6,133.37 ; 16.8,152.7 J2.GE6 16.8,153.92 ; 15.42,121.29 J1.GD3 15.42,120.33 ; 16.8,151.42 J2.GE5 16.8,150.2 ; 24.4,135.31 J1.GH9 ; J1.GH9 24.4,136.31 ; J1.GH9 25.4,135.31 ; J1.GH9 25.4,136.31 ; 16.8,127.7 J1.GE6 16.8,128.92 ; 15.42,123.79 J1.GD4 15.42,122.83 ; 144.55,33.51 CN21.3 ; CN21.3 146.03,33.51 ; CN21.3 144.55,32.02 ; CN21.3 146.03,32.02 ; 21.78,155.33 J2.GG7 21.78,156.29 ; 21.78,135.33 J1.GG9 21.78,136.29 ; 10.92,157.83 J2.GB8 10.92,158.79 ; 20.4,133.92 J1.GF8 20.4,132.7 ; 8.4,127.35 J1.GA5 7.9,126.21 ; 24.4,155.31 J2.GH7 ; J2.GH7 25.4,156.31 ; J2.GH7 24.4,156.31 ; J2.GH7 25.4,155.31 ; 20.4,151.42 J2.GF5 20.4,150.2 ; 12.78,121.29 J1.GC3 12.78,120.33 ; 11.4,137.7 J1.GB10 11.4,138.92 ; 17.28,118.79 J1.GE2 17.28,117.83 ; 20.4,126.42 J1.GF5 20.4,125.2 ; 20.4,153.92 J2.GF6 20.4,152.7 ; 21.78,148.79 J2.GG4 21.78,147.83 ; 20.4,143.92 J2.GF2 20.4,142.7 ; 12.78,155.33 J2.GC7 12.78,156.29 ; 21.78,137.83 J1.GG10 21.78,138.79 ; 21.78,128.79 J1.GG6 21.78,127.83 ; 20.4,135.2 J1.GF9 20.4,136.42 ; 173.59,44.22 CN18.2 ; CN18.2 173.59,42.28 ; CN18.2 175.53,42.28 ; CN18.2 175.53,44.22 ; 10.92,152.83 J2.GB6 10.92,153.79 ; 20.4,140.2 J2.GF1 20.4,141.42 ; 16.8,130.2 J1.GE7 16.8,131.42 ; CN2.3 170.3,126.03 ; CN2.3 169.05,127.28 ; CN2.3 170.3,127.28 ; CN2.3 169.05,126.03 ; 15.42,115.33 J1.GD1 15.42,116.29 ; 8.4,158.85 J2.GA8 8.4,159.85 ; 12.78,158.79 J2.GC8 12.78,157.83 ; 12.3,148.92 J2.GC4 12.3,147.7 ; 12.78,127.83 J1.GC6 12.78,128.79 ; 21.78,125.33 J1.GG5 21.78,126.29 ; 15.42,150.33 J2.GD5 15.42,151.29 ; 20.4,137.7 J1.GF10 20.4,138.92 ; 15.42,125.33 J1.GD5 15.42,126.29 ; 15.9,140.2 J2.GD1 15.9,141.42 ; 8.4,118.85 J1.GA2 8.4,119.85 ; 8.4,146.35 J2.GA3 8.4,147.35 ; 24.4,150.31 J2.GH5 ; J2.GH5 25.4,151.31 ; J2.GH5 24.4,151.31 ; J2.GH5 25.4,150.31 ; 12.78,136.29 J1.GC9 12.78,135.33 ; 12.78,153.79 J2.GC6 12.78,152.83 ; 15.42,160.33 J2.GD9 15.42,161.29 ; 16.8,123.92 J1.GE4 16.8,122.7 ; 21.78,121.29 J1.GG3 21.78,120.33 ; 8.4,161.35 J2.GA9 8.4,162.35 ; 15.9,147.7 J2.GD4 15.9,148.92 ; 8.4,156.35 J2.GA7 8.4,157.35 ; 8.4,117.35 J1.GA1 8.4,116.35 ; 16.8,125.2 J1.GE5 16.8,126.42 ; 20.4,123.92 J1.GF4 20.4,122.7 ; 15.9,142.7 J2.GD2 15.9,143.92 ; 21.78,158.79 J2.GG8 21.78,157.83 ; 19.92,115.33 J1.GF1 19.92,116.29 ; 7.9,138.71 J1.GA10 8.4,139.85 ; 21.78,115.33 J1.GG1 21.78,116.29 ; 21.78,163.79 J2.GG10 21.78,162.83 ; 20.4,120.2 J1.GF3 20.4,121.42 ; 21.78,118.79 J1.GG2 21.78,117.83 ; 8.4,144.85 J2.GA2 8.4,143.85 ; 12.3,143.92 J2.GC2 12.3,142.7 ; 15.42,117.83 J1.GD2 15.42,118.79 ; 15.9,146.42 J2.GD3 15.9,145.2 ; 10.92,118.79 J1.GB2 10.92,117.83 ; 19.92,161.29 J2.GF9 19.92,160.33 ; 20.4,148.92 J2.GF4 20.4,147.7 ; 10.92,142.83 J2.GB2 10.92,143.79 ; 11.4,122.7 J1.GB4 11.4,123.92 ; 16.8,121.42 J1.GE3 16.8,120.2
  L6_GND w0.508: 20.4,125.2 J1.GF5 20.4,126.42 ; CN3.H11 37.06,121.86 ; CN3.H11 37.06,118.38 ; CN3.H11 33.58,121.86 ; CN3.H11 33.58,118.38 ; J2.GH1 25.4,140.31 ; J2.GH1 25.4,141.31 ; J2.GH1 24.4,140.31 ; J2.GH1 24.4,141.31 ; 24.4,153.81 J2.GH6 ; J2.GH6 25.4,153.81 ; J2.GH6 24.4,152.81 ; J2.GH6 25.4,152.81 ; 15.9,146.42 J2.GD3 15.9,145.2 ; 12.78,121.29 J1.GC3 12.78,120.33 ; 12.78,152.83 J2.GC6 12.78,153.79 ; 20.4,131.42 J1.GF7 20.4,130.2 ; 12.78,133.79 J1.GC8 12.78,132.83 ; 24.4,156.31 J2.GH7 ; J2.GH7 24.4,155.31 ; J2.GH7 25.4,156.31 ; J2.GH7 25.4,155.31 ; 15.42,135.33 J1.GD9 15.42,136.29 ; CN16.A6 162.5,78.73 ; CN16.A6 161.2,77.42 ; CN16.A6 162.5,77.42 ; CN16.A6 161.2,78.73 ; 173.59,44.22 CN18.2 ; CN18.2 175.53,44.22 ; CN18.2 175.53,42.28 ; CN18.2 173.59,42.28 ; 19.92,117.83 J1.GF2 19.92,118.79 ; 8.4,149.85 J2.GA4 8.4,148.85 ; 11.4,130.2 J1.GB7 11.4,131.42 ; 12.78,155.33 J2.GC7 12.78,156.29 ; 15.42,118.79 J1.GD2 15.42,117.83 ; 10.92,150.33 J2.GB5 10.92,151.29 ; 21.78,148.79 J2.GG4 21.78,147.83 ; 11.4,138.92 J1.GB10 11.4,137.7 ; 16.8,157.7 J2.GE8 16.8,158.92 ; 15.42,150.33 J2.GD5 15.42,151.29 ; J1.GH8 25.4,132.81 ; J1.GH8 24.4,133.81 ; J1.GH8 25.4,133.81 ; J1.GH8 24.4,132.81 ; 24.4,126.31 J1.GH5 ; J1.GH5 24.4,125.31 ; J1.GH5 25.4,125.31 ; J1.GH5 25.4,126.31 ; 12.78,125.33 J1.GC5 12.78,126.29 ; 10.92,158.79 J2.GB8 10.92,157.83 ; 15.42,131.29 J1.GD7 15.42,130.33 ; LCD1.K 84.57,154.61 ; LCD1.K 81.85,154.61 ; LCD1.K 84.57,152.83 ; LCD1.K 81.85,152.83 ; 12.78,131.29 J1.GC7 12.78,130.33 ; 10.92,118.79 J1.GB2 10.92,117.83 ; 16.8,120.2 J1.GE3 16.8,121.42 ; CN2.3 170.3,126.03 ; CN2.3 169.05,127.28 ; CN2.3 169.05,126.03 ; CN2.3 170.3,127.28 ; 14.63,39.62 DC_IN1.2 ; DC_IN1.2 18.64,37.79 ; DC_IN1.2 14.63,37.79 ; DC_IN1.2 18.64,39.62 ; 7.9,136.21 J1.GA9 8.4,137.35 ; 19.92,116.29 J1.GF1 19.92,115.33 ; 10.92,153.79 J2.GB6 10.92,152.83 ; 24.4,130.31 J1.GH7 ; J1.GH7 25.4,131.31 ; J1.GH7 25.4,130.31 ; J1.GH7 24.4,131.31 ; 16.8,141.42 J2.GE1 16.8,140.2 ; 8.4,158.85 J2.GA8 8.4,159.85 ; 7.9,128.71 J1.GA6 8.4,129.85 ; 21.78,140.33 J2.GG1 21.78,141.29 ; 8.4,141.35 J2.GA1 8.4,142.35 ; 8.4,119.85 J1.GA2 8.4,118.85 ; 12.3,140.2 J2.GC1 12.3,141.42 ; 12.3,146.42 J2.GC3 12.3,145.2 ; 21.78,150.33 J2.GG5 21.78,151.29 ; 20.4,128.92 J1.GF6 20.4,127.7 ; 176.05,132.61 PWR.1 ; PWR.1 177.45,131.21 ; PWR.1 176.05,131.21 ; PWR.1 177.45,132.61 ; 15.42,156.29 J2.GD7 15.42,155.33 ; 11.4,135.2 J1.GB9 11.4,136.42 ; 161.2,92.7 CN16.B6 ; CN16.B6 161.2,91.39 ; CN16.B6 162.5,92.7 ; CN16.B6 162.5,91.39 ; 10.92,161.29 J2.GB9 10.92,160.33 ; 10.92,141.29 J2.GB1 10.92,140.33 ; 176.05,121.21 ATT.1 ; ATT.1 177.45,122.61 ; ATT.1 176.05,122.61 ; ATT.1 177.45,121.21 ; 8.4,157.35 J2.GA7 8.4,156.35 ; 8.4,163.85 J2.GA10 8.4,164.85 ; 12.78,122.83 J1.GC4 12.78,123.79 ; J2.GH2 25.4,142.81 ; J2.GH2 24.4,142.81 ; J2.GH2 25.4,143.81 ; J2.GH2 24.4,143.81 ; 20.4,152.7 J2.GF6 20.4,153.92 ; 17.28,118.79 J1.GE2 17.28,117.83 ; 12.3,148.92 J2.GC4 12.3,147.7 ; 8.4,152.35 J2.GA5 8.4,151.35 ; 15.42,160.33 J2.GD9 15.42,161.29 ; 15.42,128.79 J1.GD6 15.42,127.83 ; 21.78,116.29 J1.GG1 21.78,115.33 ; J1.GH6 25.4,127.81 ; J1.GH6 24.4,127.81 ; J1.GH6 25.4,128.81 ; J1.GH6 24.4,128.81 ; 10.92,162.83 J2.GB10 10.92,163.79 ; 21.78,118.79 J1.GG2 21.78,117.83 ; 19.92,160.33 J2.GF9 19.92,161.29 ; 21.78,133.79 J1.GG8 21.78,132.83 ; MCU.2 158.56,126.35 ; MCU.2 157.16,126.35 ; MCU.2 157.16,124.96 ; MCU.2 158.56,124.96 ; 20.4,151.42 J2.GF5 20.4,150.2 ; 144.55,32.02 CN21.3 ; CN21.3 146.03,33.51 ; CN21.3 146.03,32.02 ; CN21.3 144.55,33.51 ; 16.8,122.7 J1.GE4 16.8,123.92 ; 8.4,127.35 J1.GA5 7.9,126.21 ; CN8.3 167.63,149.2 ; CN8.3 166.38,149.2 ; CN8.3 167.63,150.45 ; CN8.3 166.38,150.45 ; 21.78,135.33 J1.GG9 21.78,136.29 ; LCD1.11 69.73,152.46 ; LCD1.11 68.1,152.46 ; LCD1.11 68.1,151.09 ; LCD1.11 69.73,151.09 ; J2.GH4 25.4,148.81 ; J2.GH4 25.4,147.81 ; J2.GH4 24.4,147.81 ; J2.GH4 24.4,148.81 ; 21.78,145.33 J2.GG3 21.78,146.29 ; 8.4,153.85 J2.GA6 8.4,154.85 ; 8.4,144.85 J2.GA2 8.4,143.85 ; 15.42,115.33 J1.GD1 15.42,116.29 ; 15.42,126.29 J1.GD5 15.42,125.33 ; 24.4,163.81 J2.GH10 ; J2.GH10 25.4,163.81 ; J2.GH10 24.4,162.81 ; J2.GH10 25.4,162.81 ; 21.78,161.29 J2.GG9 21.78,160.33 ; 7.9,123.71 J1.GA4 8.4,124.85 ; J1.GH10 25.4,137.81 ; J1.GH10 25.4,138.81 ; J1.GH10 24.4,138.81 ; J1.GH10 24.4,137.81 ; 12.78,158.79 J2.GC8 12.78,157.83 ; 15.42,153.79 J2.GD6 15.42,152.83 ; 20.4,136.42 J1.GF9 20.4,135.2 ; 16.8,146.42 J2.GE3 16.8,145.2 ; 8.4,117.35 J1.GA1 8.4,116.35 ; 21.78,142.83 J2.GG2 21.78,143.79 ; 20.4,156.42 J2.GF7 20.4,155.2 ; 19.92,162.83 J2.GF10 19.92,163.79 ; 12.78,136.29 J1.GC9 12.78,135.33 ; 20.4,121.42 J1.GF3 20.4,120.2 ; 24.4,116.31 J1.GH1 ; J1.GH1 25.4,115.31 ; J1.GH1 24.4,115.31 ; J1.GH1 25.4,116.31 ; 20.4,133.92 J1.GF8 20.4,132.7 ; 20.4,141.42 J2.GF1 20.4,140.2 ; 8.4,134.85 J1.GA8 7.9,133.71 ; 15.76,53.6 FAN1.1 ; FAN1.1 17.12,53.6 ; FAN1.1 15.76,54.96 ; FAN1.1 17.12,54.96 ; 20.4,158.92 J2.GF8 20.4,157.7 ; 8.4,146.35 J2.GA3 8.4,147.35 ; CN3.H12 37.06,170.52 ; CN3.H12 33.58,167.04 ; CN3.H12 33.58,170.52 ; CN3.H12 37.06,167.04 ; PMBUS1.5 150.6,133.37 ; PMBUS1.5 149.12,134.85 ; PMBUS1.5 150.6,134.85 ; 10.92,116.29 J1.GB1 10.92,115.33 ; 16.8,151.42 J2.GE5 16.8,150.2 ; J1.GH3 25.4,121.31 ; J1.GH3 24.4,120.31 ; J1.GH3 25.4,120.31 ; J1.GH3 24.4,121.31 ; 17.28,161.29 J2.GE9 17.28,160.33 ; 24.4,146.31 J2.GH3 ; J2.GH3 24.4,145.31 ; J2.GH3 25.4,145.31 ; J2.GH3 25.4,146.31 ; SOC.2 165.42,126.3 ; SOC.2 165.42,124.91 ; SOC.2 164.02,124.91 ; SOC.2 164.02,126.3 ; DC_IN1.3 22.35,39.95 ; DC_IN1.3 20.52,43.97 ; DC_IN1.3 20.52,39.95 ; DC_IN1.3 22.35,43.97 ; 24.4,161.31 J2.GH9 ; J2.GH9 24.4,160.31 ; J2.GH9 25.4,161.31 ; J2.GH9 25.4,160.31 ; 11.4,133.92 J1.GB8 11.4,132.7 ; 11.4,127.7 J1.GB6 11.4,128.92 ; 10.92,145.33 J2.GB3 10.92,146.29 ; 21.78,137.83 J1.GG10 21.78,138.79 ; 11.4,123.92 J1.GB4 11.4,122.7 ; 12.78,160.33 J2.GC9 12.78,161.29 ; 15.42,120.33 J1.GD3 15.42,121.29 ; 146.13,124.91 CN9.2 ; CN9.2 146.13,126.27 ; CN9.2 147.49,124.91 ; CN9.2 147.49,126.27 ; 15.9,141.42 J2.GD1 15.9,140.2 ; 16.8,152.7 J2.GE6 16.8,153.92 ; 21.78,120.33 J1.GG3 21.78,121.29 ; 20.4,145.2 J2.GF3 20.4,146.42 ; 17.28,163.79 J2.GE10 17.28,162.83 ; 20.4,148.92 J2.GF4 20.4,147.7 ; 21.78,153.79 J2.GG6 21.78,152.83 ; 16.8,130.2 J1.GE7 16.8,131.42 ; 12.78,162.83 J2.GC10 12.78,163.79 ; 15.9,147.7 J2.GD4 15.9,148.92 ; J1.GH2 25.4,117.81 ; J1.GH2 24.4,118.81 ; J1.GH2 24.4,117.81 ; J1.GH2 25.4,118.81 ; 8.4,122.35 J1.GA3 7.9,121.21 ; 173.59,39.14 CN18.3 ; CN18.3 175.53,39.14 ; CN18.3 173.59,37.2 ; CN18.3 175.53,37.2 ; 15.42,123.79 J1.GD4 15.42,122.83 ; J1.GH9 25.4,135.31 ; J1.GH9 24.4,136.31 ; J1.GH9 25.4,136.31 ; J1.GH9 24.4,135.31 ; 16.8,135.2 J1.GE9 16.8,136.42 ; 17.28,116.29 J1.GE1 17.28,115.33 ; 11.4,126.42 J1.GB5 11.4,125.2 ; 16.8,133.92 J1.GE8 16.8,132.7 ; 15.42,133.79 J1.GD8 15.42,132.83 ; 21.78,126.29 J1.GG5 21.78,125.33 ; 24.4,151.31 J2.GH5 ; J2.GH5 25.4,151.31 ; J2.GH5 24.4,150.31 ; J2.GH5 25.4,150.31 ; J1.GH4 25.4,122.81 ; J1.GH4 25.4,123.81 ; J1.GH4 24.4,122.81 ; J1.GH4 24.4,123.81 ; 21.78,156.29 J2.GG7 21.78,155.33 ; 16.8,126.42 J1.GE5 16.8,125.2 ; 21.78,122.83 J1.GG4 21.78,123.79 ; 21.78,162.83 J2.GG10 21.78,163.79 ; 20.4,123.92 J1.GF4 20.4,122.7 ; 15.42,158.79 J2.GD8 15.42,157.83 ; 21.78,130.33 J1.GG7 21.78,131.29 ; 8.4,161.35 J2.GA9 8.4,162.35 ; 15.42,163.79 J2.GD10 15.42,162.83 ; 21.78,158.79 J2.GG8 21.78,157.83 ; 12.3,143.92 J2.GC2 12.3,142.7 ; 24.4,157.81 J2.GH8 ; J2.GH8 24.4,158.81 ; J2.GH8 25.4,157.81 ; J2.GH8 25.4,158.81 ; 16.8,143.92 J2.GE2 16.8,142.7 ; 20.4,143.92 J2.GF2 20.4,142.7 ; 16.8,138.92 J1.GE10 16.8,137.7 ; 12.78,138.79 J1.GC10 12.78,137.83 ; 15.42,138.79 J1.GD10 15.42,137.83 ; 7.9,131.21 J1.GA7 8.4,132.35 ; 12.78,150.33 J2.GC5 12.78,151.29 ; 16.8,127.7 J1.GE6 16.8,128.92 ; 20.4,137.7 J1.GF10 20.4,138.92 ; 12.78,117.83 J1.GC2 12.78,118.79 ; 12.78,127.83 J1.GC6 12.78,128.79 ; 10.92,147.83 J2.GB4 10.92,148.79 ; 12.78,115.33 J1.GC1 12.78,116.29 ; 10.92,156.29 J2.GB7 10.92,155.33 ; 11.4,120.2 J1.GB3 11.4,121.42 ; 15.9,142.7 J2.GD2 15.9,143.92 ; 7.9,138.71 J1.GA10 8.4,139.85 ; 16.8,156.42 J2.GE7 16.8,155.2 ; 16.8,147.7 J2.GE4 16.8,148.92 ; 10.92,142.83 J2.GB2 10.92,143.79 ; 21.78,128.79 J1.GG6 21.78,127.83
  L7_GND w0.508: 21.78,137.83 J1.GG10 21.78,138.79 ; 12.3,140.2 J2.GC1 12.3,141.42 ; 21.78,131.29 J1.GG7 21.78,130.33 ; 24.4,135.31 J1.GH9 ; J1.GH9 24.4,136.31 ; J1.GH9 25.4,136.31 ; J1.GH9 25.4,135.31 ; 12.78,155.33 J2.GC7 12.78,156.29 ; CN3.H12 37.06,167.04 ; CN3.H12 37.06,170.52 ; CN3.H12 33.58,167.04 ; CN3.H12 33.58,170.52 ; 15.9,140.2 J2.GD1 15.9,141.42 ; J2.GH9 25.4,161.31 ; J2.GH9 24.4,160.31 ; J2.GH9 24.4,161.31 ; J2.GH9 25.4,160.31 ; J2.GH10 25.4,162.81 ; J2.GH10 24.4,163.81 ; J2.GH10 24.4,162.81 ; J2.GH10 25.4,163.81 ; 24.4,130.31 J1.GH7 ; J1.GH7 25.4,131.31 ; J1.GH7 24.4,131.31 ; J1.GH7 25.4,130.31 ; 21.78,132.83 J1.GG8 21.78,133.79 ; 10.92,143.79 J2.GB2 10.92,142.83 ; DC_IN1.3 22.35,39.95 ; DC_IN1.3 20.52,43.97 ; DC_IN1.3 22.35,43.97 ; DC_IN1.3 20.52,39.95 ; 24.4,125.31 J1.GH5 ; J1.GH5 25.4,125.31 ; J1.GH5 24.4,126.31 ; J1.GH5 25.4,126.31 ; 16.8,155.2 J2.GE7 16.8,156.42 ; 20.4,127.7 J1.GF6 20.4,128.92 ; ATT.1 177.45,121.21 ; ATT.1 177.45,122.61 ; ATT.1 176.05,122.61 ; ATT.1 176.05,121.21 ; 16.8,148.92 J2.GE4 16.8,147.7 ; 12.78,123.79 J1.GC4 12.78,122.83 ; 20.4,158.92 J2.GF8 20.4,157.7 ; 8.4,139.85 J1.GA10 7.9,138.71 ; 173.59,42.28 CN18.2 ; CN18.2 173.59,44.22 ; CN18.2 175.53,44.22 ; CN18.2 175.53,42.28 ; FAN1.1 17.12,54.96 ; FAN1.1 15.76,54.96 ; FAN1.1 17.12,53.6 ; FAN1.1 15.76,53.6 ; J1.GH8 25.4,132.81 ; J1.GH8 25.4,133.81 ; J1.GH8 24.4,132.81 ; J1.GH8 24.4,133.81 ; J1.GH4 25.4,123.81 ; J1.GH4 25.4,122.81 ; J1.GH4 24.4,123.81 ; J1.GH4 24.4,122.81 ; 16.8,130.2 J1.GE7 16.8,131.42 ; 16.8,152.7 J2.GE6 16.8,153.92 ; 10.92,147.83 J2.GB4 10.92,148.79 ; 15.42,162.83 J2.GD10 15.42,163.79 ; 21.78,136.29 J1.GG9 21.78,135.33 ; J1.GH2 25.4,118.81 ; J1.GH2 24.4,117.81 ; J1.GH2 25.4,117.81 ; J1.GH2 24.4,118.81 ; 68.1,151.09 LCD1.11 ; LCD1.11 68.1,152.46 ; LCD1.11 69.73,151.09 ; LCD1.11 69.73,152.46 ; 15.9,145.2 J2.GD3 15.9,146.42 ; 24.4,151.31 J2.GH5 ; J2.GH5 25.4,151.31 ; J2.GH5 25.4,150.31 ; J2.GH5 24.4,150.31 ; 15.9,143.92 J2.GD2 15.9,142.7 ; 10.92,162.83 J2.GB10 10.92,163.79 ; SOC.2 165.42,126.3 ; SOC.2 165.42,124.91 ; SOC.2 164.02,126.3 ; SOC.2 164.02,124.91 ; J1.GH6 25.4,128.81 ; J1.GH6 24.4,128.81 ; J1.GH6 25.4,127.81 ; J1.GH6 24.4,127.81 ; 11.4,135.2 J1.GB9 11.4,136.42 ; 15.42,137.83 J1.GD10 15.42,138.79 ; 15.42,128.79 J1.GD6 15.42,127.83 ; 15.9,147.7 J2.GD4 15.9,148.92 ; 7.9,133.71 J1.GA8 8.4,134.85 ; 16.8,138.92 J1.GE10 16.8,137.7 ; 10.92,158.79 J2.GB8 10.92,157.83 ; 12.78,137.83 J1.GC10 12.78,138.79 ; 24.4,152.81 J2.GH6 ; J2.GH6 24.4,153.81 ; J2.GH6 25.4,153.81 ; J2.GH6 25.4,152.81 ; 16.8,128.92 J1.GE6 16.8,127.7 ; J2.GH3 25.4,146.31 ; J2.GH3 25.4,145.31 ; J2.GH3 24.4,145.31 ; J2.GH3 24.4,146.31 ; 21.78,152.83 J2.GG6 21.78,153.79 ; 10.92,115.33 J1.GB1 10.92,116.29 ; 8.4,154.85 J2.GA6 8.4,153.85 ; 20.4,143.92 J2.GF2 20.4,142.7 ; CN16.A6 162.5,77.42 ; CN16.A6 161.2,77.42 ; CN16.A6 162.5,78.73 ; CN16.A6 161.2,78.73 ; 24.4,142.81 J2.GH2 ; J2.GH2 25.4,142.81 ; J2.GH2 24.4,143.81 ; J2.GH2 25.4,143.81 ; 7.9,121.21 J1.GA3 8.4,122.35 ; 16.8,143.92 J2.GE2 16.8,142.7 ; 21.78,148.79 J2.GG4 21.78,147.83 ; 8.4,149.85 J2.GA4 8.4,148.85 ; 21.78,121.29 J1.GG3 21.78,120.33 ; 16.8,120.2 J1.GE3 16.8,121.42 ; 21.78,162.83 J2.GG10 21.78,163.79 ; 12.78,157.83 J2.GC8 12.78,158.79 ; 166.38,149.2 CN8.3 ; CN8.3 166.38,150.45 ; CN8.3 167.63,150.45 ; CN8.3 167.63,149.2 ; 20.4,121.42 J1.GF3 20.4,120.2 ; 15.42,157.83 J2.GD8 15.42,158.79 ; 10.92,160.33 J2.GB9 10.92,161.29 ; 8.4,146.35 J2.GA3 8.4,147.35 ; 19.92,163.79 J2.GF10 19.92,162.83 ; 15.42,161.29 J2.GD9 15.42,160.33 ; 12.78,135.33 J1.GC9 12.78,136.29 ; PWR.1 177.45,131.21 ; PWR.1 176.05,132.61 ; PWR.1 176.05,131.21 ; PWR.1 177.45,132.61 ; 15.42,153.79 J2.GD6 15.42,152.83 ; 17.28,117.83 J1.GE2 17.28,118.79 ; 15.42,120.33 J1.GD3 15.42,121.29 ; 169.05,126.03 CN2.3 ; CN2.3 169.05,127.28 ; CN2.3 170.3,127.28 ; CN2.3 170.3,126.03 ; 15.42,151.29 J2.GD5 15.42,150.33 ; CN21.3 146.03,32.02 ; CN21.3 146.03,33.51 ; CN21.3 144.55,33.51 ; CN21.3 144.55,32.02 ; 24.4,156.31 J2.GH7 ; J2.GH7 25.4,155.31 ; J2.GH7 25.4,156.31 ; J2.GH7 24.4,155.31 ; 12.3,145.2 J2.GC3 12.3,146.42 ; 21.78,123.79 J1.GG4 21.78,122.83 ; 11.4,138.92 J1.GB10 11.4,137.7 ; 10.92,156.29 J2.GB7 10.92,155.33 ; 8.4,141.35 J2.GA1 8.4,142.35 ; J1.GH10 25.4,138.81 ; J1.GH10 24.4,137.81 ; J1.GH10 25.4,137.81 ; J1.GH10 24.4,138.81 ; 161.2,91.39 CN16.B6 ; CN16.B6 162.5,91.39 ; CN16.B6 162.5,92.7 ; CN16.B6 161.2,92.7 ; 21.78,126.29 J1.GG5 21.78,125.33 ; 15.42,126.29 J1.GD5 15.42,125.33 ; 12.78,133.79 J1.GC8 12.78,132.83 ; 11.4,126.42 J1.GB5 11.4,125.2 ; LCD1.K 84.57,152.83 ; LCD1.K 84.57,154.61 ; LCD1.K 81.85,152.83 ; LCD1.K 81.85,154.61 ; 21.78,151.29 J2.GG5 21.78,150.33 ; 146.13,124.91 CN9.2 ; CN9.2 147.49,124.91 ; CN9.2 146.13,126.27 ; CN9.2 147.49,126.27 ; 24.4,120.31 J1.GH3 ; J1.GH3 25.4,121.31 ; J1.GH3 25.4,120.31 ; J1.GH3 24.4,121.31 ; 11.4,120.2 J1.GB3 11.4,121.42 ; 8.4,127.35 J1.GA5 7.9,126.21 ; 12.3,148.92 J2.GC4 12.3,147.7 ; CN3.H11 37.06,118.38 ; CN3.H11 37.06,121.86 ; CN3.H11 33.58,121.86 ; CN3.H11 33.58,118.38 ; 8.4,156.35 J2.GA7 8.4,157.35 ; 8.4,143.85 J2.GA2 8.4,144.85 ; 20.4,137.7 J1.GF10 20.4,138.92 ; 10.92,146.29 J2.GB3 10.92,145.33 ; 10.92,150.33 J2.GB5 10.92,151.29 ; 21.78,158.79 J2.GG8 21.78,157.83 ; 8.4,118.85 J1.GA2 8.4,119.85 ; 12.78,161.29 J2.GC9 12.78,160.33 ; 19.92,117.83 J1.GF2 19.92,118.79 ; 15.42,130.33 J1.GD7 15.42,131.29 ; 15.42,115.33 J1.GD1 15.42,116.29 ; 24.4,116.31 J1.GH1 ; J1.GH1 25.4,115.31 ; J1.GH1 25.4,116.31 ; J1.GH1 24.4,115.31 ; 8.4,129.85 J1.GA6 7.9,128.71 ; J2.GH4 25.4,148.81 ; J2.GH4 24.4,147.81 ; J2.GH4 25.4,147.81 ; J2.GH4 24.4,148.81 ; 11.4,130.2 J1.GB7 11.4,131.42 ; 12.78,130.33 J1.GC7 12.78,131.29 ; CN18.3 175.53,39.14 ; CN18.3 175.53,37.2 ; CN18.3 173.59,39.14 ; CN18.3 173.59,37.2 ; DC_IN1.2 18.64,37.79 ; DC_IN1.2 18.64,39.62 ; DC_IN1.2 14.63,39.62 ; DC_IN1.2 14.63,37.79 ; 12.3,142.7 J2.GC2 12.3,143.92 ; 20.4,145.2 J2.GF3 20.4,146.42 ; 12.78,115.33 J1.GC1 12.78,116.29 ; 12.78,128.79 J1.GC6 12.78,127.83 ; 19.92,115.33 J1.GF1 19.92,116.29 ; 20.4,136.42 J1.GF9 20.4,135.2 ; 16.8,151.42 J2.GE5 16.8,150.2 ; 10.92,117.83 J1.GB2 10.92,118.79 ; 12.78,162.83 J2.GC10 12.78,163.79 ; 24.4,140.31 J2.GH1 ; J2.GH1 25.4,141.31 ; J2.GH1 24.4,141.31 ; J2.GH1 25.4,140.31 ; 21.78,128.79 J1.GG6 21.78,127.83 ; 8.4,116.35 J1.GA1 8.4,117.35 ; 17.28,163.79 J2.GE10 17.28,162.83 ; 10.92,141.29 J2.GB1 10.92,140.33 ; 8.4,152.35 J2.GA5 8.4,151.35 ; J2.GH8 25.4,157.81 ; J2.GH8 24.4,157.81 ; J2.GH8 24.4,158.81 ; J2.GH8 25.4,158.81 ; 16.8,135.2 J1.GE9 16.8,136.42 ; 19.92,161.29 J2.GF9 19.92,160.33 ; 11.4,127.7 J1.GB6 11.4,128.92 ; 17.28,115.33 J1.GE1 17.28,116.29 ; 20.4,151.42 J2.GF5 20.4,150.2 ; 12.78,152.83 J2.GC6 12.78,153.79 ; 20.4,152.7 J2.GF6 20.4,153.92 ; 16.8,123.92 J1.GE4 16.8,122.7 ; 21.78,118.79 J1.GG2 21.78,117.83 ; 21.78,140.33 J2.GG1 21.78,141.29 ; 15.42,156.29 J2.GD7 15.42,155.33 ; 16.8,158.92 J2.GE8 16.8,157.7 ; 11.4,123.92 J1.GB4 11.4,122.7 ; 20.4,131.42 J1.GF7 20.4,130.2 ; 12.78,121.29 J1.GC3 12.78,120.33 ; 20.4,125.2 J1.GF5 20.4,126.42 ; 7.9,123.71 J1.GA4 8.4,124.85 ; 20.4,133.92 J1.GF8 20.4,132.7 ; 12.78,151.29 J2.GC5 12.78,150.33 ; PMBUS1.5 150.6,134.85 ; PMBUS1.5 149.12,134.85 ; PMBUS1.5 150.6,133.37 ; 20.4,141.42 J2.GF1 20.4,140.2 ; 7.9,131.21 J1.GA7 8.4,132.35 ; 7.9,136.21 J1.GA9 8.4,137.35 ; 21.78,116.29 J1.GG1 21.78,115.33 ; 11.4,133.92 J1.GB8 11.4,132.7 ; 21.78,155.33 J2.GG7 21.78,156.29 ; 8.4,159.85 J2.GA8 8.4,158.85 ; 16.8,141.42 J2.GE1 16.8,140.2 ; 20.4,122.7 J1.GF4 20.4,123.92 ; 21.78,161.29 J2.GG9 21.78,160.33 ; 8.4,161.35 J2.GA9 8.4,162.35 ; 15.42,122.83 J1.GD4 15.42,123.79 ; 15.42,136.29 J1.GD9 15.42,135.33 ; 20.4,147.7 J2.GF4 20.4,148.92 ; 157.16,126.35 MCU.2 ; MCU.2 158.56,126.35 ; MCU.2 158.56,124.96 ; MCU.2 157.16,124.96 ; 17.28,160.33 J2.GE9 17.28,161.29 ; 12.78,118.79 J1.GC2 12.78,117.83 ; 16.8,145.2 J2.GE3 16.8,146.42 ; 10.92,152.83 J2.GB6 10.92,153.79 ; 12.78,126.29 J1.GC5 12.78,125.33 ; 21.78,142.83 J2.GG2 21.78,143.79 ; 8.4,163.85 J2.GA10 8.4,164.85 ; 16.8,132.7 J1.GE8 16.8,133.92 ; 20.4,156.42 J2.GF7 20.4,155.2 ; 21.78,146.29 J2.GG3 21.78,145.33 ; 15.42,132.83 J1.GD8 15.42,133.79 ; 15.42,117.83 J1.GD2 15.42,118.79 ; 16.8,125.2 J1.GE5 16.8,126.42
  L11_GND w0.508: 15.9,147.7 J2.GD4 15.9,148.92 ; PWR.1 177.45,131.21 ; PWR.1 177.45,132.61 ; PWR.1 176.05,132.61 ; PWR.1 176.05,131.21 ; 24.4,122.81 J1.GH4 ; J1.GH4 25.4,123.81 ; J1.GH4 24.4,123.81 ; J1.GH4 25.4,122.81 ; 21.78,118.79 J1.GG2 21.78,117.83 ; 12.78,133.79 J1.GC8 12.78,132.83 ; 12.78,150.33 J2.GC5 12.78,151.29 ; 24.4,136.31 J1.GH9 ; J1.GH9 24.4,135.31 ; J1.GH9 25.4,136.31 ; J1.GH9 25.4,135.31 ; CN18.3 175.53,39.14 ; CN18.3 173.59,37.2 ; CN18.3 173.59,39.14 ; CN18.3 175.53,37.2 ; 24.4,120.31 J1.GH3 ; J1.GH3 25.4,121.31 ; J1.GH3 25.4,120.31 ; J1.GH3 24.4,121.31 ; 7.9,128.71 J1.GA6 8.4,129.85 ; 20.4,127.7 J1.GF6 20.4,128.92 ; 8.4,116.35 J1.GA1 8.4,117.35 ; 24.4,137.81 J1.GH10 ; J1.GH10 25.4,137.81 ; J1.GH10 25.4,138.81 ; J1.GH10 24.4,138.81 ; 21.78,140.33 J2.GG1 21.78,141.29 ; 15.9,145.2 J2.GD3 15.9,146.42 ; 21.78,132.83 J1.GG8 21.78,133.79 ; 24.4,125.31 J1.GH5 ; J1.GH5 25.4,126.31 ; J1.GH5 25.4,125.31 ; J1.GH5 24.4,126.31 ; 16.8,141.42 J2.GE1 16.8,140.2 ; CN18.2 175.53,44.22 ; CN18.2 173.59,44.22 ; CN18.2 175.53,42.28 ; CN18.2 173.59,42.28 ; PMBUS1.5 150.6,133.37 ; PMBUS1.5 149.12,134.85 ; PMBUS1.5 150.6,134.85 ; 24.4,143.81 J2.GH2 ; J2.GH2 25.4,143.81 ; J2.GH2 25.4,142.81 ; J2.GH2 24.4,142.81 ; FAN1.1 17.12,53.6 ; FAN1.1 15.76,53.6 ; FAN1.1 15.76,54.96 ; FAN1.1 17.12,54.96 ; 8.4,148.85 J2.GA4 8.4,149.85 ; 161.2,91.39 CN16.B6 ; CN16.B6 162.5,91.39 ; CN16.B6 162.5,92.7 ; CN16.B6 161.2,92.7 ; ATT.1 177.45,121.21 ; ATT.1 176.05,122.61 ; ATT.1 177.45,122.61 ; ATT.1 176.05,121.21 ; 15.9,141.42 J2.GD1 15.9,140.2 ; J2.GH5 25.4,151.31 ; J2.GH5 24.4,151.31 ; J2.GH5 24.4,150.31 ; J2.GH5 25.4,150.31 ; 12.78,117.83 J1.GC2 12.78,118.79 ; 15.42,136.29 J1.GD9 15.42,135.33 ; 7.9,126.21 J1.GA5 8.4,127.35 ; 12.3,147.7 J2.GC4 12.3,148.92 ; 20.4,131.42 J1.GF7 20.4,130.2 ; 10.92,162.83 J2.GB10 10.92,163.79 ; 24.4,155.31 J2.GH7 ; J2.GH7 25.4,156.31 ; J2.GH7 25.4,155.31 ; J2.GH7 24.4,156.31 ; 15.42,156.29 J2.GD7 15.42,155.33 ; 15.9,142.7 J2.GD2 15.9,143.92 ; 12.78,158.79 J2.GC8 12.78,157.83 ; 21.78,126.29 J1.GG5 21.78,125.33 ; 21.78,131.29 J1.GG7 21.78,130.33 ; 169.05,127.28 CN2.3 ; CN2.3 169.05,126.03 ; CN2.3 170.3,127.28 ; CN2.3 170.3,126.03 ; 10.92,115.33 J1.GB1 10.92,116.29 ; 7.9,123.71 J1.GA4 8.4,124.85 ; 15.42,130.33 J1.GD7 15.42,131.29 ; 16.8,157.7 J2.GE8 16.8,158.92 ; 15.42,123.79 J1.GD4 15.42,122.83 ; 20.4,158.92 J2.GF8 20.4,157.7 ; J2.GH4 25.4,147.81 ; J2.GH4 24.4,148.81 ; J2.GH4 24.4,147.81 ; J2.GH4 25.4,148.81 ; 12.78,153.79 J2.GC6 12.78,152.83 ; 16.8,153.92 J2.GE6 16.8,152.7 ; 21.78,145.33 J2.GG3 21.78,146.29 ; 16.8,120.2 J1.GE3 16.8,121.42 ; CN16.A6 162.5,78.73 ; CN16.A6 162.5,77.42 ; CN16.A6 161.2,78.73 ; CN16.A6 161.2,77.42 ; CN3.H12 37.06,170.52 ; CN3.H12 33.58,170.52 ; CN3.H12 33.58,167.04 ; CN3.H12 37.06,167.04 ; 12.3,142.7 J2.GC2 12.3,143.92 ; 15.42,121.29 J1.GD3 15.42,120.33 ; 21.78,137.83 J1.GG10 21.78,138.79 ; 21.78,142.83 J2.GG2 21.78,143.79 ; LCD1.11 69.73,152.46 ; LCD1.11 69.73,151.09 ; LCD1.11 68.1,152.46 ; LCD1.11 68.1,151.09 ; 24.4,116.31 J1.GH1 ; J1.GH1 24.4,115.31 ; J1.GH1 25.4,116.31 ; J1.GH1 25.4,115.31 ; 16.8,126.42 J1.GE5 16.8,125.2 ; 8.4,142.35 J2.GA1 8.4,141.35 ; CN8.3 167.63,149.2 ; CN8.3 166.38,150.45 ; CN8.3 166.38,149.2 ; CN8.3 167.63,150.45 ; 8.4,139.85 J1.GA10 7.9,138.71 ; 20.4,133.92 J1.GF8 20.4,132.7 ; 20.4,151.42 J2.GF5 20.4,150.2 ; 20.4,120.2 J1.GF3 20.4,121.42 ; 15.42,152.83 J2.GD6 15.42,153.79 ; 21.78,127.83 J1.GG6 21.78,128.79 ; 10.92,160.33 J2.GB9 10.92,161.29 ; 20.4,147.7 J2.GF4 20.4,148.92 ; 81.85,154.61 LCD1.K ; LCD1.K 84.57,152.83 ; LCD1.K 81.85,152.83 ; LCD1.K 84.57,154.61 ; 21.78,155.33 J2.GG7 21.78,156.29 ; 12.78,137.83 J1.GC10 12.78,138.79 ; 15.42,126.29 J1.GD5 15.42,125.33 ; J2.GH6 25.4,153.81 ; J2.GH6 25.4,152.81 ; J2.GH6 24.4,153.81 ; J2.GH6 24.4,152.81 ; 21.78,160.33 J2.GG9 21.78,161.29 ; 10.92,156.29 J2.GB7 10.92,155.33 ; 17.28,117.83 J1.GE2 17.28,118.79 ; 11.4,126.42 J1.GB5 11.4,125.2 ; 11.4,122.7 J1.GB4 11.4,123.92 ; 24.4,160.31 J2.GH9 ; J2.GH9 25.4,161.31 ; J2.GH9 25.4,160.31 ; J2.GH9 24.4,161.31 ; 11.4,137.7 J1.GB10 11.4,138.92 ; 16.8,138.92 J1.GE10 16.8,137.7 ; CN9.2 147.49,126.27 ; CN9.2 147.49,124.91 ; CN9.2 146.13,124.91 ; CN9.2 146.13,126.27 ; 21.78,162.83 J2.GG10 21.78,163.79 ; 20.4,152.7 J2.GF6 20.4,153.92 ; 12.78,120.33 J1.GC3 12.78,121.29 ; 24.4,157.81 J2.GH8 ; J2.GH8 25.4,158.81 ; J2.GH8 24.4,158.81 ; J2.GH8 25.4,157.81 ; 12.78,156.29 J2.GC7 12.78,155.33 ; 10.92,118.79 J1.GB2 10.92,117.83 ; J1.GH6 25.4,127.81 ; J1.GH6 24.4,127.81 ; J1.GH6 24.4,128.81 ; J1.GH6 25.4,128.81 ; 21.78,152.83 J2.GG6 21.78,153.79 ; 144.55,32.02 CN21.3 ; CN21.3 144.55,33.51 ; CN21.3 146.03,33.51 ; CN21.3 146.03,32.02 ; 19.92,118.79 J1.GF2 19.92,117.83 ; 8.4,147.35 J2.GA3 8.4,146.35 ; 10.92,151.29 J2.GB5 10.92,150.33 ; 15.42,128.79 J1.GD6 15.42,127.83 ; 12.78,161.29 J2.GC9 12.78,160.33 ; 20.4,123.92 J1.GF4 20.4,122.7 ; J2.GH3 25.4,145.31 ; J2.GH3 24.4,145.31 ; J2.GH3 24.4,146.31 ; J2.GH3 25.4,146.31 ; 16.8,155.2 J2.GE7 16.8,156.42 ; 14.63,37.79 DC_IN1.2 ; DC_IN1.2 18.64,37.79 ; DC_IN1.2 18.64,39.62 ; DC_IN1.2 14.63,39.62 ; 8.4,162.35 J2.GA9 8.4,161.35 ; 12.3,146.42 J2.GC3 12.3,145.2 ; 16.8,136.42 J1.GE9 16.8,135.2 ; DC_IN1.3 22.35,43.97 ; DC_IN1.3 20.52,39.95 ; DC_IN1.3 22.35,39.95 ; DC_IN1.3 20.52,43.97 ; 8.4,134.85 J1.GA8 7.9,133.71 ; 20.4,155.2 J2.GF7 20.4,156.42 ; 10.92,153.79 J2.GB6 10.92,152.83 ; 8.4,137.35 J1.GA9 7.9,136.21 ; 8.4,119.85 J1.GA2 8.4,118.85 ; 33.58,121.86 CN3.H11 ; CN3.H11 37.06,118.38 ; CN3.H11 37.06,121.86 ; CN3.H11 33.58,118.38 ; 16.8,127.7 J1.GE6 16.8,128.92 ; 17.28,160.33 J2.GE9 17.28,161.29 ; 16.8,147.7 J2.GE4 16.8,148.92 ; J2.GH10 25.4,163.81 ; J2.GH10 24.4,163.81 ; J2.GH10 25.4,162.81 ; J2.GH10 24.4,162.81 ; 10.92,141.29 J2.GB1 10.92,140.33 ; 10.92,148.79 J2.GB4 10.92,147.83 ; 8.4,163.85 J2.GA10 8.4,164.85 ; 16.8,132.7 J1.GE8 16.8,133.92 ; 21.78,122.83 J1.GG4 21.78,123.79 ; 20.4,140.2 J2.GF1 20.4,141.42 ; 7.9,121.21 J1.GA3 8.4,122.35 ; 10.92,158.79 J2.GB8 10.92,157.83 ; 15.42,132.83 J1.GD8 15.42,133.79 ; 21.78,151.29 J2.GG5 21.78,150.33 ; 24.4,118.81 J1.GH2 ; J1.GH2 25.4,117.81 ; J1.GH2 24.4,117.81 ; J1.GH2 25.4,118.81 ; 16.8,142.7 J2.GE2 16.8,143.92 ; 8.4,157.35 J2.GA7 8.4,156.35 ; 15.42,157.83 J2.GD8 15.42,158.79 ; 20.4,143.92 J2.GF2 20.4,142.7 ; 24.4,141.31 J2.GH1 ; J2.GH1 24.4,140.31 ; J2.GH1 25.4,140.31 ; J2.GH1 25.4,141.31 ; 10.92,143.79 J2.GB2 10.92,142.83 ; 15.42,163.79 J2.GD10 15.42,162.83 ; 20.4,125.2 J1.GF5 20.4,126.42 ; 12.78,131.29 J1.GC7 12.78,130.33 ; 12.78,125.33 J1.GC5 12.78,126.29 ; 16.8,150.2 J2.GE5 16.8,151.42 ; 16.8,145.2 J2.GE3 16.8,146.42 ; 15.42,151.29 J2.GD5 15.42,150.33 ; 21.78,157.83 J2.GG8 21.78,158.79 ; 17.28,162.83 J2.GE10 17.28,163.79 ; 20.4,146.42 J2.GF3 20.4,145.2 ; J1.GH8 25.4,133.81 ; J1.GH8 24.4,132.81 ; J1.GH8 25.4,132.81 ; J1.GH8 24.4,133.81 ; 11.4,120.2 J1.GB3 11.4,121.42 ; 8.4,143.85 J2.GA2 8.4,144.85 ; 21.78,148.79 J2.GG4 21.78,147.83 ; 7.9,131.21 J1.GA7 8.4,132.35 ; 24.4,130.31 J1.GH7 ; J1.GH7 25.4,130.31 ; J1.GH7 24.4,131.31 ; J1.GH7 25.4,131.31 ; 19.92,163.79 J2.GF10 19.92,162.83 ; 11.4,135.2 J1.GB9 11.4,136.42 ; 15.42,137.83 J1.GD10 15.42,138.79 ; 19.92,161.29 J2.GF9 19.92,160.33 ; 21.78,136.29 J1.GG9 21.78,135.33 ; 11.4,132.7 J1.GB8 11.4,133.92 ; 16.8,122.7 J1.GE4 16.8,123.92 ; 10.92,146.29 J2.GB3 10.92,145.33 ; 12.78,162.83 J2.GC10 12.78,163.79 ; 11.4,128.92 J1.GB6 11.4,127.7 ; 15.42,117.83 J1.GD2 15.42,118.79 ; SOC.2 165.42,126.3 ; SOC.2 164.02,124.91 ; SOC.2 165.42,124.91 ; SOC.2 164.02,126.3 ; 15.42,161.29 J2.GD9 15.42,160.33 ; 15.42,116.29 J1.GD1 15.42,115.33 ; 8.4,158.85 J2.GA8 8.4,159.85 ; 20.4,138.92 J1.GF10 20.4,137.7 ; 12.78,122.83 J1.GC4 12.78,123.79 ; 21.78,116.29 J1.GG1 21.78,115.33 ; 8.4,151.35 J2.GA5 8.4,152.35 ; 21.78,121.29 J1.GG3 21.78,120.33 ; MCU.2 158.56,124.96 ; MCU.2 158.56,126.35 ; MCU.2 157.16,124.96 ; MCU.2 157.16,126.35 ; 12.78,135.33 J1.GC9 12.78,136.29 ; 20.4,135.2 J1.GF9 20.4,136.42 ; 11.4,131.42 J1.GB7 11.4,130.2 ; 12.3,140.2 J2.GC1 12.3,141.42 ; 8.4,153.85 J2.GA6 8.4,154.85 ; 16.8,131.42 J1.GE7 16.8,130.2 ; 17.28,115.33 J1.GE1 17.28,116.29 ; 12.78,127.83 J1.GC6 12.78,128.79 ; 12.78,116.29 J1.GC1 12.78,115.33 ; 19.92,115.33 J1.GF1 19.92,116.29
  BOTTOM w0.203: D14.3 160.83,111.81 160.4,111.38 v1(160.4,110.97) ; v2(36.58,153.92) 37.76,155.11 37.76,156.22 NAND1.F7
  BOTTOM w0.254: U68.27 42.19,138.52 U64.48 ; v1(39.72,140.71) 39.72,140.36 40.06,140.02 U64.45 ; U60.8 34.32,38.61 v1(34.29,38.57) ; U63.25 42.92,136.76 U68.25 ; v1(30.96,147.96) 31.53,148.52 U64.21 ; U64.15 31.86,145.52 v3(30.55,144.21) ; U60.4 v1(39.08,38.11) ; U63.15 34.28,132.26 34.53,132.02 34.56,132.02 v3(34.56,131.99) ; v1(39.72,148.13) 39.72,148.18 40.06,148.52 U64.28 ; U63.28 42.42,135.26 U68.23 ; v3(34.34,139.88) 34.2,140.02 U64.4 ; U63.1 33.49,125.26 33.91,124.84 34.27,124.84 v3(34.29,124.82) ; U63.10 33.08,129.75 33.82,129.75 34.31,129.26 34.7,129.26 34.92,129.03 34.92,128.68 v1(34.76,128.52) ; v3(35.81,48.97) 35.81,48.89 36.32,48.39 37.21,48.39 37.6,47.99 U36.1 ; U64.39 41.6,143.02 42.18,142.44 42.87,142.44 v3(43.05,142.62) ; U63.45 40.06,126.76 39.84,126.55 39.84,126.2 39.43,125.79 v1(39.24,125.79) ; U64.1 33.39,138.52 34.42,137.49 v3(34.42,137.29) 33.89,136.76 U63.24 ; v3(111.81,158.24) 110.96,157.39 U50.15 108.58,157.39 108.46,157.26 108.46,156.86 108.58,156.74 U50.16 ; U63.4 32,126.76 31.97,126.73 v1(31.02,126.73) ; U65.23 42.85,129.76 U63.39 ; U63.34 42.35,132.26 U65.27 ; v1(42.47,149.8) 42.47,149.8 42.47,149.82 42.24,150.05 40.82,150.05 U64.25 ; U63.48 41.42,125.26 42.74,123.95 v1(42.74,123.51) ; U64.34 41.53,145.52 42.24,144.81 v1(42.28,144.81) ; 30.15,135.26 30.15,135.25 30.82,135.25 30.82,135.26 33.06,135.26 U63.21 ; U64.24 33.81,150.02 33.94,149.89 34.81,149.89 v1(36.51,151.58) ; U64.10 29.62,143.02 v3(29.51,142.91)
  BOTTOM w0.279: U49.22 145.57,151.21 v3(146.05,151.69) 146,151.69 145.48,152.21 U49.20 ; v3(138.23,152.7) 138.22,152.71 U49.30 ; U49.40 135.99,157.71 v3(135.69,157.4) ; U49.27 138.23,151.21 138.56,151.54 v3(138.58,151.54) ; U49.16 142.67,154.21 v3(141.81,153.34) ; U49.11 145.56,156.71 v3(145.75,156.9) ; v3(135.48,156.29) 135.56,156.21 U49.37 ; v3(138.13,154.08) 138,154.21 U49.33 ; v3(135.74,159.54) 136.07,159.21 U49.43 ; U49.3 145.69,160.71 v3(145.92,160.93) ; v3(145.76,153.56) 145.43,153.23 145.43,153.21 U49.18 ; C398.1 146.36,158.55 145.51,157.71 U49.9 ; U49.46 v3(135.59,160.71) ; U49.13 146.1,155.71 C402.2 ; U49.7 143.55,158.71 143.31,158.95 v3(143.31,159.51) 143.5,159.71 U49.5
  BOTTOM w0.305: C820.2 65.49,75.38 v2(65.99,74.88) ; v2(70.05,68.96) 70.05,68.89 70.47,68.48 C715.1 ; NAND1.C5 34.92,158.24 v2(34.65,157.96) ; C272.2 67.54,74.32 v2(67.08,73.86) ; v2(61.44,43.69) 61.51,43.76 C759.2 ; v2(41.43,154.31) 41.43,155.78 NAND1.K8 ; U47.15 104.66,167.8 104.67,167.79 v1(104.99,167.79) ; C770.2 84.63,39.56 v2(83.95,38.89) ; v1(102.6,166.87) 102.6,166.81 102.92,166.5 U47.17
  BOTTOM w0.356: v1(83.67,117.38) 83.44,117.38 83.17,117.11 U57.8 ; U48.17 93.04,166.5 v3(92.79,166.24) ; U57.14 79.92,111.34 v1(79.63,111.63) 79.27,111.28 U57.15 ; v3(157.81,116.71) 157.54,116.71 157.19,117.07 U56.14 ; v1(93.49,130.98) 93.49,130.76 93.72,130.53 U53.10 ; U50.17 108.51,156.09 108.36,155.93 v3(108.39,155.93) ; U57.2 79.27,115.57 v1(79.2,115.5) ; v1(103.25,134.24) 102.49,134.24 101.88,133.63 U53.15 ; v3(95.38,165.02) 95.55,165.2 U47.10 ; v1(102.6,166.87) 102.88,167.15 U47.16 ; U52.11 154.44,142.37 154.81,142.75 v3(155.4,142.75) ; U56.1 158.49,113.29 v1(158.37,113.41) ; U45.10 144.81,174.88 145.36,175.44 v3(145.36,175.72) ; v3(101.47,120.65) 101.47,121.28 101.23,121.52 U62.3 ; U51.15 158.01,142.39 v3(158.37,142.75) 158.66,142.45 U51.14 ; U51.8 v3(161.91,148.71) ; v3(83.54,111.81) 83.17,111.44 U57.9 ; U48.16 93.02,167.15 v3(92.71,167.46) 93.05,167.8 U48.15 ; U53.16 100.86,132.48 v1(100.58,132.21) 100.96,131.83 U53.17 ; v3(68.45,142.75) Q17.2 ; U51.9 162.27,141.86 v3(162.66,141.86) ; v3(88.32,165.2) U48.10 ; v3(101.09,154.79) U50.10
  BOTTOM w0.381: R632.2 58.57,93.5 v2(59,93.93) ; v2(64.02,84.92) 64.44,85.34 C601.2 ; v2(72.84,81.97) 72.85,81.97 73.35,81.46 C622.2 ; PHY1.D6 141.14,73.1 v2(140.64,73.6) ; v2(43.31,42.04) 43.43,41.91 44.7,41.91 45.15,41.47 R771.1 ; PHY2.D5 141.14,98.49 v2(140.64,98.99) ; v2(73.02,85.92) 73.32,86.23 C680.2 ; v1(99.77,72.01) 99.51,72.01 R713.1 ; 27.06,77.97 27.56,77.47 R694.2 ; 27.06,77.97 v3(27.06,78) ; 27.06,77.97 26.49,77.41 C663.2 ; v2(140.64,99.99) 141.14,99.49 PHY2.D4 ; v2(76.02,80.92) 76.49,81.4 C630.2 ; C345.1 v3(36.7,49.15) 36.7,49.91 37.34,50.55 C350.2 ; C58.2 86.87,144.15 87.25,143.76 v3(87.25,143.69) ; v2(145.29,41.78) 145.29,41.72 144.92,41.34 C335.2 ; v2(74.03,80.91) 74.14,81.03 74.14,81.03 C621.2 ; C249.2 38.26,72.26 v1(37.97,72.55) ; C525.2 85.27,83.38 C618.2 84.37,83.27 v2(84.02,82.92) ; v2(88.02,86.92) 87.54,86.44 C592.1 ; v2(70.02,96.92) 69.59,97.35 C518.2 ; v3(146.58,149) 146.94,149.35 C421.1 ; PHY1.H4 v2(145.64,75.6) ; C597.2 68.28,85.18 v2(68.02,84.92) ; C732.1 34.04,49.4 v3(33.78,49.15) ; v2(73.02,89.92) 73.11,89.92 73.59,90.41 C559.2 ; v2(73.02,89.92) 72.33,90.61 C560.2 ; v2(73.02,89.92) 72.47,89.38 C682.2 ; C646.2 76.56,79.46 v2(77.02,79.92) ; v1(104.78,129.03) 105.21,128.59 C99.2 ; v1(18.49,93.07) 18.9,93.07 19.6,92.36 R639.2 ; 30.15,135.26 29.27,134.38 C835.1 29.27,133.8 29.46,133.61 29.47,133.61 v1(29.47,133.56) ; R711.1 102.36,72.01 v1(102.62,72.26) ; C647.2 68.52,78.42 68.96,77.98 v2(68.96,77.93) ; v2(72.02,82.92) 71.5,83.44 C609.2 ; v2(75.03,97.97) 75.43,98.37 C514.2 ; R592.1 v3(138.68,107.7) R601.1 ; v1(68.28,110.37) 68.28,110.37 68.28,109.46 C809.2 ; R597.1 v3(144.27,107.7) R593.1 ; R723.1 R731.1 102.47,65.53 102.69,65.75 102.71,65.75 v1(102.81,65.85) ; v2(67.1,84.99) 66.9,85.19 C598.2 ; C465.2 108.15,124.24 v1(108.89,123.49) ; R745.2 74.69,48.71 74.12,48.13 v1(74.12,48.06) ; C612.2 87.45,84.35 v2(88.02,84.92) 87.74,85.2 87.74,85.2 R657.2 ; v3(148.97,83.57) 149.1,83.57 149.53,84 R659.1 ; v3(112.02,53.95) 114.55,51.42 C734.1 ; v2(75.02,83.92) 75.31,84.22 C604.2 ; C521.2 89.49,95.4 v2(90.02,95.92) ; v3(164.21,171.96) 163.83,171.96 163.58,171.7 R4.1 ; v2(80.02,96.92) 79.54,97.4 C555.2 ; C539.2 63.93,95.12 v2(64.14,94.92) ; v2(64.02,90.92) 64.39,90.55 C564.2 ; v1(64.59,35.81) C789.2 65.66,34.92 66.6,35.86 v2(66.6,36.49) ; v1(153.52,109.68) 153.92,109.28 C493.1 ; C687.2 111.34,64.77 v3(111.91,65.35) ; R665.1 v3(142.88,83.3) R674.1 ; R582.1 R583.1 122.81,118.29 v1(122.81,117.98) ; v2(84.02,90.92) 84.09,91 C565.2 ; Q15.2 122.94,150.5 122.93,150.5 v3(122.76,150.5) ; PHY1.F5 143.14,74.1 v2(142.64,74.6) ; C529.2 73.51,95.43 v2(73.02,95.92) ; v3(64.92,132.68) 65.08,132.52 R816.2 ; v3(128.26,48.3) 126.87,48.3 126.28,47.7 C353.1 ; v2(71.02,91.92) 70.43,91.33 C585.2 ; PHY1.D5 141.14,74.1 v2(140.64,74.6) ; C662.2 65.34,76.51 65.74,76.92 65.81,76.92 65.84,76.95 v2(65.9,76.95) 66.33,76.51 C661.2 ; v2(58.02,86.92) 58.62,87.52 C580.2 ; v2(84.75,47.7) 84.89,47.57 C744.2 ; v3(128.91,129.9) 129.1,129.71 C439.1 ; v2(65.02,66.92) 64.6,67.34 C707.2 ; C755.2 65.63,44.39 v2(65.77,44.53) 66.38,45.14 R754.2 ; v1(84.89,44.44) 85.03,44.31 C752.2 ; Q18.2 176.25,144.63 176.5,144.88 v3(176.5,144.88) ; PHY1.E6 142.14,73.1 v2(141.64,73.6) ; v3(137.41,144.53) 137.97,143.97 NOR1.10 ; v2(84.9,78.94) 85.47,79.51 R684.2 ; v1(148.01,65.93) C719.2 ; PHY1.J4 v2(146.64,75.6) ; C790.2 96.84,35.4 v2(96.56,35.12) ; v2(90.02,91.95) 89.81,91.95 C650.2 ; v3(159.89,171.07) 160.34,171.52 C1.2 ; v3(147.49,155.08) 147.45,155.12 C402.2 ; v3(44.72,142.97) 44.69,142.94 C842.2 ; v2(84.02,88.92) 84.62,88.32 C581.2 ; R487.2 154.11,157.8 153.77,158.14 v3(153.67,158.14) 152.99,158.14 152.65,157.8 R488.2 ; v3(133.1,73.33) 133.66,73.9 R704.2 ; R687.2 C653.2 21.77,76.87 21.91,76.73 v3(21.97,76.73) ; v3(117.09,31.72) 116.92,31.9 Q21.2 ; R671.2 55.3,81.64 v2(55.02,81.92) ; v1(44.7,160.4) 44.7,160.35 44.19,159.84 NAND1.K3 ; R805.1 45.28,145.29 44.73,144.73 v1(44.73,144.63) ; C691.2 79.6,66.51 79.83,66.73 v2(80.02,66.92) ; v3(149.05,91.24) 149.33,91.24 149.93,90.63 C569.2 ; PHY1.F4 143.14,75.1 v2(142.64,75.6) ; v1(100.08,87.99) 100.05,87.99 99.78,88.27 R648.2 ; v1(43.21,133.21) 43.2,133.21 43.2,133.24 43.24,133.27 43.36,133.27 43.39,133.3 43.4,133.3 43.72,133.62 43.72,133.97 43.68,134.01 43.68,134.02 43.63,134.07 C836.2 ; v2(141.64,99.99) 142.14,99.49 PHY2.E4 ; v3(162.69,150.37) C416.1 ; C674.2 76.53,75.44 v2(76.02,74.92) ; PHY2.L6 v2(148.64,97.99) ; C389.1 152.16,170.38 v3(152.52,170.02) ; C575.2 69.44,89.5 v2(69.02,89.92) ; R739.1 102.07,62.99 v1(102.62,63.54) 102.52,63.63 102.51,63.63 102.17,63.97 102.17,63.98 102.05,64.1 R734.1 ; C392.2 106.61,165.92 107.19,166.5 107.19,166.47 v3(107.2,166.47) ; v3(74.8,41.02) 75.44,40.39 R778.1 ; R600.1 v3(140.08,107.7) R591.1 ; R664.1 v3(144.27,83.3) R673.1 ; v2(59.05,75.06) 59.05,75.18 58.6,75.63 C699.2 ; v2(76.9,68.92) 77.27,69.29 77.41,69.44 C704.2 ; R720.1 102.05,70.38 102.46,69.98 v1(102.87,69.98) 102.87,69.67 102.29,69.09 R721.1 ; R744.1 69.02,49.66 69.56,49.12 70.78,49.12 v3(70.98,49.31) ; R612.2 18.03,105.24 v3(18.77,105.97) ; v2(64.01,79.12) 64.52,78.61 C643.2 ; v1(97.28,67.18) 97.97,67.18 R743.2 ; v2(96.52,38.88) 96.44,38.96 C772.2 ; v2(79.02,79.92) 79.53,80.43 C607.2 79.59,80.5 v2(80.01,80.92) ; C535.2 70.41,95.25 v2(69.98,94.82) ; C536.2 64.7,95.61 v2(65.02,95.92) ; v2(143.76,41.78) 143.76,41.69 143.42,41.34 C776.1 ; C677.2 72.21,74.48 71.3,75.38 R716.2 ; v2(89.99,93.93) 89.88,93.93 C531.2 ; PHY2.G5 v2(143.64,98.99) ; Q12.2 172.34,156.46 v1(171.67,156.46) ; R259.2 C134.2 58.85,124.9 58.85,125.9 v3(58.85,125.91) ; PHY2.F4 143.14,99.49 v2(142.64,99.99) ; v2(65.99,74.88) 65.99,74.85 65.49,74.35 C303.2 ; v2(77.55,43.7) 77.47,43.62 C758.2 ; PHY1.E4 142.14,75.1 v2(141.64,75.6) ; v2(42.49,45.31) 42.32,45.14 C748.2 ; v2(71.02,66.92) 70.54,67.4 C710.2 ; v2(78.02,97.92) 77.58,97.48 C545.2 ; R668.2 36.19,89.07 v3(35.17,90.08) ; C424.1 162.69,143.76 v3(162.56,143.64) ; C553.2 59.74,90.07 60.03,89.78 v2(60.03,89.76) ; v2(69.92,78.81) 69.92,78.92 69.53,79.32 C641.2 ; v1(112.52,168.35) 112.28,168.6 R479.1 ; C519.2 67.47,96.76 67.71,96.99 v2(67.9,96.99) ; C683.2 72.47,88.3 v2(72.97,88.8) ; v3(111.85,63.36) 111.83,63.37 C702.2 ; v3(150.32,83.06) 149.73,82.47 R678.2 ; Q14.2 176.94,150.62 v1(177.55,151.23) ; PHY2.E5 142.14,98.49 v2(141.64,98.99) ; v1(138.59,60.3) 138.56,60.27 C321.1 ; C816.2 65.44,97.35 v2(66.02,97.92) 66.47,97.47 R620.1 ; C774.2 54.99,38.12 v2(55.02,38.09) ; R293.2 73.09,108.26 72.73,108.62 72.73,109.37 73.27,109.91 v1(73.56,109.91) ; C660.2 67.61,76.51 v2(67.02,75.92) 67.45,75.49 C826.2 ; R777.1 92.96,42.42 93.29,42.75 v2(93.29,42.75) ; v3(34.47,89.87) 34.44,89.84 33.92,89.84 C557.2 33.97,92.2 B29.2 36.51,92.2 C225.2 C558.2 ; C810.1 66.03,109.04 67.19,109.04 C808.2 67.51,109.37 67.51,110.27 v1(67.39,110.39) ; C574.2 67.64,90.55 v2(68.02,90.92) ; C769.2 32.7,39.38 32.44,39.13 v3(32,39.13) ; PHY1.H7 v2(145.64,72.6) ; C818.2 77.44,75.5 v2(77.02,75.92) ; v2(54.97,35.7) 54.19,34.92 53.09,34.92 52.83,35.18 C785.2 53.21,35.81 v1(54.1,35.81) ; v2(67.06,83.95) 67.01,83.95 66.66,84.3 C608.2 ; C754.2 53.35,44.46 54.13,45.24 v2(54.13,45.36) 54.09,45.4 C747.2 ; v3(21.46,64.26) 22.55,64.26 C293.2 ; v2(96.44,44.52) 96.56,44.63 C750.2 ; R644.1 v3(141.99,88.77) ; C838.2 43.48,125.95 v1(43.81,125.62) ; v3(38.86,41.66) 39.31,41.21 C764.2 ; v1(176.91,157.02) 176.83,157.1 Q11.2 ; R616.2 v1(57.4,109.85) ; C659.2 68.96,75.98 v2(69.02,75.92) 69.53,75.41 C825.2 ; R699.1 15.82,74.36 14.66,73.21 v3(14.56,73.21) ; v2(70.99,77.85) 70.54,77.4 C658.2 ; v1(31.88,87.96) 33.54,86.3 C629.2 C628.2 C627.2 ; C583.2 76.53,87.43 v2(77.02,87.92) ; v1(104.7,126.01) 105.25,126.56 C458.1 ; C771.2 72.56,39.33 v1(73.1,38.79) 73.12,38.8 73.92,38.8 C777.2 ; v1(81.69,117.6) 81.6,117.69 81.6,117.83 81.59,117.84 R587.2 ; R594.1 v3(142.88,107.7) R598.1 ; v2(85.98,71.87) 86.4,71.46 C701.2 ; C648.2 72.48,78.52 v2(73.03,77.98) 73.42,78.38 C651.2 ; R666.1 v3(141.48,83.3) R675.1 ; v1(78.77,106.86) 79.25,107.34 C494.1 ; C711.2 111.37,60.2 v3(111.95,59.62) 111.13,58.8 C672.2 ; U70.3 v3(159.94,103.23) ; R753.1 64.27,45.27 63.71,44.71 v1(63.71,44.7) ; PHY1.H6 v2(145.64,73.6) ; v2(84.02,84.92) 84.51,85.41 C602.2 ; v2(76.96,81.97) 76.96,81.98 76.58,82.36 C615.2 ; RR1.2 63.63,68.52 63.95,68.85 v2(63.95,68.95) 64.39,68.51 C705.2 ; v3(16.43,96.47) 16.39,96.43 C537.2 17.17,95.65 v3(17.17,96.49) ; C783.2 v1(32,36.96) ; R602.2 v3(149.73,107.57) R588.1 ; v2(42.42,47.75) 41.85,47.17 C739.2 ; C379.2 103.07,33.85 v1(103.63,34.42) ; PHY1.E5 142.14,74.1 v2(141.64,74.6) ; v2(75.02,89.92) 75.46,90.37 C571.2 ; C417.1 v3(157.66,150.18) ; C625.1 v3(126.52,81.21) ; C623.2 69.4,82.04 v2(68.98,82.04) 68.53,81.59 C697.2 ; C815.2 v1(132.89,32.38) ; C600.2 69.49,85.45 v2(69.02,85.92) ; v3(10.41,59.44) C724.2 ; C552.2 83.79,99.11 v2(83.99,99.11) 84.17,98.93 C562.2 ; v2(140.64,75.6) 141.14,75.1 PHY1.D4 ; C361.2 103.05,43.56 102.62,43.13 v3(102.62,42.85) 103.07,42.4 C761.1 ; U38.14 105.04,44.37 C753.1 ; v3(155.91,103.05) 156.24,102.71 C844.1 ; v1(36.17,75.18) 36.17,75.21 36.65,75.69 C153.2 ; C208.2 C522.2 34.49,99.95 B28.2 31.24,99.95 v3(30.73,99.44) ; C230.2 v1(26.16,86.84) ; R595.1 v3(141.48,107.7) R599.1 ; v3(96.52,116.26) 96.52,116.32 96.39,116.45 R605.2 ; PHY2.J6 v2(146.64,97.99) ; C665.2 57.97,74.71 v2(57.99,74.73) ; C613.2 64.57,81.46 v2(64.03,80.92) 64.57,80.39 C636.2 ; v3(147.49,156.08) 148.18,155.39 R503.2 ; R756.2 110.36,44.96 v3(109.86,45.47) ; C620.2 85.22,77.72 v2(84.98,77.96) ; v2(84.86,38.11) 85.44,37.53 C782.2 ; v2(78.02,100.92) 77.47,100.38 C546.2 77.67,99.36 77.79,99.49 79.4,99.49 C547.2 ; v3(133.99,154.91) 133.92,154.98 C401.1 ; v3(133.17,41.53) C775.1 ; C476.2 155.77,120.34 v3(156.21,120.78) 156.65,120.34 C475.1 ; R631.1 v3(133.17,96.65) ; v2(60.01,76.16) 59.99,76.19 59.94,76.19 59.29,76.84 C655.2 ; C700.2 85.52,74.45 v2(85.04,74.93) ; PHY2.G6 v2(143.64,97.99) ; v3(18.3,94.44) 18.75,94.44 20.24,95.94 20.24,103.57 v3(19.16,104.65) ; PHY2.F6 143.14,97.49 v2(142.64,97.99) ; R640.2 87.5,91.44 87.5,91.41 v2(87.98,90.93) 87.52,90.47 86.67,90.47 C554.2 ; PHY1.J5 v2(146.64,74.6) ; C678.2 67.51,69.42 67.83,69.1 v2(67.97,68.95) 68.41,68.51 C696.2 ; v3(162.36,103.56) 162.38,103.57 R613.2 ; v1(132.97,70.99) 133.53,70.99 R715.2 R709.1 ; C487.2 79.66,118.27 79.25,117.86 v1(79.12,117.86) ; v2(67.42,47.7) 67.44,47.68 R746.1 ; v2(65.79,42.91) 65.76,42.91 C760.2 ; R596.1 v3(145.67,107.7) R590.1 ; PHY2.E6 142.14,97.49 v2(141.64,97.99) ; C516.2 71.46,98.37 v2(71.02,97.92) 70.51,98.43 R623.1 ; C720.1 144.63,131.12 v3(145.05,130.71) ; R662.1 v3(140.08,83.3) R676.1 ; C626.2 58.48,81.32 v2(58.91,80.88) ; v2(76.02,94.92) 75.51,95.43 C528.2 ; v2(72.02,68.92) 72.43,68.51 C706.2 ; C570.2 144.96,90.62 v3(144.53,91.06) ; R730.1 v1(139.38,65.84) ; R476.1 101.29,171.01 v3(100.84,170.56) ; PHY1.L6 v2(148.64,73.6) ; v1(157.68,109.6) 158.01,109.28 C490.1 ; C406.1 v1(54.61,158.43) ; v3(152.88,173.2) 152.81,173.2 152.44,172.84 R472.1 ; PHY1.K6 v2(147.64,73.6) ; v2(142.64,73.6) 143.14,73.1 PHY1.F6 ; C405.2 v1(56.01,158.43) ; R787.1 17.09,31.81 16.64,32.26 v3(16.38,32.26) ; v2(60.02,84.72) 59.68,84.39 C599.2 ; v2(58.04,82.93) 58.47,82.5 R667.1 ; C709.2 75.53,69.44 v2(75.02,68.92) ; C654.2 111.88,57.4 112.02,57.55 v3(112.05,57.55) ; v1(92.72,111.37) 92.89,111.37 C496.1 ; v1(30.96,147.96) 30.35,147.96 30.03,147.63 C837.1 ; v2(89.19,45.36) 89.11,45.28 C751.2 ; v2(88.01,92.91) 87.68,92.58 C567.2 ; C479.1 v3(90.3,121.2) ; C586.2 68.64,87.43 v2(69.09,87.88) 69.54,87.43 C561.2 ; v2(90.03,89.94) 89.79,89.94 89.48,90.25 C543.2 ; v2(56.97,90.87) 57.08,90.98 R638.2 ; R672.1 v3(145.67,83.3) R661.1 ; v2(74.02,66.92) 73.73,66.92 73.48,67.18 C692.2 73.23,67.43 73.23,68.1 73.64,68.51 C695.2 ; C766.1 103.07,40.58 102.6,40.11 v3(102.59,40.11) ; v2(59,91.82) 58.8,91.82 58.55,92.07 R635.2 ; v2(71.02,95.92) 71.5,95.44 C530.2 ; C548.2 C549.2 81.6,96.59 v2(82.03,97.02) ; v2(140.64,97.99) 141.14,97.49 PHY2.D6 ; C664.2 63.5,77.39 63.36,77.53 62.77,77.53 v2(62.12,76.89) ; v2(54.19,47.7) 53.78,47.3 C740.2 ; R768.1 128.76,42.11 v3(128.35,42.52) ; C27.2 167.46,161.93 167.46,161.91 v3(167.45,161.91) ; v2(83.02,97.92) 83.51,97.43 C550.2 C542.2 84.14,96.9 84.41,96.9 C698.2 ; R474.1 v3(95.69,171.01) ; U69.3 51.65,163.54 52.1,163.09 v3(52.35,163.09) ; C685.2 60.07,73.34 60.07,72.85 v2(59.99,72.77) ; R727.1 v1(145.03,65.15) ; PHY1.G5 v2(143.64,74.6) ; R475.1 v3(98.24,171.01) ; R489.2 150.68,157.8 v3(150.11,158.37) ; C360.1 34.92,43.56 v3(34.54,43.18) 35.56,42.16 R770.2 ; C610.2 69.85,83.09 v2(70.02,82.92) ; C708.2 111.87,61.59 v3(112.02,61.75) ; v1(87.81,35.41) 88.6,36.2 C780.2 89.72,36.2 v2(90.02,36.49) ; v1(102.74,73.4) 102.06,73.4 102.06,73.41 R706.1 ; C679.2 75.48,86.49 v2(75.03,86.94) ; v1(99.8,73.53) 99.38,73.53 R707.1 ; PHY1.L4 v2(148.64,75.6) ; v2(73.02,79.92) 72.95,79.92 C635.2 ; PHY2.H4 v2(145.64,99.99) ; v3(49.14,159.94) 48.53,160.55 C396.2 ; PHY2.J4 v2(146.64,99.99) ; C152.2 78.68,83.37 v2(79.18,83.87) 79.14,83.87 C817.2 ; C718.2 v1(153.79,66.67) ; C533.2 66.61,95.32 v2(66.15,94.87) ; C566.2 59.99,86.92 v2(59.99,86.91) ; PHY2.L4 v2(148.64,99.99) ; C784.1 103.19,36.45 103.19,35.7 103.07,35.58 C378.2 103.07,34.92 v3(102.62,34.47) ; v3(107.61,83.7) 107.88,83.7 C593.2 ; C823.2 C155.2 78.29,91.74 v2(78.05,91.97) ; v2(78.33,36.49) 78.04,36.2 C781.2 75.78,36.2 v1(75.18,35.6) ; PHY1.K4 v2(147.64,75.6) ; R797.1 152.88,88.96 v3(152.93,88.9) 153.35,89.31 C572.1 ; v3(125.98,167.89) 126.52,167.89 126.8,167.61 C391.2 ; C587.2 67.43,88.33 v2(68.02,88.92) ; R625.1 67.51,98.43 v2(67.02,98.92) ; R578.2 153.1,120.34 v1(153.54,120.78) ; PHY1.G4 v2(143.64,75.6) ; C738.2 50.11,48.15 v2(49.68,47.73) ; v3(49,161.88) 49,161.88 48.95,161.93 C395.2 ; v2(73.02,83.92) 72.77,84.17 C606.2 C605.2 ; C573.2 64.45,89.36 v2(64.02,88.92) ; v2(80.02,94.92) 79.24,95.7 C541.2 ; v1(177.16,147.42) 177.65,146.94 Q16.2 ; v3(147.02,151.69) 147.03,151.71 C415.1 ; C616.2 59.46,82.48 v2(59.02,82.92) ; C763.2 50.24,41.98 50.24,43.63 v1(49.89,43.99) ; v2(73,97.89) 73.48,98.37 C515.2 ; U58.4 125.55,108.2 125.04,108.71 v3(124.59,108.71) ; v3(160.15,162.31) R483.1 ; v1(103.89,121.27) 103.62,121.54 R806.1 ; R615.2 v1(69.98,107.57) ; C501.2 30.92,104.21 v3(30.73,104.39) ; C786.2 49.74,35.18 50.46,35.9 50.46,36.44 v2(50.47,36.45) ; v2(81.02,75.92) 80.52,75.42 C689.2 ; v2(61.38,48.5) 61.54,48.66 C735.2 ; R696.1 102.87,76.2 v1(102.91,76.16) ; C414.1 156.15,151.7 156.46,151.38 v3(156.46,151.13) ; C485.1 C483.1 91.62,120.4 v3(91.36,120.14) ; C703.2 75.51,67.43 v2(76.02,66.92) 76.52,67.43 C694.2 ; v3(76.35,156.83) R508.2 ; C384.2 v3(153.92,175.51) ; v2(76.02,84.92) 76.45,84.49 C603.2 ; C404.1 v1(57.4,158.43) ; C788.2 73.24,35.68 v1(73.23,35.69) ; PHY1.K5 v2(147.64,74.6) ; v3(68.56,114.79) 68.96,114.39 C806.2 ; R663.1 v3(138.68,83.3) R677.1 ; R649.2 57.59,88.5 v2(57.02,87.92) 56.57,87.48 R656.1 ; C556.2 76.58,96.36 v2(77.02,95.92) 77.24,95.7 C540.2 ; C684.2 74.48,83.39 v2(74.02,82.92) ; C714.1 v1(155.85,68.13) ; R719.2 79.44,69.35 v2(79.02,68.92) 78.57,68.48 C693.2 ; PHY1.J6 v2(146.64,73.6) ; C688.2 21.08,73.15 v3(21.46,72.77) ; C526.2 63.57,96.39 v2(64.03,96.85) ; v2(74.04,78.91) 73.67,79.28 73.66,79.28 C640.2 ; PHY2.H5 v2(145.64,98.99) ; v2(71.02,81.92) 71.42,81.52 C619.2 ; C841.2 30.53,128.4 29.79,129.13 29.79,129.16 v3(29.81,129.16) ; v2(142.64,98.99) 143.14,98.49 PHY2.F5 ; C830.1 v3(132.21,43.05) ; U54.4 81.83,127.65 82.13,127.95 v1(82.13,128.44) ; PHY1.H5 v2(145.64,74.6) ; C639.2 77.9,80.81 v2(78.02,80.92) ; v3(157.1,170.94) 156.52,170.94 C388.2 ; C407.2 v1(53.21,158.43) ; v2(89.24,47.7) 89.1,47.57 C743.2 ; C742.2 96.57,47.57 v2(96.44,47.7) ; v3(147.94,163.01) 147.57,162.63 C394.1 ; v2(66.02,88.92) 66.48,89.38 C563.2 ; v2(67.02,66.92) 66.55,67.39 C712.2 ; v2(61.95,96.9) 61.52,97.33 C527.2 61.53,97.36 61.53,98.13 61.55,98.15 R629.1 ; C637.2 58.73,79.59 58.93,79.79 v2(58.93,80.05) ; C594.2 64.45,86.49 v2(64.02,86.92) 64.57,87.48 C588.2 ; v2(84.02,86.92) 84.54,87.45 C631.2 ; v2(76.96,73.79) 76.64,74.11 C690.2 ; v2(64.02,82.92) 64.53,83.44 C624.2 ; v3(91.31,121.16) 91.69,121.54 C478.1 C477.1 ; v3(23.62,46.1) 23.18,46.55 C745.2 ; C438.2 v3(68,140.18) ; C157.2 81.22,87.06 v2(80.95,86.79) 81.22,86.52 C821.2 ; v2(149.99,45.47) 149.55,45.03 R762.2 ; v3(78.82,158.65) 78.94,158.65 78.97,158.67 Q13.3 ; R796.1 v1(153.54,67.49) ; C408.2 v1(51.82,158.43) ; PHY2.K4 v2(147.64,99.99) ; PHY2.K5 v2(147.64,98.99) ; R752.1 74.69,46.16 v1(74.24,46.61) 74.69,47.06 R748.1 ; C611.2 68.58,83.49 68.15,83.06 v2(67.94,83.06) ; v3(153.73,79.76) 153.35,79.38 C255.2 ; R544.2 v3(75.72,142.6) ; PHY1.L5 v2(148.64,74.6) ; C423.1 85.66,146.48 v1(85.85,146.29) ; R749.1 64.27,47.26 v3(63.52,48.01) 64.28,48.77 C737.2 ; C645.2 80.52,79.42 v2(81.02,79.92) ; C822.2 81.22,90.13 v2(81.02,89.92) ; PHY2.H6 v2(145.64,97.99) ; v2(69.01,79.74) 69.53,80.26 C633.2 ; v2(73.02,48.5) 72.79,48.73 C736.2 ; R685.2 56.58,80.44 v2(57.02,80.88) ; B44.2 84.53,122.33 84.67,122.46 C482.1 C481.1 86.64,122.46 86.69,122.41 86.69,121.6 86.44,121.34 86.36,121.34 v3(86.36,121.16) ; v1(42.45,43.66) 42.11,44.01 C372.1 ; R726.2 146.56,65.46 v1(146.3,65.2) ; v2(89.96,41.31) 89.42,40.77 R776.1 ; R643.2 v3(143.51,88.77) ; v2(56.02,75.92) 56.32,76.23 R698.2 ; R473.1 v3(94.81,171.01) ; C418.2 v3(156.47,140.72) ; v1(102.74,74.68) R702.1 ; C259.2 79.32,77.71 v2(80.04,76.99) 80.46,77.41 C673.2 ; v3(132.97,107.57) 133.73,107.57 134.3,107 C362.2 ; v2(75.02,87.92) 74.53,87.43 C584.2 ; R686.2 C652.2 25.15,77.72 v3(25.4,77.98) ; R627.2 v3(133.17,98.04) ; v2(81.18,81.92) 80.98,81.72 C632.2 ; C757.1 99.88,43.81 v3(99.42,44.27) ; v1(77.39,46.27) 76.95,45.84 C746.2 ; v1(41.94,40.46) 41.94,40.28 41.73,40.07 C768.1 ; C338.2 v3(150.88,51.44) ; C713.2 61.47,67.37 v2(61.02,66.92) ; PHY2.L5 v2(148.64,98.99) ; R634.2 v3(133.15,95.25) ; PHY1.G6 v2(143.64,73.6) ; R617.2 v1(58.8,109.98) ; PHY2.K6 v2(147.64,97.99) ; PHY2.G4 v2(143.64,99.99) ; R751.1 69.73,46.67 v2(69.95,46.89) 69.73,47.11 R747.1 ; R784.1 61.86,38.16 v1(61.59,37.9) ; PHY2.H7 v2(145.64,96.99) ; v3(143.89,162.43) 144.08,162.62 C393.2 ; v3(123.25,108.25) 123.74,108.25 124.01,107.98 C495.1 ; v1(44.07,35.07) 44.07,32.64 43.62,32.19 C376.1 ; C398.1 v3(146.69,157.76) ; U46.5 v3(152.27,166.62) ; PHY2.J5 v2(146.64,98.99) ; C480.1 v3(88.52,121.2)
  BOTTOM w0.406: v2(70.93,87.8) 71.37,87.36 C681.2 ; C617.2 66.56,82.38 v2(67.02,81.92) ; v2(90.02,81.92) U24.C20 C638.2 ; C657.2 71.61,76.51 72.01,76.92 72.01,76.96 v2(72,76.96) ; C649.2 66.48,78.58 67.06,78 v2(67.06,77.98) ; v2(81.02,89.92) 81.22,89.72 C156.2 ; v2(88.02,84.92) 88.57,84.37 C538.2 ; C667.2 72.57,76.37 v2(73.02,75.92) 73.56,75.38 C676.2 ; v2(70.94,85.88) 71.39,86.33 C520.2 ; C634.2 66.61,80.64 66.61,80.33 v2(67.02,79.92) ; v2(70.99,76.07) 70.99,75.51 R716.2
  BOTTOM w0.483: AMC1.85 8,97.46 v3(8.51,96.95) ; v3(8.41,75.95) 6.48,75.95 5.21,77.21 AMC1.58 ; v3(8.47,78.53) 7.44,79.57 7.42,79.57 5.28,81.71 AMC1.64 ; AMC1.13 5.43,43.46 7.11,41.78 v3(8.38,41.78) ; AMC1.70 6.5,86.21 7.59,85.12 v3(8.41,85.12) ; AMC1.7 4.85,38.96 6.53,37.29 v3(8.4,37.29) ; v3(8.38,73.91) 6.2,73.91 5.15,74.96 AMC1.55 ; AMC1.31 7.38,56.96 v3(8.33,57.91) ; AMC1.22 7.28,50.21 8.2,51.13 v3(8.41,51.13) ; v3(8.53,94.59) 7.47,94.59 6.85,95.21 AMC1.82 ; AMC1.37 5.33,61.46 6.58,62.71 v3(8.38,62.71) ; v3(8.59,88.68) 8.56,88.68 8.56,88.71 7.97,88.71 7.72,88.46 AMC1.73 ; v3(8.43,39.8) 6.55,39.8 5.15,41.21 AMC1.10 ; v3(8.32,54.28) 8.32,54.29 7.9,54.71 AMC1.28 ; AMC1.49 8.24,70.46 v3(8.44,70.26) ; v3(8.41,52.43) 2.64,52.43 AMC1.25 ; AMC1.67 5.85,83.96 8.15,81.66 8.58,81.66 v3(8.82,81.42) ; AMC1.16 5.67,45.71 6.58,44.81 v3(8.51,44.81) ; AMC1.1 8.81,34.46 9.4,35.05 v3(9.4,35.18) ; AMC1.40 v3(8.38,63.71) ; v3(8.37,90.24) 7.02,90.24 6.55,90.71 AMC1.76 ; v3(8.64,47.5) 6.37,47.5 5.91,47.96 AMC1.19 ; AMC1.52 7.88,72.71 v3(8.38,72.21) ; AMC1.79 5.36,92.96 5.53,92.79 9.86,92.79 10.46,92.18 v3(10.46,91.57) ; U59.2 157.23,105.79 156.49,106.53 v3(156.49,107.47) ; v3(8.38,65.96) AMC1.43 ; v3(8.41,76.77) 7.59,76.77 4.9,79.46 AMC1.61 ; AMC1.46 v3(8.57,68.21) ; AMC1.34 6.4,59.21 6.88,59.69 v3(8.41,59.69)
  BOTTOM w0.508: C410.2 v3(66.23,158.04) ; Q20.2 23.94,48.71 v3(24.26,49.02) ; v3(70.03,158.16) 70.04,158.15 C409.2 ; v3(117.73,173.38) 117.72,173.39 Q10.1 ; v3(49.14,159.94) C397.2 ; C733.1 112.93,51.24 v3(112.02,52.15) ; C787.1 v3(42.1,35.38) ; v2(41.27,37.59) 41.78,38.1 C778.1 ; v2(75.02,73.92) 75.06,73.96 C669.2 ; R481.2 108.33,168.78 v3(107.7,169.42) ; v3(103.5,170.05) 104.14,170.69 C387.2 ; C792.1 v3(31.1,35.43) ; v3(16.46,100.35) 16.46,100.36 16.26,100.55 16.26,101.85 C504.1 16.97,101.98 17.2,101.75 v3(17.2,100.38)
  vias: v1(8.38,91.54) v1(8.64,57.2) v1(8.64,54.91) v1(9.14,39.75) v1(9.25,50.24) v1(9.22,49) v1(9.45,80.19) v1(9.45,77.9) v1(9.55,83.72) v1(9.55,81.43) v1(9.73,43.48) v1(10.05,58.15) v1(10.17,55.54) v1(10.67,41.02) v1(10.92,49.91) v1(11.02,86.94) v1(11,85.75) v1(11.05,51.05) v1(11.07,81.91) v1(11.07,79.63) v1(11.17,58.15) v1(11.18,55.54) v1(11.48,82.63) v1(11.94,84.81) v1(12.29,80.29) v1(12.29,78) v1(12.4,74.47) v1(12.4,72.19) v1(12.4,70.41) v1(12.4,68.12) v1(12.38,65.57) v1(12.78,82.14) v1(12.95,67.56) v1(13.26,72.44) v1(13.26,70.15) v1(14.07,79.3) v1(15.06,82.14) v1(16.26,111.51) v1(16.26,110.36) v1(16.36,79.3) v1(16.51,70.28) v1(17.14,70.28) v1(17.8,70.28) v1(34.54,110.24) v1(35.26,110.24) v1(36.02,109.6) v1(36.22,107.19) v1(38.1,99.59) v1(38.76,94.23) v1(38.81,92.63) v1(38.98,90.91) v1(39.4,99.59) v1(39.53,87.44) v1(39.47,72.85) v1(39.9,85.04) v1(39.88,82.55) v1(39.88,76.58) v1(40.31,81.61) v1(40.41,65.13) v1(40.41,62.84) v1(40.5,87.49) v1(40.82,60.15) v1(41.05,94.23) v1(41.07,92.91) v1(41.23,66.04) v1(41.31,90.85) v1(41.4,74.42) v1(41.63,80.31) v1(41.78,79.5) v1(41.76,72.85) v1(42.19,85.04) v1(42.16,82.55) v1(42.62,73.33) v1(42.72,72.36) v1(42.8,60.15) v1(43.31,73.33) v1(43.43,90.98) v1(43.41,89.41) v1(43.52,66.04) v1(43.61,79.45) v1(43.61,78.23) v1(43.69,157.38) v1(43.9,95.13) v1(43.92,67.72) v1(45.01,72.36) v1(45.72,90.98) v1(45.69,89.41) v1(45.8,94.87) v1(45.87,157.68) v1(46.05,155.8) v1(49.12,66.09) v1(49.12,64.85) v1(51.13,87.73) v1(51.16,89.33) v1(51.41,74.22) v1(51.69,111.12) v1(52.85,135.88) v1(52.97,112.02) v1(54.84,135.86) v1(56.39,59.56) v1(56.97,138.66) v1(57.63,120.47) v1(57.66,132.59) v1(58.19,130.68) v1(58.17,59.94) v1(58.55,126.82) v1(58.52,61.95) v1(59.23,138.68) v1(63.09,58.12) v1(63.25,61.72) v1(63.75,118.36) v1(63.75,59.94) v1(64.26,110.49) v1(66.17,110.48) v1(68.68,62.28) v1(69.09,60.33) v1(73.18,129.87) v1(74.33,130) v1(74.4,124.94) v1(74.37,124.21) v1(74.42,62.23) v1(74.52,60.3) v1(76.2,127.13) v1(78.51,60.96) v1(78.49,60.2) v1(80.49,120.04) v1(80.7,121.13) v1(83.03,118.97) v1(83.26,120.57) v1(83.57,57.66) v1(83.79,59.11) v1(83.95,128.78) v1(83.95,60.48) v1(85.29,125.5) v1(86.84,124) v1(87.25,125.5) v1(87.6,103.56) v1(87.6,102.16) v1(88.52,125.55) v1(90.14,123.77) v1(90.47,125.58) v1(90.86,113.92) v1(91.59,124.82) v1(96.52,41.4) v1(99.19,41.91) v1(103.76,119.58) v1(115.06,135.99) v1(115.57,125.09) v1(115.7,135.89) v1(116.01,66.53) v1(115.99,65.87) v1(116.11,56.68) v1(116.29,75.96) v1(116.57,57.39) v1(117,86.47) v1(118.35,93.38) v1(118.3,75.78) v1(119.34,108.11) v1(119.47,106.51) v1(119.49,74.99) v1(119.49,73.57) v1(133.68,32.38) v1(134.42,31.88) v1(135.12,32.49) v1(135.15,31.85) v1(159.64,116.1) v1(159.64,113.82) v1(159.64,112.67) v1(159.64,110.39) v1(159.66,109.3) v1(159.66,107.01) v1(160.05,106.22) v1(160.38,113.84) v1(161.14,110.03) v1(163.42,110.03) v2(72.02,98.92) v2(87.99,77.92) v2(90.04,97.92) v3(11.48,87.47) v3(12.29,87.18) v3(15.47,40.97) v3(16.89,49.15) v3(17.26,49.83) v3(17.48,40.94) v3(17.93,100.32) v3(17.91,96.49) v3(18.67,100.33) v3(18.67,96.52) v3(19.48,36.25) v3(20.4,104.62) v3(20.49,94.06) v3(20.47,93.3) v3(21.21,103.15) v3(21.18,102.41) v3(21.21,101.68) v3(21.21,100.94) v3(21.23,97.12) v3(21.21,96.38) v3(21.23,94.06) v3(21.2,93.29) v3(21.26,95.58) v3(21.26,94.82) v3(22.63,91.89) v3(22.71,104.7) v3(23.22,72.8) v3(23.16,36.25) v3(23.27,42.82) v3(23.29,40.79) v3(23.44,91.87) v3(23.5,104.72) v3(24.23,91.89) v3(24.33,104.72) v3(24.69,70.1) v3(24.66,69.22) v3(25.4,104.39) v3(25.42,70.1) v3(25.4,69.22) v3(26.67,66.55) v3(29.31,57.91) v3(29.34,57.15) v3(30.05,57.93) v3(30.1,57.15) v3(30.73,98.68) v3(30.73,97.92) v3(30.89,57.91) v3(30.89,57.15) v3(35.69,34.19) v3(36.4,34.49) v3(38.07,60.91) v3(41.33,174.87) v3(41.33,173.99) v3(50.29,150.37) v3(50.29,149.48) v3(51.05,150.37) v3(51.05,149.48) v3(51.82,150.37) v3(51.82,149.48) v3(51.82,128.27) v3(52.45,121.16) v3(52.45,118.75) v3(52.45,116.08) v3(52.58,150.37) v3(52.58,149.48) v3(53.34,150.37) v3(53.34,149.48) v3(53.34,128.27) v3(54.1,150.37) v3(54.1,149.48) v3(54.99,150.32) v3(54.99,149.48) v3(56.01,150.37) v3(56.01,149.53) v3(58.64,142.01) v3(59.44,141.99) v3(62.99,139.95) v3(62.99,138.94) v3(63.63,138.18) v3(63.75,139.45) v3(64.39,138.68) v3(64.39,137.67) v3(64.52,139.95) v3(72.59,146.71) v3(72.59,144.3) v3(72.82,141.76) v3(72.85,141.02) v3(73.08,150.09) v3(73.1,149.25) v3(73.35,56.67) v3(73.91,147.14) v3(74.09,150.57) v3(75.51,140.23) v3(75.51,139.45) v3(75.51,138.53) v3(75.51,137.64) v3(76.78,144.45) v3(76.8,143.71) v3(76.84,142.9) v3(77.3,132.8) v3(77.59,144.49) v3(77.62,143.74) v3(77.6,142.9) v3(78.46,142.86) v3(78.46,132.79) v3(78.61,130.33) v3(79.2,142.86) v3(79.93,142.86) v3(80.01,147.32) v3(79.98,146.56) v3(79.96,144.81) v3(83.46,132.28) v3(83.52,131.43) v3(83.82,146.56) v3(83.82,144.91) v3(83.8,142.79) v3(84.33,132.26) v3(84.36,131.43) v3(84.54,142.8) v3(85.27,142.81) v3(85.85,143.89) v3(86.11,142.88) v3(86.36,120.14) v3(86.36,118.75) v3(86.36,116.84) v3(86.87,142.88) v3(87.27,116.17) v3(88.16,116.17) v3(88.27,111.24) v3(89.03,111.25) v3(89.05,110.21) v3(89.48,116.14) v3(90.25,116.14) v3(91.85,130.56) v3(91.87,132.06) v3(91.87,131.32) v3(99.64,47.96) v3(99.62,47.19) v3(102.46,116.84) v3(103.45,52.76) v3(104.32,55.09) v3(104.29,54.31) v3(104.29,53.49) v3(104.29,52.7) v3(105.28,35.18) v3(106.05,35.18) v3(106.78,171.97) v3(106.84,83.7) v3(106.84,78.38) v3(107.23,77.76) v3(107.54,171.96) v3(108.33,42.29) v3(108.33,41.53) v3(108.33,40.01) v3(108.33,39.24) v3(108.33,37.47) v3(108.33,36.7) v3(111.86,150.54) v3(112.7,150.54) v3(113.16,159.26) v3(113.16,158.24) v3(113.56,150.54) v3(114.07,158.62) v3(114.17,169.93) v3(114.2,157.48) v3(114.2,156.08) v3(114.71,159.16) v3(114.71,158.06) v3(114.66,156.79) v3(114.68,155.32) v3(114.94,169.93) v3(115.7,150.75) v3(116.46,170.31) v3(116.59,150.75) v3(117.42,150.77) v3(118.24,150.75) v3(118.75,39.29) v3(119.05,150.75) v3(119.25,42.14) v3(119.63,39.24) v3(119.84,150.72) v3(120.04,42.14) v3(120.62,150.75) v3(120.65,169.93) v3(121.39,150.72) v3(122.3,167.77) v3(123.06,167.77) v3(124.64,65.74) v3(124.56,63.6) v3(125.6,140.97) v3(126.47,141) v3(126.64,111.99) v3(126.64,111.18) v3(126.67,110.26) v3(126.99,79.25) v3(127.02,76.98) v3(127.02,76.04) v3(127.03,75.21) v3(127.03,73.81) v3(127,72.8) v3(127.08,78.31) v3(127.3,141.02) v3(127.38,40.51) v3(128.14,40.51) v3(128.17,141) v3(128.22,139.57) v3(128.27,138.3) v3(129.03,151.59) v3(129.18,48.26) v3(129.39,169.39) v3(129.39,168.12) v3(130.02,151.56) v3(130.07,168.76) v3(130.1,48.26) v3(130.43,157.33) v3(130.48,156.49) v3(130.48,155.6) v3(130.71,169.42) v3(130.71,168.07) v3(131.09,151.56) v3(131.06,48.26) v3(131.29,157.3) v3(131.32,156.49) v3(131.34,155.65) v3(132.23,151.56) v3(132.44,171.48) v3(132.36,66.73) v3(132.41,65.91) v3(133.25,151.61) v3(136.65,149.22) v3(137.41,149.22) v3(137.41,147.96) v3(137.41,146.81) v3(137.36,142.09) v3(137.39,141.27) v3(139.45,115.39) v3(140.84,115.82) v3(140.84,115.06) v3(145.72,115.87) v3(145.72,115.11) v3(146.56,53.21) v3(146.81,86.61) v3(147.32,53.21) v3(147.45,88.14) v3(148.08,86.61) v3(148.08,53.21) v3(150.5,65.13) v3(150.5,64.01) v3(150.52,62.92) v3(151.43,107.29) v3(151.41,106.49) v3(152.4,107.29) v3(152.4,106.49) v3(153.29,54.1) v3(153.37,107.29) v3(153.38,106.49) v3(155.07,46.61) v3(155.96,46.61) v3(156.84,46.61) v3(157.73,46.61) v3(160.43,119.38) v3(160.86,120.12) v3(161.16,133.99) v3(161.16,132.97) v3(161.49,119.35) v3(162.31,157.48) v3(162.94,158.62) v3(163.45,157.48) v3(168.81,139.09) v3(168.81,137.46) v3(172.97,66.93) v3(173.1,68.33) v3(173.23,46.99) v3(173.23,45.72) v3(178.18,68.33) v3(178.18,67.06) v3(178.31,45.59) v3(178.44,46.86) v4(109.22,172.21) v4(109.98,172.21) v4(110.74,172.21) v4(142.62,115.82) v4(142.62,114.94) v4(143.26,115.44) v4(143.89,115.82) v4(143.89,114.94) v4(144.42,61.34) v4(144.4,60.6) v4(145.19,61.34) v4(145.16,60.6) v4(149.48,115.95) v4(149.48,114.94) v4(149.99,115.44) v4(150.5,115.95) v4(150.5,114.94) v4(165.74,169.67)
