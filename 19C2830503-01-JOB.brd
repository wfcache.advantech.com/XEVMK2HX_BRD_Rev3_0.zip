# Allegro board 19C2830503-01-JOB.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on TOP, L3: 147.57,65.15 147.57,62.48 147.96,62.1 153.03,62.1 153.54,62.61 153.54,65.15 153.16,65.53 147.96,65.53
GND on TOP, L10: 144.53,88.9 144.53,86.23 144.91,85.85 149.99,85.85 150.5,86.36 150.5,88.9 150.11,89.28 144.91,89.28
GND on BOTTOM: 36.3,40.51 37.26,40.51 37.49,40.28 37.49,37.01 37.19,36.7 36.17,36.7 35.86,37.01 35.86,40.08
GND on BOTTOM: 82.68,129.29 82.3,129.67 82.3,132.33 82.93,132.97 84.96,132.97 85.28,132.65 85.28,129.67 84.9,129.29
GND on BOTTOM: 125.2,62.43 125.07,62.31 122.99,62.31 122.89,62.41 122.89,66.93 123.14,67.18 124.89,67.18 125.2,66.88
GND on BOTTOM: 115.39,143.79 115.39,149.53 114.81,150.11 111.63,150.11 111.55,150.2 111.55,152.97 111.81,153.23 121.53,153.23 122.22,152.53 122.22,146.35 120.19,146.35 119.89,146.05 119.89,143.76 119.66,143.54 115.65,143.54
GND on BOTTOM: 65.02,142.68 65.02,137.16 64.52,136.65 60.07,136.65 59.77,136.96 59.77,139.34 60.28,139.86 62.29,139.86 62.84,140.41 62.84,142.42 62.81,142.44 62.81,142.65 63.11,142.94 64.77,142.94
GND on BOTTOM: 58.67,141.68 58.27,142.09 58.27,145.26 58.47,145.47 59.56,145.47 59.72,145.31 59.72,145 59.72,145 59.72,141.85 59.55,141.68
GND on BOTTOM: 128.8,157.58 132.31,157.58 132.89,157 132.89,155.35 133.76,154.48 133.76,151.59 133.38,151.21 128.91,151.21 128.55,151.56 128.55,157.33
GND on BOTTOM: 15.88,51.44 17.27,51.44 17.53,51.18 17.53,48.01 17.4,47.88 15.75,47.88 15.62,48.01 15.62,51.18
GND on BOTTOM: 120.09,38.71 117.32,38.71 117.17,38.86 117.17,42.23 117.45,42.51 120.26,42.51 120.57,42.2 120.57,39.18
GND on BOTTOM: 74.6,150.88 73.3,150.88 72.77,150.34 72.77,147.62 72.39,147.24 72.39,141.1 73.53,139.95 73.53,137.41 73.91,137.03 75.54,137.03 75.82,137.31 75.82,141.43 74.93,142.32 74.93,150.55
GND on BOTTOM: 47.75,122.3 57.15,122.3 57.4,122.05 57.4,121.23 57.23,121.06 57.23,120.29 57.4,120.12 57.4,114.94 57.15,114.68 47.75,114.68 47.5,114.94 47.5,122.05
GND on BOTTOM: 69.95,122.15 69.57,121.77 64.01,121.77 63.73,122.05 63.73,127.76 63.88,127.91 69.77,127.91 69.95,127.74
GND on BOTTOM: 86.94,121.62 91.19,121.62 91.69,121.11 91.69,117.17 91.39,116.87 86.82,116.87 86.47,116.52 85.92,116.52 85.46,116.98 85.46,121.68 85.55,121.77 86.79,121.77
GND on BOTTOM: 88.8,106.65 86.51,106.65 86.26,106.91 86.26,111.61 86.49,111.84 89.08,111.84 89.28,111.63 89.28,107.14
GND on BOTTOM: 114.35,137.54 111.25,137.54 110.52,136.8 110.52,134.98 111.38,134.11 115.11,134.11 115.77,134.77 115.77,136.12
GND on BOTTOM: 106.81,173.74 109.88,173.74 111.05,172.57 111.05,171.83 110.67,171.45 106.78,171.45 106.55,171.68 106.55,173.48
GND on BOTTOM: 104.8,35.56 107.24,35.56 107.7,36.02 107.7,42.29 108.33,42.93 109.82,42.93 109.82,42.93 111.63,44.73 113.17,44.73 113.56,44.35 113.56,43.34 113.16,42.94 112.61,42.94 112.42,43.13 111.11,43.13 110.36,42.38 110.36,32.13 109.98,31.75 104.78,31.75 104.34,32.18 104.34,35.1
GND on BOTTOM: 92.46,130.05 91.19,128.78 90.42,128.78 90.21,128.99 90.21,132.88 90.55,133.22 92.2,133.22 92.46,132.97
GND on BOTTOM: 26.47,92.13 25.88,91.54 20.29,91.54 20.1,91.73 20.1,94.75 20.8,95.45 20.8,104.29 22.15,105.64 23.5,105.64 24.31,106.45 24.31,108.2 24.59,108.48 26.21,108.48 26.47,108.23
GND on BOTTOM: 125.76,128.09 132.13,128.09 132.26,127.97 132.26,123.39 131.8,122.94 125.73,122.94 125.43,123.24 125.43,127.76
GND on BOTTOM: 137.92,149.48 137.92,145.92 137.67,145.67 136.02,145.67 135.76,145.92 135.76,149.22 136.14,149.61 137.79,149.61
GND on BOTTOM: 115.95,127.89 115.57,128.27 108.31,128.27 108.1,128.07 108.1,121.95 108.56,121.49 115.65,121.49 115.95,121.79
GND on BOTTOM: 112.78,159.64 116.59,159.64 116.84,159.39 116.84,154.43 116.46,154.05 112.9,154.05 112.39,154.56 112.39,159.26
GND on BOTTOM: 129.41,171.83 133.76,171.83 134.39,171.2 134.39,168.34 133.76,167.7 129.44,167.7 129.03,168.11 129.03,171.45
GND on BOTTOM: 26.29,66.8 27.94,66.8 28.45,66.29 28.45,60.45 28.57,60.33 36.58,60.33 37.08,59.82 37.08,56.85 36.75,56.52 26.16,56.52 25.53,57.15 25.53,66.04
GND on BOTTOM: 76.49,144.36 76.5,144.37 76.5,144.5 76.76,144.75 77.37,144.75 77.62,145.01 77.62,146.13 77.9,146.41 77.9,147.55 78.23,147.88 80.21,147.88 80.42,147.68 80.42,147.17 80.87,146.71 84.23,146.71 84.3,146.63 84.3,144.55 84.71,144.15 86.13,144.15 86.31,143.97 86.31,143.23 86.46,143.08 89.28,143.08 89.69,142.67 89.69,139.39 88.85,138.55 78.11,138.55 76.49,140.17
GND on BOTTOM: 55.3,142.49 55.12,142.32 52.07,142.32 50.82,143.56 50.82,144.58 51.08,144.84 51.08,147.99 50.69,148.39 50.32,148.39 49.81,148.9 49.81,150.63 50.09,150.91 56.13,150.91 56.33,150.71 56.33,149.35 56.2,149.22 54.44,149.22 54.22,149 54.22,147.78 54.49,147.51 55.07,147.51 55.3,147.28
GND on BOTTOM: 38.46,34.8 38.81,34.44 38.81,32.16 38.56,31.9 35.48,31.9 35.1,32.28 35.1,34.34 35.56,34.8
GND on BOTTOM: 76.71,133.6 78.61,133.6 78.87,133.35 78.87,129.41 78.61,129.16 78.36,129.16 77.72,129.79 76.83,129.79 76.33,130.3 76.33,133.22
GND on BOTTOM: 113.92,171.96 116.71,171.96 117.09,171.58 117.09,170.05 116.71,169.67 114.05,169.67 113.67,170.05 113.67,171.7
GND on BOTTOM: 50.47,133.93 56.54,133.93 56.64,133.83 56.64,132.66 56.18,132.21 56.18,127.94 55.89,127.65 50.03,127.65 49.91,127.76 49.91,128.4 50.27,128.75 50.27,133.73
GND on BOTTOM: 128.04,41.9 124.96,41.9 124.51,41.44 124.51,40.17 124.66,40.01 128.16,40.01 128.43,40.28 128.43,41.51
GND on BOTTOM: 128.12,141.76 128.52,141.35 128.52,138.15 127.99,137.62 122.73,137.62 122.34,138.01 122.34,140.47 123.62,141.76
GND on BOTTOM: 45.59,76.68 45.59,73.86 44.75,73.03 42.47,73.03 42.24,73.25 42.24,73.94 43.26,74.96 43.26,76.58 43.51,76.84 45.44,76.84
GND on BOTTOM: 86.97,116.46 86.61,116.1 85.09,116.1 84.86,115.87 84.86,114.73 85.14,114.45 87.35,114.45 88.11,113.69 90.96,113.69 92.39,115.12 94.49,115.12 94.77,115.4 94.77,116.15 94.62,116.3 91.59,116.3 91.43,116.46
GND on BOTTOM, L3, L5, L8, L10: 140.97,56.71 140.97,50.48 141.13,50.32 147.96,50.32 148.34,50.7 148.34,56.32 147.83,56.83 141.1,56.83
GND on BOTTOM, L3, L5, L8, L10: 164.97,141.96 172.14,141.96 172.44,141.66 172.44,135.51 172.14,135.2 164.95,135.2 164.64,135.51 164.64,141.63
GND on BOTTOM, L3, L5, L8, L10: 165.99,157.1 165.61,156.72 160.15,156.72 159.77,157.1 159.77,160.27 160.02,160.53 165.74,160.53 165.99,160.27
GND on BOTTOM, L3, L5, L8, L10: 100.91,120.14 103.76,120.14 104.5,119.41 104.5,115.67 103.81,114.99 100.97,114.99 100.08,115.87 100.08,119.74 100.51,120.17 100.91,120.17
GND on BOTTOM, L3, L5, L10: 163.96,132.21 158.62,132.21 158.24,132.59 158.24,135.53 158.6,135.89 163.96,135.89 164.21,135.64 164.21,132.46
GND on L2_GND: 11.56,29.97 11.56,32.46 11.05,33.71 9.8,34.22 2.79,34.22 2.79,97.7 9.8,97.7 11.05,98.21 11.56,99.46 11.56,113.31 11.05,114.56 9.8,115.07 7.46,115.07 7.46,172.65 9.26,172.65 9.26,175.25 11.56,175.25 11.56,176.95 166.24,176.95 166.24,175.95 173.84,175.95 173.84,171.75 179.84,171.75 179.84,97.16 170.03,97.16 169.04,98.15 169.04,99.46 169.67,100.1 169.67,102.59 168.89,103.38 162.71,103.38 162.31,102.98 162.31,102 165.74,98.57 165.74,76.56 165.1,75.92 165.1,68.09 165.76,67.44 169.02,67.44 169.8,68.22 169.8,70.84 168.78,71.86 168.78,73.05 169.78,74.04 179.84,74.04 179.84,31.07 167,31.07 167,31.57 157.24,31.57 157.24,29.97
GND on L3: 47.75,122.3 57.15,122.3 57.4,122.05 57.4,121.36 57.12,121.08 57.12,120.37 57.4,120.09 57.4,114.94 57.15,114.68 48.13,114.68 47.5,115.32 47.5,122.05
GND on L5, L8: 47.75,122.3 57.15,122.3 57.4,122.05 57.4,121.34 57.23,121.16 57.23,120.29 57.4,120.12 57.4,114.94 57.15,114.68 47.75,114.68 47.5,114.94 47.5,122.05
GND on L5, L8: 147.45,65.02 147.45,62.36 147.83,61.98 152.91,61.98 153.42,62.48 153.42,65.02 153.03,65.41 147.83,65.41
GND on L6_GND: 11.56,29.97 11.56,32.46 11.05,33.71 9.8,34.22 2.79,34.22 2.79,97.7 9.8,97.7 11.05,98.21 11.56,99.46 11.56,113.31 11.05,114.56 9.8,115.07 7.46,115.07 7.46,172.65 9.26,172.65 9.26,175.25 11.56,175.25 11.56,176.95 166.24,176.95 166.24,175.95 173.84,175.95 173.84,171.75 179.84,171.75 179.84,97.16 170.03,97.16 169.04,98.15 169.04,99.46 169.67,100.1 169.67,102.59 168.89,103.38 162.71,103.38 162.31,102.98 162.31,102 165.74,98.57 165.74,76.56 165.1,75.92 165.1,68.09 165.76,67.44 169.02,67.44 169.8,68.22 169.8,70.84 168.78,71.86 168.78,73.05 169.78,74.04 179.84,74.04 179.84,31.07 167,31.07 167,31.57 157.24,31.57 157.24,29.97 ; 2 cut-outs
GND on L7_GND: 11.56,29.97 11.56,32.46 11.05,33.71 9.8,34.22 2.79,34.22 2.79,97.7 9.8,97.7 11.05,98.21 11.56,99.46 11.56,113.31 11.05,114.56 9.8,115.07 7.46,115.07 7.46,172.65 9.26,172.65 9.26,175.25 11.56,175.25 11.56,176.95 166.24,176.95 166.24,175.95 173.84,175.95 173.84,171.75 179.84,171.75 179.84,97.16 170.03,97.16 169.04,98.15 169.04,99.46 169.67,100.1 169.67,102.59 168.89,103.38 162.71,103.38 162.31,102.98 162.31,102 165.74,98.57 165.74,76.56 165.1,75.92 165.1,68.09 165.76,67.44 169.02,67.44 169.8,68.22 169.8,70.84 168.78,71.86 168.78,73.05 169.78,74.04 179.84,74.04 179.84,31.07 167,31.07 167,31.57 157.24,31.57 157.24,29.97 ; 2 cut-outs
GND on L8: 163.96,132.21 158.62,132.21 158.24,132.59 158.24,135.38 158.75,135.89 163.96,135.89 164.21,135.64 164.21,132.46
GND on L10: 147.57,65.02 147.57,62.36 147.96,61.98 153.03,61.98 153.54,62.48 153.54,65.02 153.16,65.41 147.96,65.41
GND on L10: 47.75,122.3 57.15,122.3 57.4,122.05 57.4,121.31 57.23,121.13 57.23,120.32 57.4,120.14 57.4,114.94 57.15,114.68 47.75,114.68 47.5,114.94 47.5,122.05
GND on L11_GND: 11.56,29.97 11.56,32.46 11.05,33.71 9.8,34.22 2.79,34.22 2.79,97.7 9.8,97.7 11.05,98.21 11.56,99.46 11.56,113.31 11.05,114.56 9.8,115.07 7.46,115.07 7.46,172.65 9.26,172.65 9.26,175.25 11.56,175.25 11.56,176.95 166.24,176.95 166.24,175.95 173.84,175.95 173.84,171.75 179.84,171.75 179.84,97.16 170.03,97.16 169.04,98.15 169.04,99.46 169.67,100.1 169.67,102.59 168.89,103.38 162.71,103.38 162.31,102.98 162.31,102 165.74,98.57 165.74,76.56 165.1,75.92 165.1,68.09 165.76,67.44 169.02,67.44 169.8,68.22 169.8,70.84 168.78,71.86 168.78,73.05 169.78,74.04 179.84,74.04 179.84,31.07 167,31.07 167,31.57 157.24,31.57 157.24,29.97 ; 2 cut-outs
GND_SHIELD on TOP, BOTTOM, L2_GND, L3, L4_PWR, L5, L6_GND, L7_GND, L8, L9_PWR, L10, L11_GND: 165.97,67.94 165.61,68.3 165.61,75.71 166.24,76.35 166.24,98.78 162.81,102.21 162.81,102.76 162.92,102.87 168.68,102.87 169.16,102.38 169.16,100.31 168.53,99.67 168.53,97.94 169.82,96.65 179.84,96.65 179.84,74.55 169.57,74.55 168.28,73.26 168.28,71.65 169.29,70.63 169.29,68.43 168.8,67.94
GND_USB1 on TOP: 179.5,161.16 179.32,161.34 175.26,161.34 175.06,161.54 175.06,162.13 174.93,162.26 170.74,162.26 170.29,161.81 170.29,161.05 169.9,160.66 169.9,160.53 169.81,160.44 169.81,159.96 170,159.77 179.27,159.77 179.5,159.99
GND_USB1 on TOP: 169.24,166.93 170.81,168.5 170.81,168.53 179.2,168.53 179.48,168.81 179.48,170.66 179.15,170.99 168.83,170.99 168.02,170.18 168.02,166.11 168.2,165.93 168.81,165.93 169.24,166.36
GND_USB1 on L10: 168.68,170.84 172.01,170.84 172.42,170.43 172.42,159.82 171.96,159.36 167.79,159.36 167.61,159.54 167.61,169.77
VBUS on TOP: 166.75,108.84 168.15,108.84 168.28,108.71 168.28,106.17 165.49,103.39 164.13,103.39 163.51,104.01 156.64,104.01 156.26,104.39 156.26,106.58 156.67,106.98 158.56,106.98 160.23,105.31 163.48,105.31 163.76,105.03 165.22,105.03 166.37,106.18 166.37,108.46
VCC0V85 on TOP: 35.32,103.87 35.32,100.47 35.05,100.2 27.99,100.2 27.84,100.36 27.84,103.63 27.97,103.76 32.64,103.76 33.15,104.27 34.92,104.27
VCC0V85 on BOTTOM: 35.56,102.69 35.56,100.51 35.51,100.46 27.3,100.46 27.05,100.71 27.05,109.93 27.3,110.19 30.76,110.19 31.24,109.7 31.24,104.7 32.13,103.81 34.44,103.81
VCC0V85 on BOTTOM: 33.53,82.3 33.53,81.03 35.31,79.25 36.07,79.25 36.45,79.63 37.13,79.63 37.34,79.43 37.34,78.56 37.16,78.38 37.16,77.75 37.34,77.57 38.63,77.57 39.07,78 39.07,81 38.84,81.23 37.9,81.23 36.7,82.42 33.66,82.42
VCC0V85 on L4_PWR: 40.49,76.58 39.22,77.85 35.54,77.85 34.04,79.35 34.04,83.33 35.28,84.58 38.46,84.58 39.12,85.24 39.12,86.72 35.92,89.92 33,89.92 32.64,90.28 32.64,104.03 33.13,104.52 48.79,104.52 49.02,104.29 49.02,81.91 51.56,79.38 63.12,79.38 63.5,78.99 63.5,77.22 61.59,75.31 61.59,73.91 61.34,73.66 51.44,73.66 48.51,76.58
VCC0V85 on L10: 70.51,89.43 65.2,89.43 64.11,88.34 64.11,82.96 63.02,81.86 62.97,81.86 62.97,79.86 62.94,79.83 62.94,79.63 62.79,79.48 62.79,77.14 62.95,76.97 63.26,76.97 63.27,76.96 65.1,76.96 65.91,77.77 65.91,80.44 67.36,81.89 67.36,86.13 67.87,86.64 70.28,86.64 70.74,87.1 70.74,89.2
VCC1V2 on L5 (solid shape): outline of 3080 points within 139.06,70.93 147.19,112.52
VCC1V2 on TOP: 141.05,114.5 142.34,114.5 142.47,114.38 142.47,113.31 143.28,112.5 143.28,111.68 143.08,111.48 141.27,111.48 140.39,110.59 138.99,110.59 138.81,110.77 138.81,113.59 139.04,113.82 140.36,113.82
VCC1V5 on TOP: 135.25,150.16 135.36,150.06 135.36,141.73 135.86,141.22 136.65,141.22 137.03,140.84 137.03,137.29 136.53,136.78 129.94,136.78 129.32,137.39 129.32,148.87 130.62,150.16
VCC1V5 on TOP: 124.71,69.55 124.5,69.33 124.5,67.45 124.36,67.31 123.34,67.31 123.1,67.55 123.1,79.82 123.22,79.93 124.43,79.93 124.71,79.65
VCC1V5 on TOP: 111.67,84.21 109.64,84.21 109.63,84.21 109.44,84.21 109.29,84.05 109.29,74.73 109.46,74.55 109.69,74.55 110.1,74.14 110.1,72.28 109.94,72.12 109.38,72.12 109.29,72.03 109.29,69.82 109.99,69.12 109.99,67.62 110.24,67.38 111.5,67.38 112.18,68.05 112.18,83.7
VCC1V5 on BOTTOM: 88.65,95.94 84.84,95.94 84.51,96.27 84.18,96.27 83.19,95.28 82.8,95.28 81.74,94.21 81.74,81.46 83.49,79.71 84.18,79.71 85.19,80.72 85.19,80.98 85.67,81.46 85.67,81.81 85.98,82.12 88.19,82.12 88.29,82.02 88.65,82.02 88.75,82.12 88.75,83.13 88.93,83.31 88.93,83.54 88.8,83.67 87.48,83.67 87.35,83.54 87.35,82.83 87.3,82.78 84.58,82.78 84.35,82.55 83.77,82.55 83.57,82.75 83.57,83.03 84.68,84.15 86.26,84.15 86.44,83.97 86.69,83.97 86.92,84.2 86.92,84.63 86.74,84.81 84.28,84.81 83.95,84.48 83.74,84.68 83.74,85.22 84.56,86.03 84.58,86.03 84.86,86.31 85.37,86.31 85.47,86.41 85.47,86.69 85.34,86.82 84.33,86.82 84.14,87.01 84.14,87.54 84.25,87.66 84.25,88.24 83.69,88.8 83.67,88.8 83.67,88.98 83.87,89.18 84.33,89.18 84.81,88.7 85.62,88.7 86,89.08 88.29,89.08 88.8,89.59 88.8,95.78 ; 1 cut-out
VCC1V5 on BOTTOM: 135.36,148.84 135.36,138.18 134.49,137.31 129.64,137.31 129.08,137.87 129.08,148.59 129.72,149.22 134.98,149.22
VCC1V5 on BOTTOM: 73.13,74.93 78.23,74.93 80.39,72.77 80.57,72.77 81.48,71.86 81.48,63.41 80.74,62.67 61.31,62.67 59.46,64.52 59.46,69.24 63.36,73.14 68.8,73.14 68.83,73.18 69.16,73.18 69.65,72.69 70.43,72.69 70.84,73.1 70.84,73.18 71.83,74.17 72.67,74.17 72.97,74.47 72.97,74.78 ; 1 cut-out
VCC1V5 on BOTTOM: 41.02,38.99 41.27,39.24 41.27,40.39 42.16,41.27 42.16,42.67 41.78,43.05 40.13,43.05 39.88,42.8 39.88,40.77 39.5,40.39 39.5,39.24 39.75,38.99
VCC1V5 on BOTTOM: 119.51,139.5 119.51,138.23 118.87,137.59 117.83,137.59 117.35,137.11 117.35,134.75 117.68,134.42 119.99,134.42 120.55,134.98 120.55,137.26 121.26,137.97 121.26,140.18 122.12,141.05 122.12,141.66 122.05,141.73 121.41,141.73 121.11,141.43 120.07,141.43 119.86,141.22 119.86,139.85
VCC1V5 on L4_PWR: 105.64,62.99 102.23,66.4 102.23,74.02 100.31,75.95 96.88,75.95 93.07,79.76 83.75,79.76 80.77,82.73 80.77,93.62 84.84,97.68 84.84,102.76 101.35,119.27 101.35,143.51 121.39,143.51 126.47,148.59 134.9,148.59 135.89,147.6 135.89,118.47 125.48,108.06 125.48,87.23 123.83,85.58 123.83,64.75 122.07,62.99
VCC1V5 on L4_PWR: 41.25,33.78 39.37,35.67 39.37,49.15 41.78,51.56 45.97,51.56 48.77,54.36 48.77,56.03 51.05,58.31 51.05,72.79 51.41,73.15 67.06,73.15 69.34,70.87 74.42,70.87 75.69,69.6 75.69,64.16 89.68,50.16 106.57,50.16 109.73,47.01 109.73,33.78
VCC1V5 on L5: 124.92,142.85 129.11,142.85 129.29,142.67 130.76,142.67 131.32,142.11 131.32,140.84 131.17,140.69 129.59,140.69 128.85,141.43 125.6,141.43 124.36,140.18 124.36,140.13 120.09,140.13 119.94,140.28 119.94,141.25 120.14,141.45 121.64,141.45 121.97,141.78 121.97,142.29 122.5,142.82 124.94,142.82
VCC1V5 on L8: 83.69,82.3 84.58,82.3 84.96,81.91 84.96,79.5 84.35,78.89 83.34,78.89 83.06,78.61 82.8,78.61 82.55,78.87 82.55,81.15
VCC1V5 on L9_PWR: 41.25,33.78 39.37,35.67 39.37,44.34 41.39,46.37 41.39,48.88 44.2,51.69 45.97,51.69 48.64,54.36 48.64,56.92 50.8,59.08 50.8,63.78 55.22,68.2 58.27,68.2 59.16,69.09 60.68,69.09 61.72,70.13 61.72,72.28 62.59,73.15 69.32,73.15 70.34,74.17 78.13,74.17 78.36,73.94 78.36,72.54 78.76,72.14 80.41,72.14 82.32,70.23 84.43,70.23 84.96,70.76 84.96,75.16 84.71,75.42 84.71,105.81 85.07,106.17 101.45,106.17 103.63,108.35 103.63,111.4 105.13,112.9 118.13,112.9 122.56,108.48 122.56,96.41 124.08,94.89 124.08,62.59 121.92,60.43 121.92,48.24 120.16,46.48 110.51,46.48 107.44,43.41 107.44,34.65 106.57,33.78 76.02,33.78 76.01,33.79 64,33.79 63.98,33.78
VCC1V5 on L10: 64.39,75.44 77.98,75.44 78.49,74.93 78.49,73.03 78.99,72.52 80.26,72.52 80.64,72.14 80.64,71.37 80.14,70.87 75.06,70.87 74.68,70.48 63.88,70.48 62.87,69.47 61.72,69.47 61.47,69.72 61.47,70.36 63.37,72.26 63.37,74.42
VCC1V8 on TOP: 34.32,55.98 33.58,55.25 33.58,54.76 33.22,54.41 32.77,54.41 32.38,54.03 32.38,53.24 32.54,53.09 36.93,53.09 37.2,53.35 37.2,53.48 36.25,54.43 36.25,55.83 36.09,55.98
VCC1V8 on TOP: 144.15,50.83 143.61,50.29 140,50.29 139.57,50.72 139.57,54 140.53,54.95 140.53,58.36 141.02,58.85 143.08,58.85 144.15,57.78
VCC1V8 on TOP: 34.92,71.07 35.47,71.61 38.51,71.61 38.66,71.47 38.66,70.42 37.8,69.56 37.8,63.78 36.38,62.36 36.37,62.36 36.02,62 27.03,62 26.47,62.56 26.47,66.29 26.85,66.68 28.7,66.68 29.34,67.31 29.34,70.74 29.67,71.07
VCC1V8 on TOP: 143.19,35.43 143.19,37.15 144.27,38.23 144.27,40.41 143.99,40.69 142.49,40.69 142.01,40.21 142.01,39.24 142,39.23 142,38.75 138.94,35.69 138.94,31.37 139.35,30.96 141.35,30.96 141.73,31.34 141.73,33.97
VCC1V8 on BOTTOM: 76.54,88.33 76.28,88.59 76.28,89.48 76.28,89.48 76.28,91.11 76.16,91.22 73.55,91.22 72.48,92.29 66.43,92.29 64.95,93.78 64.95,95.55 66.34,96.95 70.36,96.95 71.07,97.66 76.43,97.66 76.86,97.23 77.06,97.23 77.27,97.03 77.27,96.49 76.5,95.73 74.73,95.73 74.63,95.63 74.63,95 74.97,94.65 75.86,94.65 75.88,94.63 76.95,94.63 77.7,93.88 77.7,90.41 77.7,90.4 77.7,89.07 79.65,87.12 79.65,85.55 79.88,85.32 80.19,85.32 80.64,84.86 80.64,84.4 80.34,84.1 79.76,84.1 78.79,85.06 78.79,86.16 78.03,86.92 77.72,86.92 77.41,87.22 77.41,88.14 77.23,88.33
VCC1V8 on BOTTOM: 81.51,78.23 82.55,78.23 84.58,76.2 84.58,74.04 84.2,73.66 89.34,68.52 90.11,68.52 96.01,62.61 97.79,62.61 98.62,61.79 105.73,61.79 107.7,63.75 109.98,63.75 110.36,63.37 110.36,57.28 110.05,56.96 106.49,56.96 106.05,57.4 106.05,58.55 103.89,60.71 93.34,60.71 91.06,62.99 91.06,65.41 90.04,66.42 86.61,66.42 79.36,73.67 79.36,73.89 78.56,74.69 78.56,74.85 78.89,75.18 79.27,75.18 79.5,74.96 79.5,74.9 80.04,74.37 81.03,74.37 81.28,74.63 81.28,76.44 81.37,76.53 81.37,78.09
VCC1V8 on BOTTOM: 142.49,40.77 145.03,40.77 145.29,40.51 145.29,39.24 145.03,38.99 142.49,38.99 142.24,39.24 142.24,40.51
VCC1V8 on BOTTOM: 48.01,158.45 47.83,158.27 46.91,158.27 46.76,158.42 46.76,163.37 46.96,163.58 47.78,163.58 48.01,163.35
VCC1V8 on BOTTOM: 35.75,61.02 35.56,60.83 29.02,60.83 28.77,61.09 28.77,69.53 30.35,71.12 33.96,71.12 34.63,71.79 34.63,74.58 34.85,74.8 37.37,74.8 37.54,74.63 37.54,69.67 35.77,67.9 35.77,67.08 35.75,67.07
VCC1V8 on BOTTOM: 66.04,113.66 65.15,113.66 64.9,113.41 64.9,112.27 66.04,111.12 67.69,111.12 67.94,111.38 67.94,112.01 67.56,112.4 67.31,112.4
VCC1V8 on L9_PWR: outline of 98 points within 2.79,29.97 153.54,176.95 ; 3 cut-outs
VCC1V8 on L10: 142.62,151.13 142.62,154.53 139.37,157.78 134.44,157.78 133.81,158.42 133.81,164.19 131.37,166.62 106.78,166.62 105.16,165 100.18,165 98.68,163.5 96.65,163.5 88.62,155.47 84.35,155.47 83.24,156.59 83.24,168.48 82.73,168.99 63.02,168.99 62.87,169.14 62.87,174.68 63.45,175.26 82.88,175.26 85.22,172.92 87.45,172.92 89.79,175.26 142.32,175.26 148.32,169.25 151.07,169.25 151.5,168.82 151.5,166.36 149.35,164.21 149.35,162.43 149.73,162.05 149.73,160.15 148.08,158.5 148.08,157.23 149.81,155.5 157.43,155.5 159,153.92 159,150.24 157.86,149.1 144.65,149.1
VCC2V5 on TOP (solid shape): 149.74,80.01 149.74,78.99 149.73,78.98 149.73,77.59 149.35,77.21 147.96,77.21 147.32,77.84 147.32,80.27 147.36,80.28 147.68,80.57 147.61,81 147.58,81.03 147.7,81.15 148.59,81.15
VCC2V5 on TOP: 145.57,109.6 145.57,113.66 145.75,113.84 147.42,113.84 148.11,114.53 149.05,114.53 149.22,114.35 149.22,113.28 150.65,111.86 150.65,111.3 150.29,110.95 148.08,110.95 147.96,110.82 147.96,109.98 148.72,109.22 148.72,104.39 149.73,103.38 149.73,101.85 149.35,101.47 147.69,101.47 147.18,101.99 147.18,107.99
VCC2V5 on L10: 137.54,65.43 138.1,64.87 141.53,64.87 142.67,63.73 146.53,63.73 146.91,64.11 146.91,67.49 147.47,68.05 157.99,68.05 158.88,68.94 158.88,82.3 158.12,83.06 145.41,83.06 144.15,84.33 144.15,89.15 145.03,90.04 155.96,90.04 158.88,92.96 158.88,96.52 158.86,96.53 158.86,98.82 158.12,99.57 152.15,99.57 150.61,101.1 150.61,111.06 149.66,112.01 138.68,112.01 137.54,110.87
VCC3V3_AUX on TOP: 105.69,159.72 108.36,159.72 108.58,159.94 108.58,160.27 108.89,160.58 108.89,161.09 108.71,161.26 105.71,161.26 105.49,161.04 105.49,159.92
VCC3V3_AUX on TOP: 42.55,122.81 42.55,125.22 42.16,125.6 40.13,125.6 39.88,125.35 39.88,123.06 40.39,122.56 42.29,122.56
VCC3V3_AUX on TOP: 25.7,86.79 24.99,86.79 24.92,86.87 24.92,88.27 24.89,88.29 24.89,90.81 25.27,91.19 30.35,91.19 30.48,91.06 30.48,90.55 30.35,90.42 26.04,90.42 25.91,90.3 25.91,89.53 26.67,88.77 26.67,88.14 25.91,88.14 25.65,87.88 25.65,87.63 25.7,87.58
VCC3V3_AUX on TOP: 73.91,135.43 69.24,135.43 69.16,135.51 69.16,136.37 69.75,136.96 73.79,136.96 74.04,136.7 74.04,135.56
VCC3V3_AUX on TOP: 148.59,119.13 149,119.13 149.2,118.92 149.2,116.48 149.12,116.41 148.87,116.41 148.06,117.22 146.1,117.22 145.31,118.01 145.31,119.13 144.58,119.86 144.58,120.45 145.29,121.16 147.96,121.16 148.34,120.78 148.34,119.38
VCC3V3_AUX on TOP: 126.75,67.74 125.73,67.74 125.65,67.82 125.65,70.64 127.67,72.66 127.67,81.5 129.59,83.41 129.62,83.41 130.11,83.91 137.43,83.91 140.11,81.23 140.89,81.23 141.71,80.42 141.71,79.25 141.59,79.13 139.81,79.13 138.18,80.77 135.69,80.77 135.61,80.85 135.61,81.51 135.33,81.79 130.4,81.79 129.41,80.8 129.41,72.62 126.85,70.05 126.85,67.84
VCC3V3_AUX on TOP: 141.49,119.37 141.68,119.18 142.27,119.18 142.46,118.99 142.46,116.5 142.37,116.41 141.91,116.41 141.15,117.17 139.09,117.17 138.77,117.49 138.77,119.06 139.08,119.37
VCC3V3_AUX on TOP: 169.57,44.91 172.54,44.91 172.8,44.65 172.8,43.69 172.57,43.46 169.52,43.46 169.34,43.64 169.34,44.68
VCC3V3_AUX on TOP: 35.93,85.08 35.69,85.32 35.69,89.1 36.02,89.43 36.32,89.43 36.6,89.15 36.6,88.06 37.02,87.63 38.07,87.63 38.2,87.5 38.2,85.36 37.92,85.08
VCC3V3_AUX on TOP: 123.57,164.72 127.51,164.72 127.89,164.34 127.89,152.34 127.41,151.86 123.71,151.86 123.06,152.51 123.06,164.21
VCC3V3_AUX on BOTTOM: 115.49,48.89 112.65,48.89 112.52,49.02 112.52,50.04 112.67,50.19 115.57,50.19 115.75,50.01 115.75,49.15
VCC3V3_AUX on BOTTOM: 71.58,128.14 71.58,120.73 70.59,119.74 62.51,119.74 61.99,120.26 61.99,123.05 61.68,123.36 61.68,128.13 62.95,129.4 70.32,129.4 ; 1 cut-out
VCC3V3_AUX on BOTTOM: 127.89,158.5 127.89,151.23 127.48,150.83 125.25,150.83 124.97,151.1 124.97,151.59 123.06,153.49 123.06,158.62 123.57,159.13 127.25,159.13
VCC3V3_AUX on BOTTOM: 116.33,127.89 117.98,127.89 118.24,127.63 118.24,125.73 117.98,125.48 116.33,125.48 116.2,125.6 116.2,127.76
VCC3V3_AUX on BOTTOM: 58.27,125.5 56.9,125.5 56.72,125.32 56.72,124.74 56.52,124.54 55.82,124.54 55.64,124.71 55.64,125.59 55.37,125.86 52.58,125.86 52.06,126.38 51.24,126.38 51.23,126.39 48.74,126.39 48.26,126.87 48.26,129.03 48.9,129.67 48.9,134.75 50.04,135.89 57.07,135.89 59.84,133.12 59.84,127.08 ; 1 cut-out
VCC3V3_AUX on L3: 15.37,91.82 16.13,91.82 19.68,88.27 22.23,88.27 23.24,89.28 25.27,89.28 25.65,88.9 25.65,88.01 24.64,87 18.29,87 15.11,90.17 15.11,91.57
VCC3V3_AUX on L3: 101.83,45.26 101.84,45.28 101.96,45.28 102.39,45.71 102.39,47.29 103.02,47.93 111.2,47.93 112.01,48.74 117.07,48.74 117.69,49.36 124.32,49.36 125.55,50.6 125.55,53.75 124.54,54.76 111.84,54.76 108.23,51.16 100.86,51.16 100.2,50.5 100.2,45.77 100.67,45.3 101.03,45.3 101.07,45.26
VCC3V3_AUX on L4_PWR: outline of 86 points within 9.65,29.97 179.84,176.95
VCC3V3_AUX on L9_PWR: 154.05,29.97 154.05,59.92 152.38,61.59 139.93,61.59 138.43,63.1 138.43,103.99 137.27,105.16 123.3,105.16 123.06,105.39 123.06,108.69 118.34,113.41 104.92,113.41 103.12,111.61 103.12,108.56 101.24,106.68 75.92,106.68 74.8,107.8 74.8,112.54 83.95,121.69 83.95,124.86 85.98,126.89 85.98,129.14 85.2,129.92 78.76,129.92 77.09,128.25 77.09,124.82 74.44,122.17 63.01,122.17 56.54,115.7 44.68,115.7 40.51,119.87 40.51,124.59 42.04,126.11 43.43,126.11 44.2,126.87 44.2,146.81 44.19,146.82 44.19,148.85 45.59,150.26 45.59,157.63 47.73,159.77 69.45,159.77 70.61,160.93 70.61,176.95 166.24,176.95 166.24,175.95 173.84,175.95 173.84,171.75 179.84,171.75 179.84,97.16 170.03,97.16 169.04,98.15 169.04,99.46 169.67,100.1 169.67,102.59 168.89,103.38 162.71,103.38 162.31,102.98 162.31,102 165.74,98.57 165.74,76.56 165.1,75.92 165.1,68.09 165.76,67.44 169.02,67.44 169.8,68.22 169.8,70.84 168.78,71.86 168.78,73.05 169.78,74.04 179.84,74.04 179.84,31.07 167,31.07 167,31.57 157.24,31.57 157.24,29.97
VCC3V3_AUX on L10: 23.5,44.96 39.5,44.96 40.89,43.56 40.89,38.73 38.61,36.45 24.38,36.45 23.88,35.94 23.88,33.66 25.15,32.38 114.3,32.38 115.95,30.73 124.71,30.73 125.73,31.75 146.05,31.75 151.64,37.34 151.64,39.37 157.8,45.53 170.88,45.53 172.09,44.32 172.09,34.67 169.42,32 157.61,32 157.1,31.5 157.1,30.73 156.34,29.97 12.45,29.97 12.19,30.23 12.19,35.69 13.84,37.34 19.81,37.34 22.73,40.26 22.73,44.2
VCC3V3_AUX on L10: 138.07,55.32 133.83,55.32 133.43,55.73 131.32,55.73 129.72,54.13 123.39,54.13 123.06,53.8 123.06,51.68 123.25,51.49 133.22,51.49 134.23,52.49 137.87,52.49 138.45,53.07 138.45,54.95
VCC3V3_MP on TOP: 128.7,134.44 129.57,134.44 129.77,134.24 129.77,132.44 129.67,132.33 128.73,132.33 128.55,132.51 128.55,134.29
VCC3V3_MP on BOTTOM: 127.89,133.81 133.12,133.81 133.62,133.31 133.62,131.36 133.22,130.96 129.01,130.96 128.55,130.51 128.55,129.36 128.57,129.34 128.57,128.57 128.42,128.42 125.88,128.42 125.73,128.57 125.73,131.65
VCC3V3_MP on BOTTOM: 158.75,149.61 158.88,149.48 158.88,146.81 158.75,146.69 156.46,146.69 156.34,146.81 156.34,149.35 156.59,149.61
VCC3V3_MP on BOTTOM: 137.45,107.84 135.43,107.84 134.81,107.21 134.81,105.38 134.4,104.98 134.4,104.27 134.55,104.12 137.27,104.12 137.76,104.61 137.76,107.52
VCC3V3_MP on L3: 171.73,155.82 171.73,149.68 173.38,148.03 175.9,148.03 176.99,149.12 176.99,156.69 176.7,156.98 176.7,158.81 177.06,159.18 178.97,159.18 179.45,158.7 179.45,144.55 178.28,143.38 168.25,143.38 168.21,143.34 165.85,143.34 158.65,136.14 150.04,136.14 148.79,134.9 148.79,123.72 150.27,122.25 158.93,122.25 159.72,121.46 159.72,117.93 158.95,117.17 143.92,117.17 142.9,118.19 142.9,155.96 146.43,159.49 146.43,161.04 146.56,161.16 147.83,161.16 149.22,159.77 159.38,159.77 159.64,159.51 159.64,158.88 159.38,158.62 159.38,156.46 160.1,155.75 164.67,155.75 165.82,156.91 170.64,156.91
VCC3V3_MP on L5: 133.65,133.1 133.65,129.97 133.38,129.69 127.66,129.69 126.87,128.91 126.87,122.53 127.79,121.62 135.53,121.62 136.27,120.88 136.27,119.08 135.74,118.54 126.47,118.54 125.12,119.89 125.12,132.41 126.26,133.55 133.2,133.55
VCC3V3_MP on L10: 148.35,132.37 148.35,129.57 147.71,128.93 127.36,128.93 126.72,129.57 126.72,132.98 127.23,133.49 147.69,133.49 148.36,132.82 148.36,132.38
VCC3V3_MP_ALT on BOTTOM: 118.75,175.51 119.2,175.97 120.83,175.97 121.16,175.64 121.16,172.67 121.51,172.31 124.1,172.31 125.35,171.07 125.35,162.56 124.08,161.29 111,161.29 110.49,161.8 110.49,165.1 113.54,168.15 113.54,169.19 113.77,169.42 117.86,169.42 118.75,170.31
VCC3V3_MP_AMC on BOTTOM: 13.08,108.59 16.38,108.59 17.02,107.95 17.02,107.19 16.64,106.81 15.37,106.81 14.35,105.79 12.83,105.79 12.7,105.92 12.7,108.2
VCC3V3_MP_AMC on BOTTOM: 136.53,111.63 137.29,111.63 137.54,111.38 137.54,108.71 136.91,108.08 135.89,108.08 135.64,108.33 135.64,109.6 136.27,110.24 136.27,111.38
VCC3V3_MP_AMC on L3: 9.4,94.87 10.92,94.87 11.18,94.62 11.18,92.46 10.92,92.2 8.51,92.2 6.65,90.35 6.65,50.24 8.26,48.64 9.78,48.64 10.54,47.88 10.54,45.47 14.48,41.53 14.48,34.29 14.35,34.16 12.57,34.16 12.19,34.54 12.19,36.2 12.45,36.45 12.45,37.21 9.46,40.2 6.01,40.2 5.23,40.97 5.23,93.22 6.18,94.17 8.7,94.17
VCC3V3_MP_AMC on L5: 11.56,35.43 11.82,35.69 13.21,35.69 13.34,35.56 13.34,33.66 13.08,33.4 13.08,31.37 13.46,30.99 135.25,30.99 141.73,37.47 141.73,43.81 135.38,50.16 135.38,96.65 136.4,97.66 136.4,107.7 136.27,107.82 135.76,107.82 135.64,107.95 135.64,109.85 135.76,109.98 137.79,109.98 138.18,109.6 138.18,74.3 136.59,72.71 136.59,68.26 139.57,65.28 139.57,51.18 143.07,47.69 143.07,36.89 136.14,29.97 11.74,29.97 11.56,30.15
VCC3V3_MP_AMC on L8: 13.34,106.93 14.73,106.93 14.86,106.81 14.86,95.5 12.95,93.6 9.65,93.6 9.27,93.98 9.27,95.38 9.78,95.88 12.06,95.88 13.21,97.03 13.21,106.81
VCC3V3_U on TOP: 163.58,168.66 164.85,168.66 164.97,168.53 164.97,167 164.72,166.75 164.72,166.12 164.59,165.99 162.43,165.99 161.67,166.75 161.67,167.51 161.93,167.77 163.19,167.77 163.45,168.02 163.45,168.53
VCC3V3_U on BOTTOM: 156.46,167.13 155.57,167.13 155.45,167.26 155.45,168.66 155.07,169.04 154.31,169.04 154.05,169.29 154.05,172.34 154.31,172.59 154.31,173.1 153.92,173.48 153.67,173.48 153.54,173.61 153.54,173.99 153.67,174.12 156.21,174.12 156.46,173.86 156.46,172.09 155.45,171.07 155.45,170.05 155.57,169.93 156.46,169.93 156.59,169.8 156.59,167.26
VCC3V3_U on L8: 145.03,164.47 145.03,160.02 147.57,157.48 151.51,157.48 151.89,157.86 151.89,161.42 150.11,163.2 149.48,163.2 149.35,163.07 149.35,161.16 149.1,160.91 148.59,160.91 147.83,161.67 147.83,162.43 147.19,163.07 147.19,163.96 146.56,164.59 145.16,164.59
VCC3V3_U on L10: 166.88,161.54 154.69,161.54 152.78,159.64 152.78,157.86 152.02,157.1 148.72,157.1 148.34,157.48 148.34,158.12 150.11,159.89 150.11,162.05 149.61,162.56 149.61,163.45 152.78,166.62 152.78,169.29 151.64,170.43 149.35,170.43 147.19,172.59 147.19,173.74 147.57,174.12 157.86,174.12 165.86,166.12 167.13,166.12 167.39,165.86 167.39,163.07 167,162.69 167,161.67
VCC5 on TOP: 121.79,166.24 122.17,165.86 122.17,154.81 121.54,154.18 117.6,154.18 117.09,154.69 117.09,165.74 117.6,166.24
VCC5 on BOTTOM: 122.17,159.64 122.17,154.81 121.54,154.18 117.6,154.18 117.09,154.69 117.09,159.51 117.6,160.02 121.79,160.02
VCC5 on BOTTOM: 154.13,107.72 155.55,107.72 155.8,107.47 155.8,105.82 155.35,105.36 153.19,105.36 153.06,105.49 153.06,105.79 153.26,105.99 153.59,105.99 153.9,106.3 153.9,107.49
VCC5 on L5: 118.11,155.32 122.17,155.32 122.56,155.7 122.56,165.35 126.24,169.04 144.78,169.04 150.86,162.95 150.86,119.62 150.51,119.27 150.51,110.35 151.68,109.18 152.29,109.18 154,107.47 154,103.94 154.43,103.5 157.07,103.5 157.54,103.97 157.54,116.79 159.99,119.24 159.99,130.59 157.54,133.05 157.54,167.27 148.96,175.86 103.29,175.86 102.79,175.36 102.79,173.41 103.43,172.77 116.36,172.77 117.47,171.65 117.47,155.96
VCC12 on TOP: 116.79,149.12 116.87,149.05 116.87,145.9 116.74,145.77 112.75,145.77 111.3,147.22 111.3,149.64 111.7,150.04 113.79,150.04 113.84,149.99 113.84,148.87 114.17,148.54 115.32,148.54 115.9,149.12
VCC12 on TOP: 129.21,169.98 129.13,169.9 128.09,169.9 127.86,170.13 127.86,172.52 127.64,172.75 125.7,172.75 125.35,173.1 125.35,174.75 124.97,175.13 117.47,175.13 116.59,174.24 114.81,174.24 114.55,174.5 114.55,175.82 114.73,176 128.68,176 129.21,175.46
VCC12 on TOP: 9.5,52.58 9.5,54.03 9.68,54.2 12.06,54.2 13.26,55.4 13.26,59.31 12.42,60.15 12.42,64.87 15.88,68.33 15.88,69.34 16.33,69.8 20.88,69.8 21.56,69.11 22.45,69.11 22.61,68.96 22.61,68.58 22.48,68.45 21.11,68.45 20.57,67.92 20.57,67.06 19.94,66.42 19.94,63.37 19.05,62.48 19.05,52.22 18.49,51.66 14.05,51.66 13.23,52.48 9.6,52.48
VCC12 on TOP: 14.43,102.24 14.43,100.91 14.63,100.71 15.52,100.71 15.75,100.48 15.75,99.49 15.6,99.34 13.16,99.34 12.95,99.14 12.95,97.71 13.13,97.54 15.65,97.54 15.8,97.38 15.8,96.52 15.57,96.29 14.68,96.29 14.43,96.04 14.43,94.72 14.07,94.36 10.59,94.36 10.21,94.74 10.21,96.98 11.61,98.37 11.61,102.18 11.91,102.49 14.17,102.49
VCC12 on TOP: 51.05,144.88 51.05,144.68 50.95,144.57 50.16,144.57 49.95,144.78 48.9,144.78 48.77,144.91 48.77,145.16 49.02,145.41 50.52,145.41
VCC12 on TOP: 52.2,145.16 52.25,145.21 52.25,147.8 51.89,148.16 46.96,148.16 46.74,147.93 46.74,146.61 47.68,145.67 49.35,145.67 49.36,145.67 50.52,145.67 50.8,145.39 50.8,145.39 51.03,145.16
VCC12 on TOP: 132.51,35.83 132.51,33.1 132.66,32.94 138.18,32.94 138.66,33.43 138.66,36.37 138.53,36.5 137.55,36.5 137.32,36.27 137.32,35.52 137.1,35.3 134.44,35.3 133.9,35.84 132.52,35.84
VCC12 on TOP: 79.45,152.27 84.2,152.27 85.72,150.75 85.72,149.73 85.34,149.35 84.45,149.35 84.12,149.02 84.12,148.01 83.92,147.8 82.98,147.8 82.8,147.98 82.8,150.72 82.73,150.8 81.2,150.8 80.98,150.57 80.98,148.03 80.85,147.9 79.86,147.9 79.65,148.11 79.65,149.22 79.53,149.35 78.41,149.35 78.19,149.57 78.19,151.02
VCC12 on BOTTOM: 14,103.5 14.73,103.5 15.11,103.12 15.11,93.9 14.94,93.73 13.26,93.73 13.06,93.93 13.06,96.27 12.45,96.88 11.13,96.88 10.83,97.17 10.83,97.47 11.61,98.25 11.61,103.91 11.86,104.17 13.34,104.17
VCC12 on BOTTOM: 15.24,52.45 15.37,52.32 15.37,49.66 15.24,49.53 13.23,49.53 12.98,49.78 12.98,52.25 13.18,52.45
VCC12 on BOTTOM: 113.54,175.77 115.95,175.77 116.2,175.51 116.2,173.23 115.95,172.97 113.54,172.97 113.28,173.23 113.28,175.51
VCC12 on BOTTOM: 84.72,147.89 84.15,147.32 81.15,147.32 81,147.47 81,147.93 80.72,148.21 77.67,148.21 77.37,147.9 77.37,145.9 76.99,145.52 75.92,145.52 75.54,145.9 75.54,149.68 76.8,150.94 78.19,150.94 79.53,152.27 84.28,152.27 84.72,151.83
VCC12 on L4_PWR: 122.43,33.78 122.43,62.63 124.33,64.54 124.33,85.37 125.98,87.02 125.98,107.84 136.4,118.26 136.4,147.81 135.11,149.1 126.26,149.1 121.18,144.02 94.72,144.02 94.09,144.65 92.53,144.65 92.41,144.78 91.9,144.78 91.77,144.65 77.7,144.65 74.02,148.34 52.85,148.34 51.18,146.66 51.18,125.71 49.02,123.55 49.02,105.26 48.79,105.03 32.91,105.03 32.13,104.25 32.13,90.28 31.77,89.92 22.88,89.92 21.59,88.62 21.59,79.86 19.18,77.45 19.18,43.92 17.93,42.67 10.44,42.67 9.14,41.38 9.14,34.22 2.79,34.22 2.79,97.7 9.8,97.7 11.05,98.21 11.56,99.46 11.56,113.31 11.05,114.56 9.8,115.07 7.46,115.07 7.46,172.65 9.26,172.65 9.26,175.25 11.56,175.25 11.56,176.95 128.14,176.95 128.14,171.81 118.62,162.28 118.62,155.85 119.66,154.81 131.68,154.81 132.46,155.6 132.46,158.14 135.61,161.29 146.33,161.29 151.26,156.36 151.26,118.09 144.17,111 140.74,111 137.92,108.18 137.92,63.22 137.29,62.59 137.29,50.69 139.06,48.92 139.06,35.41 137.44,33.78
VCCA0V75 on TOP: 109.47,48.89 110.01,48.36 110.01,47.47 110.34,47.14 112.06,47.14 112.5,47.57 114.48,47.57 114.71,47.8 120.19,47.8 120.73,47.27 126.59,47.27 126.8,47.07 126.8,44.68 126.14,44.02 115.62,44.02 115.06,44.58 108.97,44.58 108.58,44.96 108.58,45.34 108.6,45.35 108.6,46.11 108.28,46.43 106.58,46.43 106.53,46.48 106.53,46.71 106.58,46.76 107.52,46.76 107.52,46.77 107.59,46.77 107.69,46.87 107.69,47.36 107.61,47.45 106.58,47.45 106.53,47.5 106.53,54.61 107.01,55.1 108.9,55.1 109.22,54.78 109.22,51.56 109.47,51.31
VCCA0V75 on BOTTOM: 124.94,47.12 126.75,47.12 126.9,46.96 126.9,45.64 126.64,45.39 125.02,45.39 124.87,45.54 124.87,47.04
VCCB0V75 on BOTTOM: 41.27,35.56 42.42,34.42 43.18,34.42 43.43,34.16 43.43,33.27 43.18,33.02 42.39,33.02 41.27,31.9 40.23,31.9 39.55,32.59 39.55,34.54 38.99,35.1 38.99,38.35 39.37,38.73 41.02,38.73 41.27,38.48
VCCB0V75 on L5: 99.95,49.28 105.92,43.31 105.92,36.32 105.28,35.69 104.52,35.69 102.62,33.78 100.08,33.78 99.31,34.54 99.31,40.01 98.6,40.72 97.03,40.72 96.47,41.27 51.69,41.27 50.04,42.93 43.05,42.93 42.29,42.16 42.29,34.92 41.88,34.52 38.38,34.52 37.34,35.56 37.34,43.18 41.91,47.75 49.07,47.75 50.6,49.28
VCCPLLA2A on TOP: 73.51,131.27 73.51,132.72 73.79,132.99 73.79,134.87 73.66,135 72.64,135 72.52,134.87 72.52,134.62 72.11,134.21 72.11,131.04 72.16,130.99 73.23,130.99
VCCPLLA2B on TOP: 70.27,133.44 70.08,133.25 70.08,130.61 69.16,129.69 69.16,128.27 69.14,128.24 68.43,128.24 68.36,128.31 68.36,130.44 68.78,130.86 68.78,134.26 69.39,134.87 70.56,134.87 70.59,134.85 71.02,134.85 71.25,134.62 71.25,133.86 70.83,133.44
VCCPLLA3A on BOTTOM: 82.63,121.87 84.12,121.87 84.15,121.84 84.79,121.84 85.01,121.62 85.01,119.74 84.89,119.61 84.66,119.61 84.58,119.68 84.58,120.02 84.61,120.04 84.61,120.45 84.45,120.6 83.87,120.6 83.59,120.88 82.55,120.88 82.4,121.03 82.4,121.64
VCCPLLA3A on L3: 90.93,115.01 89.15,115.01 88.75,114.61 85.78,114.61 85.69,114.71 84.73,114.71 84.61,114.58 84.38,114.58 84.26,114.69 84.26,119.98 83.72,120.52 83.72,121.77 84.38,122.43 90.93,122.43 91.53,121.83 91.53,115.61
VCCPLLA3B on TOP: 83.95,108.59 86.94,108.59 87.3,108.94 87.3,109.19 87.81,109.7 88.54,109.7 88.71,109.54 88.7,109.52 88.7,108.2 87.43,106.93 84.28,106.93 83.69,107.52 83.69,108.33
VDD33 on TOP: 28.22,96.57 34.92,96.57 35.31,96.19 35.31,92.68 35.05,92.43 28.7,92.43 28.69,92.44 28.08,92.44 27.94,92.58 27.94,96.29
VDD33 on BOTTOM: 27.97,92.35 28.27,92.05 33.15,92.05 33.81,92.71 35.92,92.71 36.3,93.09 36.3,95.17 34.8,96.67 28.22,96.67 27.97,96.42
VDD33 on L8: 70.59,99.06 70.59,93.85 70.84,93.6 72.16,93.6 72.33,93.43 72.33,91.53 72.16,91.36 65.79,91.36 65.41,91.74 65.41,94.08 65.01,94.48 61.68,94.48 59.61,92.41 59.61,90.78 59.21,90.37 49.43,90.37 48.87,90.93 48.87,95.81 52.5,99.44 70.21,99.44
VDD33 on L10: 45.69,97.23 49.28,93.65 50.75,93.65 50.95,93.45 50.95,91.44 50.75,91.24 47.57,91.24 46.38,92.43 44.53,92.43 41.38,95.58 37.72,95.58 35.79,93.65 32.89,93.65 31.57,92.33 27.84,92.33 27.71,92.46 27.71,96.98 27.97,97.23
VDDPLL0 on BOTTOM: 78.87,92.18 79.73,92.18 80.54,91.36 80.54,86.08 81.46,85.17 81.46,83.11 80.11,81.76 79.76,81.76 79.58,81.94 79.58,83.44 79.81,83.67 80.49,83.67 80.85,84.02 80.85,84.96 80.26,85.55 80.01,85.55 79.86,85.7 79.86,87.45 78.79,88.52 78.79,92.1
VDDPLL1 on BOTTOM: 68.07,75.41 68.07,74.22 67.77,73.91 67.77,73.63 67.89,73.51 68.43,73.51 68.55,73.63 70.03,73.63 70.21,73.81 70.21,74.63 69.93,74.9 69.14,74.9 68.86,75.18 68.86,75.44 68.66,75.64 68.3,75.64
VDDPLL1 on BOTTOM: 40.51,76.12 38.61,76.12 38.42,75.92 38.42,74.69 38.26,74.53 38.26,73.97 38.56,73.67 40.56,73.67 40.94,74.05 40.94,75.69
VDDPLL1 on L3: 72,74.88 72.9,74.88 73.56,74.22 73.56,73.66 73.2,73.3 67.99,73.3 66.03,75.26 65.18,75.26 63.91,76.53 47.04,76.53 44.07,73.56 40.31,73.56 39.75,74.12 39.75,75.89 39.98,76.12 41.5,76.12 42.57,77.19 44.23,77.19 48.75,81.71 68.56,81.71 70.54,79.73 70.54,76.33
(no net) on TOP: 149.35,76.7 149.99,77.34 149.99,78.61 150.24,78.86 151.89,78.86 152.27,78.48 152.27,77.41 151.19,76.33 151.19,70.17 149.48,68.45 140.84,68.45 138.18,71.12 138.18,72.64 138.56,73.03 138.94,73.03 141.6,70.36 147.83,70.36 149.35,71.88
(no net) on TOP: 149.35,101.09 150.11,101.85 150.11,103.12 150.24,103.25 152.15,103.25 152.27,103.12 152.27,102.24 151.51,101.47 151.51,95.25 149.38,93.12 141.07,93.12 138.3,95.88 138.3,97.03 138.56,97.28 139.32,97.28 141.94,94.67 142.16,94.67 142.21,94.62 147.78,94.62 149.35,96.19
(no net) on TOP: 147.32,77.84 147.96,77.21 149.35,77.21 149.73,77.59 149.73,78.98 149.74,78.99 149.74,80.01 148.59,81.15 147.7,81.15 147.32,80.77
(no net) on L5: 139.06,78.35 139.07,78.35 139.07,93.6 139.19,93.73 139.19,98.17 139.06,98.3 139.06,112.27 139.32,112.52 144.7,112.52 147.19,110.03 147.19,92.58 144.02,89.41 144.02,80.77 147.19,77.6 147.19,71.88 146.24,70.93 140.65,70.93 139.19,72.39 139.19,74.8 139.06,74.93
(no net) on L5: 148.08,94.49 148.72,93.85 151.76,93.85 152.53,94.62 152.53,102.87 152.15,103.25 148.84,103.25 148.08,102.49
5482S_RJ451_VCC on TOP: 156.08,76.45 156.59,76.96 162.81,76.96 163.7,77.85 165.35,77.85 165.58,78.08 165.58,80.54 165.35,80.77 163.45,80.77 162.31,79.63 154.31,79.63 154.05,79.38 154.05,75.95 154.05,75.77 154.38,75.44 155.83,75.44 156.08,75.69
5482S_RJ452_VCC on TOP: 162.69,90.68 163.96,91.95 164.97,91.95 165.61,92.58 165.61,94.36 165.35,94.62 163.45,94.62 162.56,93.73 156.97,93.73 156.46,94.23 154.18,94.23 153.92,93.98 153.92,90.93 154.18,90.68
CVDD on TOP: 110.74,42.44 110.74,32.38 111.12,32 115.6,32 115.6,32.03 115.98,32.41 117.88,32.41 118.11,32.64 118.11,38.73 116.61,40.23 116.61,42.49 116.05,43.05 111.35,43.05
CVDD on TOP: 69.85,137.59 68.95,136.69 66.05,136.69 65.58,137.16 65.58,140.56 65.98,140.95 65.98,149.57 66.6,150.19 71.35,150.19 71.5,150.04 71.5,142.42 71.5,142.29 71.39,142.17 70.8,142.17 69.85,141.22
CVDD on BOTTOM: 74.96,79.2 75.23,79.2 75.79,78.64 76.4,78.64 77.55,79.78 78.66,79.78 79.38,79.07 79.38,78.54 79.15,78.31 78.11,78.31 78,78.21 78,77.5 78.33,77.17 78.33,77.01 78.16,76.84 77.44,76.84 76.71,76.1 76.53,76.1 76.12,75.69 75.92,75.69 75.36,76.25 74.65,76.25 74.09,75.69 73.71,75.69 73.2,76.2 73.2,77.62 73.53,77.95 73.71,77.95
CVDD on BOTTOM: 65.89,150.85 71.15,150.85 72.52,149.48 72.52,147.88 72.01,147.37 72.01,140.72 72.9,139.83 72.9,137.41 72.64,137.16 70.99,137.16 70.61,137.54 70.61,138.96 69.98,139.59 69.98,145.01 69.44,145.54 67.69,145.54 67.32,145.17 67.32,139.57 67.48,139.4 68.81,139.4 69.76,138.46 69.76,137.32 68.97,136.53 65.66,136.53 65.35,136.83 65.35,150.32
CVDD on BOTTOM: 111,42.47 111,32.13 111.38,31.75 114.25,31.75 114.27,31.78 114.6,31.78 115.37,32.54 115.37,36.22 116.81,37.67 116.81,42.91 115.04,44.68 114.52,44.68 114.36,44.51 114.36,42.99 114.29,42.91 111.44,42.91
CVDD on BOTTOM: 85.88,105.69 85.72,105.54 83.95,105.54 83.78,105.7 83.78,110.12 84.02,110.36 84.02,112.5 84.99,113.46 91.16,113.46 91.16,113.46 92.4,114.69 94.66,114.69 94.75,114.61 94.75,113.8 94.52,113.57 93.27,113.57 91.85,112.14 86.49,112.14 85.88,111.53
CVDD on L4_PWR: 110.24,33.78 110.24,47.22 106.79,50.67 89.89,50.67 76.2,64.37 76.2,69.85 74.68,71.37 69.6,71.37 67.31,73.66 62.36,73.66 62.1,73.91 62.1,75.06 64.01,76.96 64.01,79.25 63.37,79.88 51.82,79.88 49.53,82.17 49.53,123.34 51.69,125.5 51.69,146.45 53.06,147.83 73.81,147.83 77.49,144.15 93.87,144.15 94.51,143.51 100.84,143.51 100.84,119.49 84.33,102.98 84.33,97.9 80.26,93.83 80.26,82.52 83.54,79.25 92.86,79.25 96.67,75.44 100.1,75.44 101.73,73.81 101.73,66.19 105.43,62.48 121.92,62.48 121.92,33.78 ; 2 cut-outs
CVDD on L8: 82.17,78.23 84.58,75.82 84.58,74.93 85.22,74.3 85.22,71.63 84.58,70.99 81.79,70.99 78.36,74.42 64.77,74.42 64.39,74.8 64.39,77.72 64.9,78.23
CVDD1 on TOP: 79.21,128.17 79.21,132.77 78.68,133.3 76.86,133.3 76.4,133.76 76.4,136.98 76.78,137.36 81.58,137.36 81.92,137.03 81.92,128.52 81.15,127.76 79.62,127.76
CVDD1 on TOP: 83.41,114.33 82.79,113.7 81.43,113.7 81.27,113.54 81.27,112.4 81.39,112.27 83.29,112.27 83.86,112.85 84.53,112.85 85.28,113.6 85.28,114.36 85.19,114.45 84.73,114.45 84.61,114.33
CVDD1 on BOTTOM: 82.93,137.03 83.44,136.53 83.44,134.11 81.92,132.59 81.92,128.93 81.28,128.3 80.44,128.3 80.14,128.6 79.68,128.6 79.25,129.03 79.25,135.21 80.03,135.99 80.52,135.99 81.57,137.03
CVDD1 on L3: 83.26,120.09 82.8,120.55 82.8,129.77 81.25,131.32 79.48,131.32 77.8,129.64 77.8,120.19 78.74,119.25 78.74,111.91 80.18,110.48 81.62,110.48 81.69,110.54 83.92,110.54 85.24,111.86 85.24,114.38 85.17,114.45 84.76,114.45 84.61,114.3 82.7,114.3 82.5,114.5 82.5,115.85 83.26,116.61
CVDD1 on L5: 87.91,111.86 90.59,111.86 92.67,109.78 92.67,102.63 91.06,101.02 91.06,91.47 90.53,90.93 90.53,81.71 90.27,81.46 68.78,81.46 68.33,81.91 68.33,84.66 73.32,89.65 73.32,94.78 76.33,97.79 78.33,97.79 83.5,102.96 83.5,107.45
CVDD1 on L8: 85.27,114.07 85.27,112.17 85.28,112.15 85.28,109.92 85.88,109.32 89.05,109.32 89.59,109.85 89.59,110.34 89.76,110.52 92.02,110.52 92.25,110.29 92.25,107.04 91.8,106.58 84.66,106.58 83.29,107.95 79.38,107.95 77.7,106.27 75.23,106.27 74.8,106.71 74.8,106.98 75.69,107.87 76.71,107.87 78.83,109.99 80.63,109.99 80.7,109.93 81.1,109.93 82.7,111.53 82.7,112.22 83.1,112.61 83.12,112.61 83.46,112.95 83.46,113.79 83.74,114.07 84.63,114.07 84.81,114.25 85.09,114.25
CVDD1T on TOP: 89.28,128.07 88.87,127.66 86.08,127.66 85.6,128.14 85.6,132.46 85.09,132.97 83.82,132.97 83.31,133.48 83.31,136.53 83.95,137.16 88.65,137.16 89.28,136.53
CVDD1T on BOTTOM: 50.29,79.63 51.1,79.63 51.31,79.43 51.31,78.26 47.69,74.64 46.32,74.64 46.2,74.75 46.2,76.76 46.43,76.99 47.65,76.99
CVDD1T on BOTTOM: 86.11,137.29 89.41,137.29 89.79,136.91 89.79,128.14 89.28,127.63 86.36,127.63 85.72,128.27 85.72,136.91
CVDD1T on L3: 91.06,110.13 91.06,112.9 92.01,113.86 92.01,121.98 91.19,122.81 88.82,122.81 87.17,124.46 87.17,126.54 85.88,127.84 85.88,129.11 86.59,129.82 91.92,129.82 96.27,125.48 96.27,108.74 91.34,103.81 82.73,103.81 80.39,106.15 80.39,109.3 80.92,109.83 84.91,109.83 87.1,107.65 88.57,107.65
CVDD1T on L5: 63.37,79.12 63.75,78.74 64.39,78.74 64.64,78.99 64.64,79.25 64.77,79.38 66.78,79.38 68.68,81.28 79.91,81.28 80.64,80.54 80.64,75.16 79.78,74.3 52.32,74.3 49.53,77.09 49.53,79.25 49.78,79.5 53.34,79.5 54.23,78.61 62.23,78.61 62.74,79.12
CVDD1T on L8: 79.5,78.36 65,78.36 64.77,78.59 64.77,81.43 65.3,81.97 65.3,90.2 65.79,90.68 69.34,90.68 69.6,90.42 69.6,89.71 69.85,89.46 73.2,89.46 74.55,90.81 74.55,102.59 74.63,102.59 79.6,107.57 82.42,107.57 83.85,106.15 83.85,103.45 83.82,103.43 83.82,91.95 83.77,91.9 83.77,82.63
FARM0_AVGG1 on TOP: 58.03,141.92 58.37,141.58 58.98,141.58 59.08,141.48 59.08,140.76 58.94,140.62 56.28,140.62 55.86,141.04 55.86,141.92 55.93,141.98 56.21,141.98 56.28,141.92
FARM0_AVGG2 on TOP: 128.83,39.99 127.32,39.99 126.77,40.54 126.11,40.54 125.89,40.31 125.89,38.41 125.97,38.33 126.48,38.33 126.57,38.42 126.57,38.92 126.68,39.03 128.54,39.03 128.62,38.95 128.89,38.95 128.94,39.01 128.94,39.87
FARM0_SW_SHAPE1 on TOP: 56.34,145.06 56.24,145.16 56.24,147.8 57.86,149.43 62.84,149.43 63.66,148.62 63.66,144.19 63.41,143.94 59.99,143.94 58.88,145.06
FARM0_SW_SHAPE1 on BOTTOM: 59.94,141.48 58.33,141.48 58.15,141.3 58.15,140.94 58.32,140.76 60.48,140.76 60.5,140.78 61.41,140.78 61.77,141.15 61.77,143.39 63.36,144.98 63.36,149.61 62.56,150.41 58.32,150.41 57.84,149.94 57.84,146.36 58.14,146.06 59.67,146.06 60.15,145.58 60.15,141.69
FARM0_SW_SHAPE2 on TOP: 128.32,32.82 128.57,33.07 128.57,35.76 128.52,35.81 124.97,35.81 124.96,35.82 124.41,35.82 124.21,36.02 124.21,37.97 123.95,38.23 120.9,38.23 120.65,37.97 120.65,33.27 121.11,32.82
FARM0_SW_SHAPE2 on BOTTOM: 125.51,35.19 125.27,34.96 125.27,31.88 125.35,31.8 127.32,31.8 127.39,31.86 127.39,34.92 127.11,35.19
FARM0_SW_SHAPE2 on BOTTOM: 127.96,44.03 124.63,44.03 122.88,42.27 122.88,37.74 123.04,37.57 124.16,37.57 124.29,37.7 124.29,41.58 125.59,42.89 127.85,42.89 128.17,43.21 128.17,43.82
FARM0_VGG1 on BOTTOM: 58.09,144.73 58.09,143.18 57.89,142.98 57.48,142.98 57.2,142.7 57.2,142.16 57.05,142.01 56.01,142.01 55.6,142.42 55.6,145.03 55.61,145.05 55.61,145.16 55.87,145.41 57.4,145.41
FARM0_VGG2 on TOP: 124.76,36.96 124.56,37.16 124.56,38.98 124.76,39.17 125.54,39.17 125.63,39.09 125.63,38.25 125.76,38.13 127.09,38.13 127.33,37.88 127.33,37.11 127.18,36.96
FARM0_VGG2 on BOTTOM: 126.54,39.52 124.75,39.52 124.51,39.28 124.51,37.28 124.86,36.92 126.6,36.92 126.75,37.07 126.75,39.32
FARM1_SW_SHAPE1 on TOP: 28.17,72.52 28.57,72.11 28.57,67.77 28.04,67.23 24.71,67.23 24.31,67.64 21.26,67.64 21.08,67.82 21.08,68.07 21.21,68.2 25.07,68.2 25.93,69.06 25.93,72.29 26.16,72.52
FARM1_SW_SHAPE2 on TOP: 121.3,149.54 126.54,149.54 127.19,148.89 127.19,142.98 126.89,142.68 124.01,142.68 123.67,143.02 123.67,145.24 122.61,146.3 120.88,146.3 120.82,146.37 120.82,149.06
FARM1_VGG2 on BOTTOM: 121.13,142.34 121.13,143.28 120.04,144.37 120.04,145.52 120.22,145.69 122.53,145.69 122.91,145.31 122.91,144.3 122.78,144.17 122.02,144.17 121.95,144.09 121.95,142.32 121.87,142.24 121.23,142.24
SIM_VCC on TOP: 152.43,61.11 156.13,61.11 156.24,61.01 156.24,59.61 156.06,59.44 152.48,59.44 152.22,59.69 152.22,60.91
SW10-P1 on TOP: 164.72,44.45 164.97,44.2 166.88,44.2 167.18,43.89 167.18,42.11 167.37,41.92 167.77,41.92 167.89,42.05 167.89,45.59 167.51,45.97 164.97,45.97 164.72,45.72
USB0V85 on BOTTOM: 35.99,99.44 32,99.44 31.75,99.19 31.75,97.66 32,97.41 34.92,97.41 35.81,96.52 39.04,96.52 39.29,96.77 39.29,97.97 39.09,98.17 37.26,98.17
USB0V85 on L5: 49.35,92.28 48.79,92.84 48.79,97.05 49.33,97.59 72.26,97.59 72.57,97.28 72.57,93.12 71.73,92.28
USB0V85 on L10: 37.69,97.64 37.44,97.89 37.44,98.98 37.69,99.24 46.79,99.24 50.43,95.6 50.43,94.21 50.22,94.01 49.43,94.01 45.8,97.64
USBVDD3V3 on BOTTOM: 34.29,90.55 34.16,90.68 34.16,91.57 34.29,91.69 38.1,91.69 38.44,91.35 38.44,89.05 38.09,88.7 37.09,88.7 36.79,89 36.79,89.95 36.2,90.55
USBVDD3V3 on L3: 43.94,88.16 50.19,88.16 50.37,87.99 50.37,86.72 50.16,86.51 43.38,86.51 41.5,88.39 37.39,88.39 37.03,88.75 37.03,89.94 37.31,90.22 41.88,90.22
USBVDD3V3 on L5: 72.11,91.74 72.62,91.24 72.62,89.59 69.65,86.61 67.06,86.61 66.8,86.87 52.45,86.87 52.07,86.49 49.91,86.49 49.4,87 49.4,91.14 50.01,91.74
VPP1V8 on TOP: 106.55,166.12 106.81,165.86 107.19,165.86 107.37,165.68 107.37,164.54 107.29,164.47 106.25,164.47 106.15,164.36 104.65,164.36 104.41,164.6 104.41,165.9 105.23,166.73 105.23,167.56 105.56,167.89 106.3,167.89 106.55,167.64
VPP1V8 on L10: 81.58,80.54 84.33,80.54 84.53,80.34 84.53,76.21 86.22,74.52 90.58,74.52 94.23,70.87 94.23,64.67 95.67,63.23 95.67,58.17 95.11,57.61 95.11,57.58 94.79,57.26 94.79,53.75 94.44,53.39 93.8,53.39 93.17,54.03 93.17,58.14 93.55,58.52 93.55,61.16 91.31,63.4 91.31,70.18 89.15,72.34 84.1,72.34 80.49,75.95 80.49,78.13 81.41,79.04 81.41,80.37
N863951 on TOP: 170.8,104.13 170.85,104.78 170.15,106 168.78,106.3 168.69,106.32 168.66,106.4 168.66,108.89 168.26,109.28 165.47,109.28 164.81,109.95 164.81,112.93 166.28,114.4 166.28,115.53 164.67,117.14 162.38,117.14 162.18,117.33 162.18,119.25 162.81,119.89 171.45,119.89 172.47,118.87 172.47,104.01 171.83,103.38 170.59,103.38 170.5,103.43 170.51,103.54
N863951 on BOTTOM: 165.1,119.89 171.07,119.89 172.21,118.75 172.21,104.39 171.2,103.38 164.85,103.38 164.34,103.89 164.34,104.59 164.59,104.84 165.87,104.84 168.42,107.39 168.42,115.21 167.37,116.26 165.73,116.26 164.34,117.66 164.34,119.13
N13254570 on TOP: 116.2,127.38 118.39,127.38 118.85,127.84 120.19,127.84 120.29,127.74 120.29,127.28 120.17,127.15 118.77,127.15 118.57,126.95 116.2,126.95 116.13,127.03 116.13,127.3
