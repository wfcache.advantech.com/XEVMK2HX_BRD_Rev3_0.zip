# Allegro board 19C2830503-01-JOB.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CLK3_REF_SEL: length 16.4
  TOP w0.127: R277.2 96.04,117.6 97.22,116.42 v1(97.23,116.42)
  L5 w0.114: v1(100.03,127.36) 100.03,123.4 97.28,120.65 97.28,116.56 97.23,116.5 v1(97.23,116.42)
  BOTTOM w0.127: U53.25 100.76,126.63 v1(100.03,127.36)
CLK3_SYNC: length 3.1
  TOP w0.127: R300.2 89.48,112.97 89.03,113.42 89.03,114.05 88.62,114.45 U19.42
CLK_RSTZ: length 132.1
  TOP w0.127: v1(48.18,123.3) 48.18,125.47 47.92,125.73 47.92,126.18 48.13,126.4 48.13,126.69 48.02,126.8 48.02,128.58 48.27,128.84 48.27,129.14 48.78,129.64 48.78,129.85 48.94,130.01 U14.44 ; U15.44 v1(66,130.37) ; v1(91.21,112.01) 90.64,112.59 90.64,113.08 90.04,113.68 90.04,113.98 89.62,114.39 U19.44
  L5 w0.114: v1(96.34,128.98) 95.95,128.59 95.95,127.76 96.24,127.47 96.24,123.77 95.73,123.27 95.73,120.82 95.63,120.72 95.63,117.39 91.21,112.97 v1(91.21,112.01)
  L8 w0.114: v1(66,130.37) 66,131.14 68.67,133.81 74.65,133.81 76.71,131.75 81.69,131.75 83.09,130.35 89.97,130.35 91.8,128.52 92.46,128.52 92.89,128.1 94.93,128.1 95.81,128.98 v1(96.34,128.98)
  L10 w0.114: v1(96.34,128.98) 91.07,128.98 90.05,130 82.76,130 82.69,130.08 79.62,130.08 79.14,129.6 78.31,129.6 77.57,130.33 76.2,130.33 73.28,133.25 67.3,133.25 67.03,133.51 60.78,133.51 57.89,136.4 51.87,136.4 50.37,134.9 50.37,126.93 49.76,126.33 49.76,125.58 48.21,124.03 48.21,123.3 v1(48.18,123.3)
  BOTTOM w0.127: U53.7 95.51,128.58 95.91,128.98 v1(96.34,128.98)
COREPLLOBSCLKN: length 2.5
  TOP w0.102: v2(59.94,98.9) 60.42,98.42 U24.AM4
  BOTTOM w0.102: v2(59.94,98.9) 59.93,98.9 59.51,99.32 TP64.1
COREPLLOBSCLKP: length 3.5
  TOP w0.102: v2(59.99,96.89) 59.94,96.95 59.94,98 U24.AN4
  BOTTOM w0.102: v2(59.99,96.89) 59.33,97.56 TP65.1
CVDD: length 252.7
  TOP w0.381: U24.W26 v2(74.02,76.92) U24.V25 ; U24.N10 U24.P9 v2(78.02,93.92) U24.R8 ; U24.P25 U24.R24 v2(77.02,78.92) U24.T23 ; U24.P25 78.41,77.42 v2(78.05,77.06) 77.52,76.53 U24.R26 v2(77.02,76.92) U24.T25 v2(76.02,77.92) U24.U24 v2(75.02,78.92) U24.V23 ; U24.P25 U24.N26 v2(80.02,75.92) U24.M27 v2(81.02,74.92) U24.L28 v2(82.02,73.92) U24.K29 82.53,73.42 v2(83.06,72.9) 83.52,72.44 U24.J30 v2(84.02,71.92) U24.H31 85.02,71.92 v2(85.02,71.92) ; v2(71.93,87.91) 71.93,87.83 72.34,87.42 U24.Y15 ; U24.AC14 v2(69.02,88.92) U24.AD13 v2(68.02,89.92) U24.AE12 67.44,90.42 67.06,90.81 67.06,90.94 v2(66.96,91.03) ; U24.N14 U24.P13 ; U24.P13 U24.N12 ; U24.P13 U24.R12 v2(77.02,90.92) U24.T11 v2(76.02,91.92) U24.U10 U24.V9 v2(74.02,93.92) U24.W8 U24.Y9 ; U24.N22 v2(79.02,80.92) U24.P21 77.98,81.96 v2(77.98,81.97) 77.95,81.99 77.95,81.99 U24.R20 U24.T19 v2(76.02,83.92) U24.U18 ; U24.V25 v2(74.02,77.92) U24.W24 ; U24.V25 U24.U26 ; U24.V19 v2(74.02,83.92) U24.W18 U24.Y17 v2(72.02,85.92) U24.AA16 U24.AB15 ; U24.Y27 72.35,75.42 71.88,75.9 v2(71.88,75.92) 71.88,76.06 U24.AA26 U24.AB25 U24.AC24 69.52,78.48 69.28,78.72 69.28,78.79 69.09,78.97 v2(69.03,78.97) 68.79,79.21 68.79,79.21 68.58,79.42 U24.AD23 v2(68.02,79.92) U24.AE22 ; U24.AG8 v2(66.02,93.92) U24.AF9 U24.AE10 67.99,91.95 v2(68.02,91.92) ; U24.AG28 65.27,74.42 v2(64.77,74.92) 64.77,75.17 U24.AH27 64.52,75.42 U24.AJ28 ; U24.M25 80.52,77.47 v2(80.01,77.98) ; U24.AM5 60.52,97.32 v2(60.96,96.88) 61.41,96.42 U24.AL6 v2(62.02,95.92) U24.AK7 U24.AJ8 v2(64.02,93.92) U24.AH9 v2(65.02,92.92) U24.AG10 ; U24.L6 81,96.94 v2(81,97.05) ; U24.U12 v2(76.02,89.92) ; U24.N18 U24.P17 77.72,86.22 U24.R16 v2(77.02,86.92) U24.T15 ; U24.N6 79.69,96.25 79.7,96.25 79.98,95.97 v2(79.98,95.93) 79.99,95.93 80.5,95.42 U24.M7 ; U24.AE14 v2(68.02,87.92) U24.AD15 v2(69.02,86.92) U24.AC16 69.58,86.42 70.05,85.95 v2(70.06,85.95) 70.08,85.95 70.08,85.91 70.52,85.47 U24.AB17 v2(71.02,84.92) U24.AA18 v2(72.02,83.92) U24.Y19 v2(73.02,82.92) U24.W20 ; U24.AM31 61.52,72.42 U24.AL30 62.52,73.42 U24.AK29 62.55,73.42 v2(62.99,73.86) ; 72.01,81.93 v2(72.14,81.93) ; 72.01,81.93 U24.AA20 v2(71.02,82.92) U24.AB19 ; 72.01,81.93 U24.Y21 ; U24.P15 78.52,87.29 v2(78.99,86.82) 79.39,86.42 U24.N16 ; v2(69.98,93.98) 70.52,93.44 U24.AB9 U24.AA10 ; v2(67.94,77.98) 67.94,78 ; 67.94,78 U24.AD25 U24.AC26 U24.AB27 ; 67.94,78 U24.AE24 ; U24.AE16 67.9,86.81 67.9,87.02 v2(67.91,87.02) ; v2(77.02,88.92) U24.R14 ; U24.AC8 v2(69.02,94.92) ; U24.P7 U24.N8 v2(80.02,93.92) U24.M9 ; U24.P23 v2(79.02,78.92) U24.N24 ; U24.W14 v2(74.02,87.92) U24.V15 ; v1(54.13,138.79) 53.98,138.63 R145.1 ; U24.W12 v2(74.02,89.92) ; U24.AE18 v2(68.02,83.92) ; v2(64.08,92.04) 63.9,92.04 U24.AJ10 U24.AK9 v2(62.02,93.92) U24.AL8 ; U24.Y23 v2(72.02,79.92) U24.AA22 v2(71.02,80.92) U24.AB21 U24.AC20 68.98,82.96 v2(68.98,82.96) ; v2(70.02,89.92) U24.AC12 ; U24.AF25 v2(67.02,76.92) U24.AE26 v2(68.02,75.92) U24.AD27 ; v2(71.12,94.82) U24.AA8 ; U24.T27 v2(76.02,75.92) ; U24.W10 74.04,91.9 v2(74.17,91.9) ; v2(66.98,74.96) U24.AF27 ; U24.P19 U24.R18 77.09,84.85 v2(77.09,84.96) 76.63,85.42 U24.T17 ; U24.AB11 v2(70.02,91.92) U24.AC10 U24.AD9 v2(68.02,93.92) U24.AE8 ; U24.AE20 67.6,82.42 v2(67.95,82.07) 68.52,81.5 U24.AD21 v2(69.02,80.92) U24.AC22 U24.AB23 v2(71.02,78.92) U24.AA24 71.52,78.34 v2(71.88,77.98) 72.44,77.42 U24.Y25 ; U24.P27 78.49,75.45 78.49,75.64 v2(78.18,75.95) ; U24.R10 U24.T9 v2(76.02,93.92) U24.U8 ; U24.V27 v2(74.02,75.92)
  BOTTOM w0.254: C434.2 54.04,138.87 v1(54.13,138.79) 54.74,138.79 55.4,139.45 59.08,139.45 59.95,140.32 62.04,140.32 62.46,140.74 62.46,143.08 62.89,143.51 65.71,143.51
  BOTTOM w0.381: v2(81.02,74.92) 80.57,74.48 C689.1 ; v2(72.02,83.92) 71.54,84.4 C609.1 ; C658.1 70.07,78.3 69.18,77.41 C659.1 68.7,77.41 68.22,76.93 v2(68.2,76.93) ; C608.1 67.56,84.38 v2(68.02,83.92) 68.49,84.4 C611.1 ; C606.1 72.55,85.39 v2(72.02,85.92) 72.42,86.33 C680.1 ; C539.1 62.67,95.27 v2(62.02,95.92) 62.36,96.27 C526.1 ; v2(71.88,75.92) 72.34,75.47 C677.1 ; v2(85.02,71.92) 85.49,72.4 86.22,72.4 86.26,72.36 C701.1 ; C684.1 75.51,83.41 v2(76.02,83.92) 76.56,83.38 C615.1 ; v1(96.28,68.67) 96.6,68.35 R741.2 ; C542.1 C550.1 82.61,97.6 82.5,97.71 82.5,98.67 82.54,98.71 82.54,98.76 C552.1 82.58,99.09 83.44,99.95 v2(83.96,99.95) 84.45,100.44 85.2,100.44 85.46,100.18 C562.1 85.41,98.93 84.48,98 C698.1 ; C586.1 68.43,88.33 v2(68.02,87.92) 67.53,87.43 C587.1 ; v2(60.96,96.88) 61.38,96.45 C527.1 ; v2(78.02,93.92) 77.85,94.09 C540.1 ; C622.1 73.36,82.58 v2(73.02,82.92) ; C575.1 68.53,89.41 v2(68.02,89.92) 67.48,89.38 C563.1 ; R755.1 130.75,45.28 129.92,46.1 128.46,46.1 C749.2 127.01,44.65 122.63,44.65 121.11,43.13 116.41,43.13 ; C540.1 C541.1 ; C540.1 77.11,94.8 C556.1 ; v2(83.06,72.9) 83.59,73.43 84.76,73.43 84.78,73.41 C700.1 ; v2(68.98,82.96) 68.51,82.49 C697.1 ; C585.1 69.53,91.43 v2(70.02,91.92) ; C679.1 74.52,86.46 73.84,87.15 73.84,87.74 v2(74.02,87.92) 73.85,88.09 C683.1 ; v2(72.14,81.93) 71.65,82.42 C619.1 ; C673.1 80.02,76.01 v2(80.02,75.92) ; C546.1 77.75,98.46 77.76,98.44 79.46,98.44 C547.1 79.72,98.48 79.75,98.45 79.8,98.4 80.14,98.4 80.51,98.03 80.51,97.54 v2(81,97.05) ; v2(80.01,77.98) 80.01,78.11 80.4,78.49 C645.1 ; C633.1 70.74,80.65 v2(71.02,80.92) ; v2(76.02,89.92) 75.56,89.47 C571.1 ; C623.1 70.43,82.33 v2(71.02,82.92) ; C533.1 67.51,95.15 67.5,95.14 67.5,94.44 v2(68.02,93.92) ; C600.1 70.45,85.55 70.06,85.95 v2(70.06,85.95) ; C647.1 68.62,79.32 68.97,78.97 v2(69.03,78.97) ; C648.1 71.16,79.07 v2(71.02,78.92) 70.72,79.22 70.57,79.38 C641.1 ; R614.2 71.37,106.65 71.45,106.58 v3(71.42,106.58) ; C559.1 73.99,89.92 v2(74.02,89.92) 73.43,89.33 C682.1 ; v2(67.91,87.02) 68.28,86.65 C597.1 ; C635.1 71.58,80.36 71.72,80.22 v2(72.02,79.92) ; C545.1 79.37,96.5 C555.1 79.56,96.5 79.98,96.09 v2(79.98,95.93) 80.32,96.27 C549.1 C548.1 ; v2(77.09,84.96) 76.66,85.39 C603.1
  BOTTOM w0.406: C657.1 71.5,77.57 71.88,77.95 v2(71.88,77.98) ; v2(67.02,76.92) 66.53,77.41 C661.1 66.19,77.41 66.12,77.48 65.68,77.48 65.61,77.41 C662.1 ; C520.1 71.42,85.33 v2(71.02,84.92) ; v2(71.93,87.91) 71.58,88.26 C681.1 ; v2(67.95,82.07) 67.93,82.07 C617.1 ; v2(68.02,79.92) 67.51,80.43 C634.1 ; C660.1 67.94,77.67 v2(67.94,77.98) 67.94,78 67.51,78.43 67.51,78.46 C649.1
  vias: v3(65.91,139.83) v3(65.93,138.89) v3(65.93,138) v3(65.92,137.19) v3(66.32,148.42) v3(66.29,147.45) v3(66.29,146.43) v3(66.29,145.41) v3(66.42,144.27) v3(66.47,149.48) v3(66.93,139.83) v3(67.44,149.63) v3(68.33,149.48) v3(69.42,137.69) v3(69.98,149.22) v3(70.23,149.99) v3(84.07,105.87) v3(84.86,105.87) v3(85.6,105.88) v3(112.65,38.86) v3(112.7,41.22) v3(112.7,39.98) v3(112.78,37.21) v3(112.78,36.2) v3(113.54,38.86) v3(113.63,41.25) v3(113.63,40.01) v3(113.67,37.21) v3(113.67,36.2) v3(114.43,38.86) v3(114.55,41.25) v3(114.55,40.01) v3(114.55,37.21) v3(114.63,36.32)
CVDD1: length 41.8
  TOP w0.381: v2(80.01,79.93) 80.52,79.43 U24.M23 ; v2(65.94,78.03) 65.54,78.42 U24.AG24 ; U24.V21 v2(75.02,81.92) U24.U20 v2(76.02,81.92) U24.T21 ; U24.U16 v2(75.02,85.92) 74.52,85.42 U24.V17 v2(74.02,85.92) U24.W16 ; v2(74.12,91.01) 74.52,91.41 U24.V11 ; U24.AD19 U24.AC18 v2(69.02,84.92) U24.AD17 ; v2(68.94,91.01) 68.52,91.42 U24.AD11 ; U24.V13 v2(75.02,88.92) U24.U14 75.52,88.42 v2(76.02,88.92) U24.T13
  L10 w0.305: v2(80.01,79.93) 79.54,80.41 76.85,80.41 76.53,80.72 76.53,81.41 v2(76.02,81.92)
  L10 w0.381: v2(75.02,81.92) 74.54,81.44 72.8,81.44 71.76,80.4 68.8,80.4 68.76,80.44 66.8,80.44 66.5,80.14 66.5,78.59 v2(65.94,78.03) ; v2(68.94,91.01) 72.29,91.01 72.76,91.48 73.65,91.48 v2(74.12,91.01)
  BOTTOM w0.381: C610.1 69.54,84.4 v2(69.02,84.92) ; v2(76.02,88.92) 75.95,88.85 C583.1 ; C584.1 74.52,88.43 v2(75.02,88.92) ; C604.1 75.29,85.39 75.02,85.66 v2(75.02,85.92) ; C605.1 74.04,85.9 v2(74.02,85.92) ; C621.1 v2(75.02,81.92) ; v1(75.18,106.96) R294.2
  vias: v3(80.26,135.71) v3(80.26,134.87) v3(80.26,134.01) v3(80.82,131.15) v3(80.83,128.66) v3(81.09,129.35) v3(81.51,136.63) v3(81.74,128.99) v3(83.78,113.79) v3(83.87,112.98) v3(84.48,113.51) v3(85.03,114.01) v3(89.92,110.24) v3(89.97,109.5) v3(90.73,109.5) v3(91.49,109.5)
CVDD1T: length 7.8
  TOP w0.381: U24.W22 73.17,80.77 v2(73.02,80.77) ; U24.R22 v2(77.02,80.92) ; U24.U22 v2(75.02,80.92)
  BOTTOM w0.254: R606.2 95.12,112.79 v3(95.08,112.74)
  BOTTOM w0.381: C640.1 73.61,80.33 73.17,80.77 v2(73.02,80.77) ; C630.1 76.59,80.5 v2(77.02,80.92)
  vias: v1(50.13,78.71) v1(50.72,79.32) v1(86.36,136.65) v1(86.74,132.59) v1(86.74,131.57) v1(87.5,136.65) v1(87.5,132.59) v1(87.5,131.57) v1(88.52,136.65) v3(81,107.26) v3(81,106.53) v3(81,105.79) v3(82.17,107.06) v3(82.17,106.17) v3(86.55,128.38) v3(87.05,128.93) v3(87.48,128.22) v3(87.9,128.92)
CVDD_PWR_MON: length 6.1
  TOP w0.254: v1(122.68,119.31) 123.07,119.7 R243.1 123.59,119.7 124.98,121.09 126.36,121.09 126.66,121.39 U13.1
  BOTTOM w0.254: v1(122.68,119.31) 123.07,119.7 R243.1
CVDD_PWR_OK: length 26.1
  TOP w0.254: U16.24 111.89,117.55 D7.1 109.94,116.79 R271.1 109.57,116.55 108.97,115.95 108.97,115.49 v1(108.66,115.19) ; v1(123.57,115.26) 123.32,115.51 R243.2
  BOTTOM w0.254: v1(123.57,115.26) 123,115.82 109.07,115.82 108.66,115.42 v1(108.66,115.19)
DAC_SSPCK_3.3V: length 5.3
  TOP w0.127: U29.6 130.1,60.14 130.82,59.43 U32.6
DAC_SSPCS2_3.3V: length 6.3
  TOP w0.127: U29.5 129.45,59.94 130.61,58.78 U32.5
DAC_VOUT: length 150.3
  TOP w0.356: U29.3 130.1,66.73 129.92,66.55 129.67,66.55 129.45,66.76 U29.4 128.94,67.7 128.68,67.44 TP49.1
  TOP w0.381: v1(127.43,69.88) 128.37,69.88 128.69,69.56 128.69,69.07 128.65,69.04 128.65,69.02 C301.2 TP49.1
  TOP w0.508: v1(72.26,115.95) 73.79,114.43 73.79,112.65 74.17,112.27 v1(75.44,112.27) ; R261.2 45.24,114.83 v1(44.83,114.43)
  L3 w0.508: v1(122.3,111) 118.62,111 118.14,110.52 114,110.52 110.85,113.66 106.93,113.66 106.32,113.06 100.84,113.06 98.55,115.35 98.55,116.53 v1(97.72,117.36)
  L8 w0.508: v1(127.43,69.88) 127.91,70.36 127.91,81.48 126.85,82.55 126.85,106.77 126.49,107.13 126.49,108.59 124.08,111 v1(122.3,111) ; v1(58.55,116.03) 58.42,115.9 58.42,115.23 57.36,114.17 45.09,114.17 v1(44.83,114.43) ; v1(75.44,112.27) 76.33,112.27 76.71,112.65 76.71,113.79 77.11,114.19 77.11,115.2 78.62,116.71 78.99,116.71 81.86,119.58 81.86,121.39 83.03,122.56 91.82,122.56 92.79,121.59 92.79,120.44 93.47,119.75 93.95,119.75 94.6,119.11 94.6,118.51 95.74,117.36 v1(97.72,117.36)
  L10 w0.508: v1(72.26,115.95) 72.26,115.95 72.22,115.91 70.92,115.91 69.22,117.61 63.08,117.61 61.5,116.03 v1(58.55,116.03)
DDR3A_CLKN: length 83.8
  TOP w0.102: v1(83.58,118.01) 83.97,118.01 84.43,117.55 84.78,117.55 84.93,117.39 U19.33
  L10 w0.089: v2(91.95,74.93) 91.64,74.93 91.54,75.03 91.54,75.69 90.7,76.53 86.01,76.53 85.62,76.91 85.62,82.51 85.56,82.58 85.56,83.6 85.62,83.67 85.62,87.15 84.26,88.52 82.85,88.52 82.61,88.77 82.61,95.27 81.36,96.52 71.83,96.52 71.64,96.71 71.64,100.73 71.66,100.75 71.66,103.55 72.12,104.01 72.12,110.55 72.86,111.29 73.79,111.29 74.38,110.69 74.59,110.49 75.49,110.49 75.59,110.39 78.03,110.39 79.07,111.43 79.07,111.91 79.93,112.77 80.5,112.77 81.7,113.97 81.7,115.34 83.15,116.79 83.15,118.02 83.25,118.12 83.46,118.12 v1(83.58,118.01)
  BOTTOM w0.102: v2(91.95,74.93) 91.64,74.93 91.54,75.03 91.54,75.21 91.92,75.59 93.15,75.59 95.39,77.83 98.96,77.83 99.21,78.08 99.21,78.82 99.42,79.03 C670.1
DDR3A_CLKP: length 83.8
  TOP w0.102: v1(83.59,118.64) 83.59,118.62 83.95,118.26 84.08,118.26 84.53,117.8 84.78,117.8 84.87,117.89 U19.32
  L10 w0.089: v1(83.59,118.64) 83.31,118.36 83.19,118.36 82.93,118.11 82.93,116.88 81.48,115.43 81.48,114.06 80.41,112.99 79.84,112.99 78.85,112 78.85,111.52 77.94,110.6 75.68,110.6 75.58,110.71 74.68,110.71 73.88,111.51 72.77,111.51 71.9,110.64 71.9,104.1 71.44,103.64 71.44,100.83 71.43,100.82 71.43,96.62 71.74,96.3 81.27,96.3 82.39,95.18 82.39,88.68 82.77,88.3 84.17,88.3 85.41,87.06 85.41,83.76 85.34,83.69 85.34,82.49 85.41,82.42 85.41,76.83 85.92,76.31 90.61,76.31 91.33,75.6 91.33,75.2 v2(91.06,74.93)
  BOTTOM w0.102: C671.1 98.65,79.03 98.96,78.71 98.96,78.18 98.86,78.08 95.28,78.08 93.05,75.84 91.82,75.84 91.29,75.31 91.29,75.11 91.11,74.93 v2(91.06,74.93)
DDR3AATO: length 1.4
  TOP w0.102: U24.F13 86.52,89.42 v2(87.02,88.92)
  BOTTOM w0.102: v2(87.02,88.92) 87.51,88.43 TP71.1
DDR3ACLKN_C: length 12
  TOP w0.102: U24.A25 91.52,77.42 v2(91.97,76.96)
  BOTTOM w0.102: C670.2 99.4,79.93 99.23,80.1 99.23,80.46 98.78,80.9 96.77,80.9 92.33,76.45 91.69,76.45 91.62,76.53 91.62,76.78 91.8,76.96 v2(91.97,76.96)
DDR3ACLKP_C: length 12
  TOP w0.102: v2(90.98,76.96) 90.52,77.42 U24.B25
  BOTTOM w0.102: C671.2 98.76,79.93 98.97,80.14 98.97,80.35 98.68,80.65 96.88,80.65 92.43,76.2 91.59,76.2 91.36,76.42 91.36,76.76 91.16,76.96 v2(90.98,76.96)
DDR3APLLOBSCLKN: length 7.6
  TOP w0.102: 93.18,78.58 93.03,78.42 U24.A24
  TOP w0.127: TP46.1 96.9,79.38 93.98,79.38 93.18,78.58
DDR3APLLOBSCLKP: length 8.4
  TOP w0.102: U24.B24 90.91,78.03 93.18,78.03
  TOP w0.127: 93.18,78.03 94.12,78.97 97.76,78.97 TP47.1
DDR3B_CLKN: length 110.9
  TOP w0.102: C324.1 43.87,63.57 43.74,63.7 43.51,63.7 41.83,62.03 41.83,60.48 v1(42.11,60.2) ; U19.36 84.93,115.89 84.83,116 84.51,116 84.4,115.89 83.21,115.89 82.3,116.8 82.3,120.14 82.19,120.24 81.46,120.24 81.18,119.96 v1(81.18,119.94)
  L10 w0.089: v1(81.18,119.94) 81.18,120.09 80.8,120.47 78.98,120.47 77.77,119.26 77.77,117.04 74.84,114.11 71.27,114.11 68.79,116.59 64.58,116.59 59.73,111.74 59.73,109.64 57.98,107.89 57.98,105.55 62.59,100.94 62.59,98.39 62.64,98.33 62.64,91.19 62.55,91.1 62.55,83.26 60.88,81.58 60.88,79.6 60.62,79.34 60.62,74.59 59.61,73.58 59.61,70.59 59.33,70.31 54.76,70.31 54.25,69.8 54.25,68.86 49.05,63.66 49.05,62.6 47.39,60.93 42.14,60.93 41.83,60.63 41.83,60.48 v1(42.11,60.2)
DDR3B_CLKP: length 110.9
  TOP w0.102: C323.1 43.87,64.12 43.71,63.96 43.4,63.96 41.58,62.13 41.58,60.3 v1(41.48,60.2) ; U19.35 84.93,116.39 84.8,116.26 84.4,116.26 84.3,116.15 83.31,116.15 82.55,116.91 82.55,120.25 82.3,120.5 81.41,120.5 v1(81.2,120.7)
  L10 w0.089: v1(81.2,120.7) 81.18,120.68 78.89,120.68 77.55,119.35 77.55,117.13 74.75,114.33 71.36,114.33 68.88,116.8 64.49,116.8 59.52,111.83 59.52,109.73 57.76,107.98 57.76,105.46 62.37,100.85 62.37,98.3 62.43,98.24 62.43,91.28 62.34,91.19 62.34,83.35 60.67,81.67 60.67,79.69 60.4,79.43 60.4,74.68 59.4,73.67 59.4,70.68 59.24,70.52 54.67,70.52 54.04,69.89 54.04,68.95 48.84,63.75 48.84,62.69 47.3,61.15 42.05,61.15 41.62,60.71 41.62,60.34 v1(41.48,60.2)
DDR3BATO: length 1.4
  TOP w0.102: U24.AB32 70.42,70.42 v2(69.98,69.98)
  BOTTOM w0.102: TP88.1 69.52,69.52 v2(69.98,69.98)
DDR3BCLKN_C: length 16.4
  TOP w0.102: C324.2 44.77,63.32 44.96,63.5 45.21,63.5 45.49,63.22 45.49,62.78 46.98,61.29 49.41,61.29 50.02,61.9 56.26,61.9 57.15,62.78 57.15,63.16 57.1,63.21 57.1,63.75 57.23,63.88 57.33,63.88 57.52,63.69 U24.AR39
DDR3BCLKP_C: length 16.4
  TOP w0.102: U24.AR38 57.52,64.22 57.38,64.08 57.15,64.08 56.9,63.83 56.9,63.27 56.9,63.26 56.9,62.89 56.16,62.15 49.91,62.15 49.3,61.54 47.09,61.54 45.75,62.89 45.75,63.33 45.32,63.75 44.86,63.75 44.77,63.84 C323.2
DDR3BPLLOBSCLKN: length 8.7
  TOP w0.102: U24.AP39 56.69,61.59 56.67,61.59
  TOP w0.127: TP55.1 55.94,56.07 55.94,60.87 56.67,61.59
DDR3BPLLOBSCLKP: length 10.6
  TOP w0.102: 55.55,61.59 56.25,61.59 57.91,63.26 57.91,63.82 U24.AP38
  TOP w0.127: 55.55,61.59 54.61,60.66 TP53.1
DIMM_SA0: length 5.7
  TOP w0.356: R421.1 111.89,51 111.89,49.66 112.4,49.15 DIMM1.197
  TOP w0.381: R410.1 R421.1
DIMM_SA1: length 4.3
  TOP w0.356: R432.1 112.14,47.95 DIMM1.201
  TOP w0.381: R432.1 R428.1
DIMM_SCL: length 9.2
  TOP w0.127: U34.7 126.3,50.86 125.63,51.54 125.27,51.54 125.04,51.3 R424.1 124.48,51.49 123.7,51.49 123.48,51.27 123.48,48.4 122.73,47.65 DIMM1.202
DIMM_SDA: length 8.9
  TOP w0.127: DIMM1.200 122.79,48.25 123.1,48.55 123.1,51.43 123.54,51.87 124.45,51.87 R420.1 125.04,52.13 125.25,51.92 125.76,51.92 125.97,52.13 U34.6
DIP_SW_B0: length 71.3
  TOP w0.127: SW1.1 101.6,172.09 v1(101.35,171.83) ; v1(156.21,156.21) 156.53,155.89 156.72,155.89 156.96,155.65 U7.86
  L8 w0.114: v1(101.35,171.83) 102.08,171.09 112.07,171.09 112.58,171.61 123.09,171.61 125.53,174.05 140.39,174.05 141.04,173.39 143.61,173.39 146.76,170.24 146.76,167.95 155.07,159.65 155.07,157.91 156.21,156.77 v1(156.21,156.21)
  BOTTOM w0.127: R498.1 156.21,155.9 v1(156.21,156.21)
DIP_SW_B1: length 73.7
  TOP w0.127: v1(98.93,171.83) 99.06,171.96 SW1.2 ; U7.85 157.46,155.73 156.87,156.31 v1(156.87,156.31)
  L8 w0.114: v1(156.87,156.31) 156.87,156.45 155.97,157.35 155.97,159.09 147.21,167.85 147.21,170.14 143.71,173.63 141.14,173.63 140.49,174.29 125.28,174.29 123.53,172.54 114.74,172.54 114.44,172.83 99.93,172.83 v1(98.93,171.83)
  BOTTOM w0.127: R497.1 157.1,156.08 v1(156.87,156.31)
DIP_SW_B2: length 77.1
  TOP w0.127: v1(157.51,156.34) 157.96,155.89 U7.84 ; SW1.3 v1(96.52,171.83)
  L8 w0.114: v1(96.52,171.83) 97.76,173.07 116.47,173.07 117.27,173.87 123.65,173.87 124.31,174.53 143.16,174.53 147.45,170.24 147.45,167.95 156.48,158.92 156.48,158.23 157.51,157.2 v1(157.51,156.34)
  BOTTOM w0.127: R496.1 157.99,155.39 157.51,155.87 v1(157.51,156.34)
DIP_SW_B3: length 80.9
  TOP w0.127: U7.83 158.46,156.26 158.33,156.39 v1(158.14,156.39) ; SW1.4 v1(93.98,171.83)
  L8 w0.114: v1(158.14,156.39) 158.14,156.91 156.72,158.33 156.72,161.31 143.26,174.77 124.21,174.77 123.57,174.14 117.19,174.14 116.37,173.31 95.46,173.31 v1(93.98,171.83)
  BOTTOM w0.127: R495.1 158.9,156.39 v1(158.14,156.39)
DSP_SCL_AMC: length 9
  BOTTOM w0.127: AMC1.160 4.75,41.96 4.95,42.16 5.46,42.16 6.99,40.64 9.01,40.64 9.65,40 9.65,39.86 9.65,39.62 9.94,39.33 10.32,39.33 10.47,39.19 R764.1
DSP_SDA_AMC: length 8.9
  BOTTOM w0.127: R759.1 10.47,39.81 10.25,39.59 10.07,39.59 9.91,39.75 9.91,40.13 9.14,40.89 7.09,40.89 5.57,42.42 4.95,42.42 4.66,42.71 AMC1.159
DSP_UCD9244_VID1A: length 230.4
  TOP w0.127: U16.41 118.18,124.71 v1(118.24,124.76) ; U37.4 35.49,43.24 34.33,42.08 R450.1 34.04,42.06 34.58,41.52 34.58,40.4 34.06,39.88 31.5,39.88 30.1,38.48 v1(29.84,38.48)
  L8 w0.114: v1(29.84,38.48) 30.28,38.04 30.28,37.47 29.07,36.25 29.07,34.01 31.51,31.57 108.09,31.57 108.3,31.78 111.65,35.12 111.65,41.87 112.54,42.76 115.1,42.76 117.75,40.1 122.89,40.1 123.53,39.47 132.81,39.47 137.52,44.18 137.52,49.53 136.4,50.66 136.4,51.51 134.65,53.26 134.65,82.09 132.05,84.68 132.05,114.43 128.92,117.57 124.09,117.57 123.04,118.62 122.4,118.62 121.69,119.33 121.69,120.82 118.24,124.27 v1(118.24,124.76)
DSP_UCD9244_VID1B: length 231.6
  TOP w0.127: v1(118.87,124.88) 118.54,125.21 U16.42 ; U37.5 36.14,42.79 R451.1 35.43,42.06 35.98,41.52 35.98,40.4 35.2,39.62 31.62,39.62 v1(29.84,37.85)
  L8 w0.114: v1(29.84,37.85) 28.83,36.83 28.83,33.91 31.41,31.32 108.19,31.32 108.47,31.61 111.89,35.02 111.89,41.76 112.59,42.47 115.04,42.47 117.65,39.86 122.65,39.86 123.29,39.22 132.95,39.22 137.76,44.04 137.76,49.63 136.64,50.76 136.64,51.7 134.98,53.37 134.98,82.27 132.33,84.91 132.33,114.5 129.02,117.81 124.66,117.81 123.75,118.72 123.75,120.18 119.05,124.88 v1(118.87,124.88)
DSP_UCD9244_VID1C: length 228.4
  TOP w0.127: U37.6 v1(36.79,42.88) 36.79,42.12 R452.1 ; v1(108.89,118.62) U16.18
  L8 w0.114: v1(108.89,118.62) 109.49,118.62 110.42,117.68 111.64,117.68 111.66,117.71 121.23,117.71 122.58,116.36 124.85,116.36 125.24,115.97 130.99,110.22 130.99,83.52 131.6,82.91 131.6,71.3 133.65,69.24 133.65,51.44 136.56,48.54 136.56,46.26 133.86,43.56 131.19,43.56 129.11,41.48 123.65,41.48 123.31,41.14 118.09,41.14 115.51,43.72 112.14,43.72 110.6,42.18 110.6,35.44 107.69,32.53 32.07,32.53 30.09,34.52 30.09,35.9 31.25,37.06 31.25,39.9 31.73,40.38 31.73,40.79 31.46,41.05 31.46,41.76 32.22,42.52 36.43,42.52 v1(36.79,42.88)
DSP_UCD9244_VID1S: length 229
  TOP w0.127: R453.1 38.23,42.1 v1(37.43,42.9) 37.44,42.91 U37.7 ; U16.12 106.53,122.71 v1(106.4,122.83)
  L8 w0.114: v1(106.4,122.83) 105.93,122.36 105.93,121.36 106.31,120.98 107.19,120.98 107.72,120.45 107.72,118.52 108.3,117.94 109.21,117.94 109.95,117.2 111.84,117.2 111.86,117.23 121.03,117.23 122.38,115.87 124.65,115.87 130.4,110.12 130.4,82.8 130.7,82.51 130.7,71.06 133.12,68.63 133.12,50.27 134.27,49.12 134.27,44.74 133.6,44.07 130.94,44.07 128.84,41.97 123.2,41.97 122.85,41.62 118.29,41.62 115.55,44.37 110.87,44.37 110.04,43.53 110.04,35.56 107.49,33.01 32.77,33.01 31.88,33.91 31.88,35.81 32.77,36.7 32.77,37.97 34.67,39.88 34.67,40.77 35.94,42.04 36.57,42.04 37.23,42.69 v1(37.43,42.9)
DSP_VCL_R: length 63.3
  TOP w0.102: v2(58.02,65.92) U24.AP36
  TOP w0.127: v1(25.4,37.21) 25.4,37.08 23.67,35.35 CN19.1
  L3 w0.102: v2(58.02,65.92) 58.02,66.38 57.64,66.77 57.64,67.08 57.86,67.3 57.86,67.3 58.31,67.75 58.31,68.07 58.08,68.3 55.83,68.3 53.61,66.08 53.61,65.74 52.9,65.02 51.82,65.02
  L3 w0.114: v1(47.05,63.47) 47.13,63.55 50.34,63.55 51.82,65.02
  L8 w0.114: v1(25.4,37.21) 25.17,37.45 25.17,45.27 31.03,51.13 31.03,55.35 31.3,55.62 31.3,56.17 31.88,56.75 31.88,57.67 36.47,62.27 40.48,62.27 42.12,63.91 46.6,63.91 v1(47.05,63.47)
DSP_VD_R: length 58.6
  TOP w0.102: U24.AP35 v2(58.02,66.92)
  TOP w0.127: v1(26.05,37.08) 25.67,36.7 CN19.2
  L3 w0.102: 51.82,65.28 52.86,65.28 53.34,65.76 53.34,66.1 55.75,68.51 58.16,68.51 58.51,68.16 58.51,67.42 v2(58.02,66.92)
  L3 w0.114: v1(46.38,63.47) 46.89,63.98 50.19,63.98 51.49,65.28 51.82,65.28
  L8 w0.114: v1(46.38,63.47) 42.02,63.47 40.58,62.03 36.57,62.03 32.72,58.18 32.72,55.98 32.36,55.62 32.36,52.12 27.15,46.91 27.15,38.18 v1(26.05,37.08)
DSP_VIDA: length 36
  TOP w0.102: v2(57.02,65.92) 57.52,66.42 U24.AR36
  TOP w0.127: R415.1 33.22,52.51 34.19,51.54 v1(35.1,51.54) 35.31,51.33 35.31,51.31 35.49,51.13 U37.13
  L3 w0.102: v2(57.02,65.92) 57.4,65.54 57.4,64.23 54.76,61.59
  L3 w0.114: v1(35.1,51.54) 35.97,50.67 37.69,50.67 41.03,54.01 41.03,55.6 44.72,59.29 52.45,59.29 54.76,61.59
DSP_VIDB: length 32.7
  TOP w0.102: U24.AT38 v2(57.02,64.92)
  TOP w0.127: R416.1 34.47,52.07 35.31,52.07 v1(35.81,51.56) 36.14,51.24 U37.12
  L3 w0.114: v2(57.02,64.92) 57.02,64.38 52.17,59.53 44.62,59.53 40.79,55.7 40.79,54.11 37.59,50.91 36.46,50.91 v1(35.81,51.56)
DSP_VIDC: length 30.3
  TOP w0.102: U24.AU38 56.01,64.91 v2(56.01,65.02)
  TOP w0.127: U37.11 36.79,51.31 36.59,51.51 36.59,51.54 v1(36.58,51.54) 35.6,52.51 R417.1
  L3 w0.114: v2(56.01,65.02) 56.01,64.49 54.4,62.89 54.4,62.76 51.41,59.77 44.52,59.77 40.54,55.79 40.54,54.2 37.49,51.16 36.96,51.16 v1(36.58,51.54)
DSP_VIDS: length 31.4
  TOP w0.102: U24.AR35 57.12,67.82 v2(57.12,67.92)
  TOP w0.127: R418.1 36.83,52.08 v1(37.31,51.59) 37.44,51.47 U37.10
  L3 w0.114: v2(57.12,67.92) 56.02,66.81 56.02,65.87 55.23,65.09 55.23,64.29 54.26,63.31 52.66,63.31 49.36,60.01 44.42,60.01 40.29,55.89 40.29,54.58 v1(37.31,51.59)
ECC_NU: length 1.7
  TOP w0.102: U41.D7 71.4,45.32 v2(71.4,45.31)
  BOTTOM w0.102: v2(71.4,45.31) 70.63,46.08 R751.2
EEPROM_WPZ: length 65.9
  TOP w0.127: v1(127.56,99.69) EEPROM1.7 125.42,99.69 R324.2
  L3 w0.114: v1(127.56,99.69) 126.16,101.1 126.16,111.97 121.98,116.15 121.98,121.89 121.43,122.43 121.43,126.53 121.43,127.17 120.64,127.97 120.64,128.45 113.65,135.44 113.65,143.33 112.17,144.81 108.55,148.43 v1(107.82,148.43)
  BOTTOM w0.127: v1(107.82,148.43) 106.66,149.59 U50.2
EMIF_DIR: length 124.2
  L5 w0.114: v1(47.04,123.47) 47.04,124.45 49.01,126.41 49.01,127.62 49.64,128.26 49.64,136.16 48.51,137.29 48.51,139.15 46.7,140.97 46.7,141.53 46.14,142.09 46.14,144.25 43.13,147.26 43.13,147.99 43.7,148.56 43.7,149.42 41.83,151.29 41.83,153.19 42.23,153.59 42.23,154.29 42.09,154.43 42.09,158.07 42.95,158.92 42.95,160.5 43.97,161.52 45.2,161.52 45.99,162.31 48.01,162.31 49.35,163.65 87.15,163.65 87.58,163.22 90.12,163.22 91.08,164.19 93.78,164.19 94.03,164.44 102.05,164.44 102.06,164.45 102.46,164.45 102.47,164.44 105.29,164.44 106.63,163.1 106.63,161.57 106.1,161.04 106.1,159.08 107.62,157.56 107.62,156.38 107.18,155.93 v1(107.18,155.93)
  BOTTOM w0.127: v1(107.18,155.93) 107.18,154.98 107.52,154.64 107.52,153.67 108.03,153.16 108.64,153.16 108.96,152.84 U50.22 ; R810.2 45.48,125.03 v1(47.04,123.47)
EMIF_DIR_R: length 13.3
  TOP w0.127: U65.1 44.18,128.31 v1(44.74,127.76) 44.86,127.63 46.53,127.63 46.75,127.85 46.75,129.11 46.86,129.22 46.86,131.77 46.26,132.37 46.26,132.55 45.59,133.22 45.3,133.22 45.13,133.39 45.02,133.39 44.18,134.23 U68.1
  BOTTOM w0.127: v1(44.74,127.76) 45.22,127.28 R811.1 45.32,125.94 R810.1
EMIF_OEZ: length 130.7
  TOP w0.127: v1(42.04,127.76) 41.68,128.12 U65.19 ; U68.19 41.68,134.77 41.7,134.77 v1(42.02,134.44)
  L5 w0.114: v1(45.59,153.42) 45.59,154.31 48.65,157.37 52.77,157.37 53.85,158.44 53.85,158.75 55.55,160.45 91.41,160.45 92.84,161.87 98.88,161.87 99.92,162.92 103.12,162.92 104.44,161.59 104.44,158.95 105.89,157.51 105.89,156.54 v1(106.5,155.93) ; v1(44.84,140.76) 44.86,140.76 44.86,140.78 45.75,140.78 47.71,138.82 47.71,131.91 47.12,131.32 47.12,129.9 46.24,129.02 44.91,129.02 44.17,128.28 43.61,128.28 42.55,128.28 v1(42.04,127.76)
  L10 w0.114: v1(42.02,134.44) 42.39,134.44 42.7,134.14 42.7,132.97 41.99,132.26 41.99,127.81 v1(42.04,127.76)
  BOTTOM w0.127: U69.4 51.65,159.5 51.18,159.03 51.18,152.88 50.19,151.89 47.12,151.89 46.66,152.35 ; 46.66,152.35 v1(45.59,153.42) ; 46.66,152.35 46.66,143.18 44.86,141.38 44.86,140.76 v1(44.84,140.76) ; v1(106.5,155.93) 105.97,156.46 105.97,158.55 106.76,159.33 R812.2
EMIFA00: length 185.9
  TOP w0.102: v2(87.05,67.92) 87.02,67.92 U24.F34
  TOP w0.127: v1(32.92,106.88) 32.72,106.68 23.9,106.68 23.6,106.98 21.43,106.98 v1(20.21,105.77)
  L5 w0.102: 87.78,61.59 87.78,63.25 85.6,65.43 85.6,66.07 86.05,66.52 86.16,66.52 86.44,66.8 86.44,67.18 87.05,67.79 v2(87.05,67.92)
  L5 w0.114: 87.78,61.59 87.78,61.56 88.04,61.3 88.04,58.44 83.02,53.42 51.63,53.42 46.88,58.18 43.57,58.18 38.85,53.45 28.74,53.45 28.05,52.76 20.12,52.76 19.24,53.64 19.24,73.41 20.99,75.17 20.99,86.78 19.01,88.76 19.01,95.49 19.66,96.14 19.66,105.21 v1(20.21,105.77)
  L8 w0.114: v1(32.92,106.88) 32.92,111.15 34.61,112.85 37.79,112.85 40.92,115.98 40.92,116.81 43.42,119.32 v1(44.81,119.32)
  BOTTOM w0.127: v1(44.81,119.32) 44.9,119.22 44.9,118.6 44.64,118.34 44.27,118.34 42.93,119.68 42.93,123.08 43.18,123.32 43.18,124.03 41.44,125.76 U63.47
EMIFA01: length 170.6
  TOP w0.102: 87.38,61.59 87.38,63.03 87.14,63.27 87.14,64.8 86.83,65.11 U24.F37
  TOP w0.127: v1(32.97,106.17) 32.72,106.43 23.8,106.43 23.49,106.73 21.82,106.73 v1(20.85,105.76) ; v2(87.38,61.37) 87.38,61.59
  L5 w0.114: v2(87.38,61.37) 87.8,60.95 87.8,58.54 82.92,53.66 55.08,53.66 50.07,58.68 25.57,58.68 24.31,59.94 20.69,59.94 19.49,61.15 19.49,73.32 21.23,75.07 21.23,86.88 19.25,88.86 19.25,95.33 19.9,95.97 19.9,104.82 20.19,105.11 20.2,105.11 v1(20.85,105.76)
  L8 w0.114: v1(32.97,106.17) 33.36,106.56 33.36,111.25 34.71,112.61 37.93,112.61 41.16,115.84 41.16,116.71 42.36,117.91 43.58,117.91 v1(44.46,118.79)
  BOTTOM w0.127: v1(44.46,118.79) 43.19,120.06 43.19,122.97 43.43,123.22 43.43,125.3 42.48,126.26 U63.46
EMIFA02: length 183.4
  TOP w0.102: v2(85.98,65.91) 85.98,65.96 U24.G36
  L5 w0.102: 88.11,61.59 88.11,63.2 86.23,65.08 86.23,65.66 v2(85.98,65.91)
  L5 w0.114: 88.11,61.59 88.28,61.43 88.28,58.34 82.64,52.7 47.63,52.7 47,52.06 43.53,52.06 42.94,52.65 41.19,52.65 40.8,53.04 32.63,53.04 32.11,52.52 20.02,52.52 19,53.54 19,74.85 20.25,76.1 20.25,87.04 17.42,89.87 17.42,94.26 19.16,96 19.16,101.19 18.43,101.92 18.43,104.6 19.5,105.67 19.5,107.26 21.32,109.09 25.05,109.09 26.32,110.36 27.71,110.36 29.66,112.31 29.66,126.06 31.07,127.46 31.07,129.49 30.78,129.77 30.39,129.77 v1(29.82,130.35)
  L8 w0.114: v1(29.82,130.35) 29.84,130.35 30.32,129.86 34.33,129.86 34.57,130.11 v1(34.61,130.11)
  BOTTOM w0.127: v1(34.61,130.11) 34.6,130.11 34.6,130.13 35.54,129.19 37.01,129.19 39.14,127.06 39.93,127.06 40.13,127.26 U63.44
EMIFA03: length 165.5
  TOP w0.102: 87.76,61.59 87.63,61.72 87.63,63.31 U24.E39
  TOP w0.127: v2(87.38,60.61) 87.8,61.02 87.8,61.56 87.76,61.59
  L5 w0.114: v2(87.38,60.61) 87.38,58.47 82.82,53.91 55.18,53.91 50.17,58.92 25.67,58.92 24.41,60.19 20.79,60.19 19.98,60.99 19.98,73.47 21.47,74.97 21.47,88.93 19.5,90.9 19.5,95.14 20.14,95.78 20.14,103.51 21.52,104.88 21.52,107.66 22.71,108.85 25.15,108.85 26.36,110.06 28.1,110.06 29.91,111.87 29.91,124.58 31.46,126.13 31.46,129.15 32.41,130.1 33.69,130.1 34.14,130.54 v1(34.14,130.54)
  BOTTOM w0.127: U63.43 40.06,127.76 39.88,127.95 38.61,127.95 37.11,129.44 36.04,129.44 34.94,130.55 34.44,130.55 34.43,130.54 v1(34.14,130.54)
EMIFA04: length 190.2
  TOP w0.102: v2(87.99,67.94) 87.99,67.95 U24.E34
  L5 w0.102: 89.03,61.59 89.03,62.05 88.77,62.31 88.77,64.06 87.63,65.2 87.63,67.59 v2(87.99,67.94)
  L5 w0.114: v1(29.47,132.59) 28.84,131.96 28.84,113.41 27.98,112.54 27.98,111.91 27.22,111.15 26.09,111.15 24.75,109.81 20.78,109.81 17.16,106.19 17.16,104.39 15.26,102.49 15.26,94.52 16.59,93.19 16.59,92.78 16.59,92.78 16.59,89.53 19.53,86.59 19.53,76.4 18.27,75.15 18.27,52.28 19.91,50.65 40.66,50.65 41.19,51.17 47.13,51.17 47.93,51.97 82.94,51.97 89.03,58.06 89.03,61.59
  L8 w0.114: v1(34.62,131.02) 34.62,131.01 33.83,131.01 32.66,132.18 29.87,132.18 29.46,132.59 v1(29.47,132.59)
  BOTTOM w0.127: U63.41 39.96,128.76 39.86,128.86 38.57,128.86 36.38,131.06 36.01,131.06 35.97,131.02 v1(34.62,131.02)
EMIFA05: length 105
  TOP w0.102: U24.J34 83.94,68 v2(84.05,68)
  L5 w0.102: 53.4,67.1 55.4,67.1 55.97,66.52 66.27,66.52 66.45,66.34 77.97,66.34 78.64,67 78.64,67.08 78.86,67.3 79.5,67.3 79.73,67.54 83.6,67.54 v2(84.05,68)
  L5 w0.114: v1(44.84,120.47) 44.41,120.47 42.89,118.94 42.89,115.44 41.19,113.74 41.19,96.5 42,95.69 42,88.28 44.95,85.33 44.95,75.78 47.46,73.26 47.46,72.29 52.65,67.1 53.4,67.1
  BOTTOM w0.127: v1(44.84,120.47) 44.84,120.49 45.28,120.93 45.28,122.03 44.18,123.13 44.18,125.35 44.3,125.47 44.3,125.76 43.89,126.17 43.89,127.93 42.56,129.26 U63.40
EMIFA06: length 120.6
  TOP w0.102: U24.H35 84.99,66.95 v2(85.01,66.95)
  L5 w0.102: v2(85.01,66.95) 85.01,66.48 84.61,66.07 84.61,65.7 84.25,65.34 82.88,65.34 82.65,65.11 82.65,65.02 82.18,64.54 81.79,64.54 81.15,63.9 81.15,61.87 80.88,61.59
  L5 w0.114: 80.88,61.59 77.98,58.7 74.72,58.7 73.64,59.78 73.64,60.66 72.46,61.84 70.71,61.84 69.64,62.91 66.08,62.91 66.06,62.89 57.86,62.89 57.29,62.32 53.73,62.32 46.96,69.09 45.38,69.09 42.2,72.27 42.2,73.03 41.74,73.48 39.78,73.48 37.66,75.61 37.66,76.9 35.23,79.32 35.23,81.25 35.64,81.66 35.64,89.33 36.49,90.18 36.49,100.5 37.48,101.49 37.48,113.86 39.7,116.08 39.7,125.29 39.92,125.51 39.92,126.41 39.23,127.1 39.23,128.95 39.75,129.47 v2(39.75,129.51)
  BOTTOM w0.127: U63.38 40.15,130.26 39.75,129.87 v2(39.75,129.51)
EMIFA07: length 103
  TOP w0.102: U24.K33 82.93,69.01 v2(83.08,69.01)
  L5 w0.102: v2(83.08,69.01) 83.07,69.01 80.78,71.3 51.82,71.3
  L5 w0.114: 51.82,71.3 51.69,71.3 49.91,73.09 49.91,74.84 46.97,77.78 46.97,98.93 49.13,101.09 49.13,111.61 46.99,113.75 46.99,122.71 v2(46.79,122.91)
  BOTTOM w0.127: U63.37 42.39,130.76 42.75,131.13 44.13,131.13 45.4,129.86 45.4,129.32 44.13,128.05 44.15,128.04 44.15,126.31 44.55,125.91 44.55,124.1 45.03,123.62 46.08,123.62 v2(46.79,122.91)
EMIFA08: length 212.5
  TOP w0.102: U24.C35 89.55,67.42 v2(90.02,66.95)
  L5 w0.102: 91.06,61.59 91.23,61.76 91.23,65.75 v2(90.02,66.95)
  L5 w0.114: v1(28.64,137.79) 26.91,136.06 26.91,114.74 24.39,112.22 23.84,112.22 23.14,111.53 19.8,111.53 13.57,105.3 13.57,89.99 17.34,86.21 17.34,79.32 15.48,77.46 14.08,77.46 11.35,74.73 11.35,60.6 12.53,59.41 12.53,51.43 15.97,48 40.06,48 41.79,49.73 47.73,49.73 48.53,50.53 84.89,50.53 92.25,57.88 92.25,59.72 91.06,60.9 91.06,61.59
  L8 w0.114: v1(34.62,133.16) 34.61,133.17 33.97,133.17 32.57,134.58 29.52,134.58 28.64,135.45 v1(28.64,137.79)
  BOTTOM w0.127: U63.36 40.13,131.26 40.06,131.34 36.46,131.34 36.42,131.38 36.39,131.38 36.13,131.64 36.13,131.67 34.64,133.16 v1(34.62,133.16)
EMIFA09: length 140.7
  TOP w0.102: U24.G37 86.14,64.8 86.14,64.27 86.3,64.1 86.3,63.74 86.14,63.59 86.14,63.58 v2(86.14,62.88)
  L5 w0.102: 85.61,61.59 85.61,61.65 86.14,62.18 v2(86.14,62.88)
  L5 w0.114: v1(36.58,131.83) 36.91,131.5 36.91,129.61 36.51,129.21 36.05,129.21 35.7,128.86 35.7,128.15 35.6,128.05 35.6,126.75 34.79,125.93 34.79,123.55 31.52,120.28 31.52,91.29 29.57,89.34 29.57,86.07 30.47,85.16 30.47,77.25 34.73,72.98 34.73,71.7 36.28,70.15 36.28,63.97 39.57,60.68 50.4,60.68 56.21,54.87 82.42,54.87 85.61,58.06 85.61,61.59
  BOTTOM w0.127: v1(36.58,131.83) 36.64,131.76 U63.35
EMIFA10: length 172.3
  TOP w0.102: U24.F38 86.9,64.04 v2(86.9,62.87)
  L5 w0.102: v2(86.9,62.87) 86.96,62.8 86.96,61.59
  L5 w0.114: 86.96,61.59 86.96,58.39 82.72,54.15 55.28,54.15 50.27,59.16 25.77,59.16 24.51,60.43 20.89,60.43 20.22,61.09 20.22,72.91 23,75.69 23.3,75.69 23.55,75.94 23.55,87.19 19.74,91 19.74,95.02 20.38,95.67 20.38,103.41 21.76,104.78 21.76,107.56 22.81,108.6 25.25,108.6 26.45,109.8 28.18,109.8 30.15,111.77 30.15,124.48 32.31,126.64 32.31,128.37 33.61,129.67 34.79,129.67 35.11,129.98 35.11,134.16 34.85,134.42 34.73,134.42 v1(34.29,134.86)
  BOTTOM w0.127: v1(34.29,134.86) 34.86,134.86 35.43,134.29 35.43,133.48 36.15,132.76 U63.33
EMIFA11: length 233.5
  TOP w0.102: U24.D35 89.01,66.93 v2(89.05,66.93)
  L5 w0.102: 89.63,62.77 89.63,66.35 v2(89.05,66.93)
  L5 w0.114: v1(29.4,135.32) 29.12,135.32 27.64,133.83 27.64,114.44 24.24,111.04 20,111.04 14.05,105.1 14.05,90.19 17.82,86.41 17.82,79.12 15.68,76.97 14.28,76.97 11.83,74.53 11.83,60.8 13.02,59.61 13.02,51.63 15.99,48.66 20.01,48.66 20.74,49.39 21.83,49.39 22.74,48.48 39.86,48.48 41.59,50.21 47.53,50.21 48.33,51.01 83.34,51.01 90.14,57.81 90.14,62.25 89.63,62.76 89.63,62.77
  L8 w0.114: v1(29.4,135.32) 29.47,135.25 29.47,135.24 29.83,134.87 32.92,134.87 33.38,134.42 34.61,134.42 34.61,134.42 34.97,134.42 35.64,133.75 35.64,133.53 35.93,133.24 36.33,133.24 36.36,133.27 v1(36.67,133.27)
  BOTTOM w0.102: NAND1.C4 35.05,159.04 34.29,158.27 33.94,158.27 32.77,157.1 32.08,157.1
  BOTTOM w0.127: U63.32 37.42,133.26 37.26,133.1 36.93,133.1 36.75,133.27 v1(36.67,133.27) ; 32.08,157.1 30.99,157.1 29.84,155.96 29.84,154.81 27.43,152.4 27.43,137.29 v1(29.4,135.32)
EMIFA12: length 180.9
  TOP w0.102: U24.H36 84.99,65.95 v2(84.99,65.91)
  L5 w0.102: 83.95,61.59 84.43,62.08 84.43,63.84 84.9,64.31 84.94,64.31 85.4,64.77 85.4,65.5 v2(84.99,65.91)
  L5 w0.114: 83.95,61.59 78.19,55.84 57.24,55.84 51.43,61.65 39.97,61.65 37.25,64.37 37.25,70.55 35.7,72.1 35.7,73.39 31.44,77.65 31.44,88.23 32.23,89.03 32.23,90.32 32.89,90.98 32.89,105.63 32.48,106.04 32.48,111.25 37.45,116.23 v1(37.45,117.11)
  L8 w0.114: v1(30.61,135.76) 31.36,136.52 34.33,136.52 35.05,135.8 35.05,135.23 36.04,134.24 v1(36.67,134.24)
  L10 w0.114: v1(37.45,117.11) 37.45,117.21 37.64,117.4 37.64,121.41 35.86,123.19 35.23,123.19 32.26,126.16 32.26,134.11 v1(30.61,135.76)
  BOTTOM w0.102: 32.08,155.93 33.84,157.68 34.39,157.68 34.49,157.58 35.08,157.58 35.56,157.1 35.99,157.1 36.25,157.36 36.25,157.57 36.32,157.64 36.32,157.97 NAND1.D5
  BOTTOM w0.127: U63.30 36.73,134.26 36.7,134.24 v1(36.67,134.24) ; v1(30.61,135.76) 30.48,135.89 29.21,135.89 27.69,137.41 27.69,152.29 30.65,155.26 31.41,155.26 32.08,155.93
EMIFA13: length 202.1
  TOP w0.102: v2(88.06,66.95) 87.99,66.95 U24.E35
  L5 w0.102: v2(88.06,66.95) 88.64,66.38 88.64,64.77 89.22,64.19 89.22,62.59 89.66,62.15 89.66,61.59
  L5 w0.114: 89.66,61.59 89.66,58.01 83.14,51.49 48.13,51.49 47.33,50.69 41.39,50.69 40.85,50.15 17.97,50.15 17.56,50.56 14.77,50.56 13.5,51.83 13.5,59.81 13.46,59.85 13.46,64.28 14.47,65.29 14.47,72.04 15.37,72.94 15.37,75.77 18.31,78.7 18.31,86.61 15.13,89.79 15.13,92.6 15.17,92.64 15.17,93.52 14.54,94.15 14.54,104.9 20.17,110.53 24.41,110.53 28.12,114.24 28.12,133.63 29.05,134.57 30.98,134.57 32.74,136.33 32.74,136.99 34.06,138.3 34.09,138.3 v1(34.24,138.46)
  BOTTOM w0.127: v1(34.24,138.46) 35.05,137.64 35.05,135.03 35.32,134.76 U63.29
EMIFA14: length 145.6
  TOP w0.102: v2(85.92,63.91) 85.92,64.02 U24.G38
  L5 w0.102: v2(85.92,63.91) 86.52,63.31 86.52,62.26 85.85,61.59
  L5 w0.114: 85.85,61.59 85.85,57.96 82.52,54.63 56.04,54.63 50.96,59.71 40.2,59.71 36.04,63.87 36.04,70.05 34.49,71.6 34.49,72.88 30.23,77.15 30.23,85.06 29.32,85.97 29.32,89.44 31.27,91.39 31.27,124.17 33.06,125.96 34.44,125.96 35.35,126.87 35.35,128.14 35.44,128.23 35.44,128.95 35.95,129.45 36.41,129.45 36.67,129.71 36.67,131.12 35.64,132.14 35.64,134.18 v1(36.67,135.21)
  BOTTOM w0.127: v1(36.67,135.21) 39.24,135.21 39.8,135.76 U63.27
EMIFA15: length 161
  TOP w0.102: 86.52,61.59 U24.F39
  TOP w0.127: 86.52,61.59 86.55,61.56 v2(86.55,61.34)
  L5 w0.114: v2(86.55,61.34) 86.55,58.32 82.62,54.39 55.38,54.39 50.37,59.4 30.65,59.4 22.68,67.38 22.68,75.02 23.09,75.44 23.39,75.44 23.79,75.84 23.79,87.29 19.98,91.1 19.98,94.91 20.62,95.55 20.62,103.31 22,104.68 22,107.46 22.91,108.36 25.35,108.36 25.82,108.83 27.55,108.83 30.39,111.67 30.39,124.38 32.55,126.54 32.55,128.07 33.91,129.43 34.89,129.43 35.34,129.88 35.36,129.89 35.36,134.58 v1(36.04,135.26)
  BOTTOM w0.127: U63.26 39.74,136.26 39.13,135.65 36.48,135.65 36.09,135.26 v1(36.04,135.26)
EMIFA16: length 115.4
  TOP w0.102: U24.K34 82.94,68 v2(83.03,68)
  L5 w0.102: v2(83.03,68) 82.48,68 82.15,68.33 81.85,68.33 81.4,68.78 81.4,69.08 81.14,69.34 79.86,69.34 79.63,69.11 79.63,69 79.18,68.54 78.72,68.54 78.49,68.3 77.86,68.3 77.41,67.86 77.41,67.78 77.18,67.54 67.94,67.54 67.15,68.34 54.6,68.34
  L5 w0.114: v1(42.97,112.71) 42.91,112.65 42.45,112.65 41.91,112.11 41.91,96.8 42.72,95.99 42.72,88.6 45.67,85.65 45.67,77.28 48.62,74.33 48.62,72.26 52.54,68.34 54.6,68.34
  L10 w0.114: v1(42.82,140.26) 42.82,139.63 41.31,138.11 41.31,125.61 42.6,124.32 42.88,124.32 43.57,123.63 43.57,121.97 44.02,121.52 44.02,117.8 44.31,117.5 44.31,113.79 43.23,112.71 v1(42.97,112.71)
  BOTTOM w0.127: v1(42.82,140.26) 41.59,139.02 U64.47
EMIFA17: length 188.6
  TOP w0.102: U24.F35 86.99,66.95 v2(87.05,66.95)
  L5 w0.102: v2(87.05,66.95) 86.64,66.55 86.64,65.25 88.34,63.55 88.34,61.77 88.52,61.59
  L5 w0.114: 88.52,61.59 88.52,58.24 82.74,52.46 47.73,52.46 47.1,51.82 43.43,51.82 43.22,52.03 32.51,52.03 31.66,51.18 25.73,51.18 25,51.92 20.28,51.92 18.76,53.44 18.76,74.95 20.01,76.2 20.01,86.85 17.08,89.78 17.08,92.58 17.08,93.39 15.74,94.72 15.74,102.26 19.25,105.77 19.25,107.36 21.22,109.33 24.95,109.33 26.22,110.6 27.61,110.6 29.32,112.31 29.32,131.07 30.25,131.99 31,131.99 32.07,133.06 32.07,133.91 33.71,135.55 33.71,136.26 33.96,136.52 36.95,136.52 39.62,139.19 v1(39.72,139.19)
  BOTTOM w0.127: U64.46 40.05,139.52 v1(39.72,139.19)
EMIFA18: length 146.8
  TOP w0.102: v2(84,66.98) 83.96,66.98 U24.J35
  L5 w0.102: 77.18,64.54 77.18,64.54 79.17,64.54 79.43,64.8 79.43,65.17 79.64,65.37 79.64,66.08 79.86,66.3 80.62,66.3 80.89,66.57 82.15,66.57 82.64,67.06 82.64,67.08 82.86,67.3 83.18,67.3 83.5,66.98 v2(84,66.98)
  L5 w0.114: v1(40.03,113.94) 40.47,113.5 40.47,97.42 38.08,95.04 38.08,90.74 38.67,90.14 38.67,88.74 38.41,88.48 38.41,85.57 38.1,85.27 38.1,81.81 38.75,81.16 38.75,80.95 42,77.7 42,77.7 46.74,72.96 46.74,71.99 52.3,66.42 55.16,66.42 56.27,65.31 66.18,65.31 66.41,65.08 66.41,64.99 66.86,64.54 77.18,64.54
  L8 w0.114: v1(29.21,145.92) 29.53,145.92 32.86,142.6 38.19,142.6 39.12,143.53 39.12,143.56 39.37,143.82 39.74,143.82 40.15,143.4 40.15,142.29 v1(42.19,140.26)
  L10 w0.114: v1(29.21,145.92) 28.38,145.09 28.38,139.52 29.98,137.92 29.98,137.05 32.51,134.52 32.51,127 33.57,125.95 34.5,125.95 34.8,125.65 34.8,124.72 34.79,124.71 34.79,123.97 35.33,123.43 35.96,123.43 38.23,121.17 38.23,116.33 40.03,114.53 v1(40.03,113.94)
  BOTTOM w0.127: U64.44 41.93,140.52 v1(42.19,140.26)
EMIFA19: length 147.8
  TOP w0.102: v2(85.58,62.86) 85.52,62.92 U24.G39
  L5 w0.102: v2(85.58,62.86) 85.58,61.95 85.37,61.74 85.37,61.59
  L5 w0.114: v1(42.93,140.89) 43.36,140.46 43.36,140.14 37.26,134.03 37.26,127.55 36.62,126.92 36.11,126.92 35.18,125.98 35.18,125.48 35.66,124.99 35.66,124.08 32.26,120.68 32.26,115.03 31.76,114.53 31.76,105.74 32.17,105.33 32.17,91.61 31.41,90.84 31.41,90.82 29.96,89.37 29.96,87.4 30.71,86.64 30.71,77.35 34.98,73.08 34.98,71.8 36.53,70.25 36.53,64.07 39.67,60.92 51.13,60.92 56.94,55.11 82.32,55.11 85.37,58.16 85.37,61.59
  BOTTOM w0.127: v1(42.93,140.89) 42.86,140.82 41.65,140.82 41.44,141.02 U64.43
EMIFA20: length 211.4
  TOP w0.102: v2(90.04,65.94) 90,65.94 U24.C36
  L5 w0.102: 90.4,61.59 90.4,65.58 v2(90.04,65.94)
  L5 w0.114: v1(38.61,143.64) 37.97,143 34.97,143 31.93,139.96 31.93,138.06 30.85,136.98 30.16,136.98 29.69,137.44 29.22,137.44 27.15,135.37 27.15,114.64 24.49,111.98 23.94,111.98 23.24,111.28 19.9,111.28 13.81,105.2 13.81,90.09 17.58,86.31 17.58,79.22 15.58,77.22 14.18,77.22 11.59,74.63 11.59,60.7 12.78,59.51 12.78,51.53 16.07,48.24 39.96,48.24 41.69,49.97 47.63,49.97 48.43,50.77 84.79,50.77 92.01,57.98 92.01,59.62 90.4,61.22 90.4,61.59
  BOTTOM w0.127: U64.41 40.15,142.02 39.77,141.64 39.39,141.64 38.61,142.43 v1(38.61,143.64)
EMIFA21: length 144.9
  TOP w0.102: v2(84.02,65.94) 84,65.94 U24.J36
  L5 w0.102: v2(84.02,65.94) 83.59,66.37 80.97,66.37 80.64,66.05 80.64,66.01 79.94,65.31 79.87,65.31 79.64,65.08 79.64,64.72 79.26,64.34 77.98,64.34 77.96,64.32
  L5 w0.114: 77.96,64.32 66.07,64.32 65.71,64.68 64.32,64.68 64.18,64.54 53.79,64.54 52.57,65.75 52.57,65.79 46.5,71.86 46.5,72.86 41.9,77.46 41.9,77.46 38.51,80.85 38.51,81.06 37.85,81.72 37.85,85.35 38.17,85.67 38.17,88.58 38.43,88.84 38.43,90.04 37.84,90.64 37.84,95.14 40.22,97.52 40.22,101.61 38.68,103.15 38.68,113.36 40.91,115.58 40.91,117.15 41.83,118.08 v1(41.83,120.75)
  L8 w0.114: v1(39.62,142.75) 39.4,142.52 39.4,142.52 39.11,142.24 31.83,142.24 29.41,144.66 29.41,145.28 v1(29.38,145.31)
  L10 w0.114: v1(41.83,120.75) 38.98,120.75 35.66,124.07 35.66,124.77 35.04,125.39 35.04,125.83 34.68,126.19 33.67,126.19 32.82,127.04 32.82,134.55 30.23,137.15 30.23,139.06 29.9,139.4 29.9,140.03 28.62,141.31 28.62,144.95 28.95,145.28 29.35,145.28 v1(29.38,145.31)
  BOTTOM w0.127: v1(39.62,142.75) 39.85,142.52 U64.40
EMIFA22: length 150.5
  TOP w0.102: U24.H38 84.96,63.98 v2(84.96,63.83)
  L5 w0.102: v2(84.96,63.83) 85.2,63.6 85.2,62.07 84.72,61.59
  L5 w0.114: 84.72,61.59 84.72,57.85 82.22,55.35 57.04,55.35 51.23,61.16 39.77,61.16 36.77,64.17 36.77,70.35 35.22,71.9 35.22,73.19 30.96,77.45 30.96,88.55 31.75,89.35 31.75,90.52 32.41,91.18 32.41,105.43 32,105.84 32,114.43 32.51,114.94 32.51,120.59 34.64,122.72 36.3,122.72 37.21,123.62 37.21,127.17 37.5,127.45 37.5,133.93 43.61,140.04 43.61,142.76 43.26,143.11 42.56,143.11 v1(42.39,142.94)
  BOTTOM w0.127: v1(42.39,142.94) 41.82,143.52 U64.38
EMIFA23: length 203
  TOP w0.102: v2(89.05,65.94) 89,65.94 U24.D36
  L5 w0.102: v2(89.05,65.94) 89.42,65.57 89.42,62.68 89.9,62.19 89.9,61.59
  L5 w0.114: 89.9,61.59 89.9,57.91 83.24,51.25 48.23,51.25 47.43,50.45 41.49,50.45 40.9,49.86 32.03,49.86 31.41,49.24 24.87,49.24 24.23,49.89 17.9,49.89 17.46,50.32 14.67,50.32 13.26,51.73 13.26,59.71 13.21,59.76 13.21,64.37 14.22,65.39 14.22,72.14 15.13,73.04 15.13,75.87 18.07,78.8 18.07,86.51 14.29,90.29 14.29,105 20.07,110.78 24.31,110.78 27.88,114.34 27.88,133.73 29.02,134.88 30.69,134.88 32.5,136.7 32.5,137.34 34.06,138.89 34.42,138.89 35.06,139.53 35.06,141.61 35.95,142.51 38.68,142.51 v1(39.55,143.38)
  BOTTOM w0.127: U64.37 39.96,144.02 39.55,143.62 v1(39.55,143.38)
EMIFBE0Z: length 126
  TOP w0.102: U24.H34 84.92,68.02 v2(85.09,68.02)
  L5 w0.102: 51.82,69.4 52.64,68.58 58,68.58 58.57,69.14 59.23,69.14 59.83,68.54 78.18,68.54 78.41,68.78 78.41,68.86 79.1,69.55 81.22,69.55 81.66,69.11 81.66,68.8 81.93,68.53 82.23,68.53 82.39,68.38 84.73,68.38 v2(85.09,68.02)
  L5 w0.114: 51.82,69.4 48.86,72.36 48.86,74.43 45.91,77.38 45.91,85.75 42.96,88.7 42.96,96.13 42.15,96.94 42.15,111.12 43.41,112.37 43.41,114.94 43.61,115.14 43.61,115.88 45.76,118.03 45.76,122.06 45.27,122.55 45.27,123.37 44.58,124.06 44.58,125.81 44.07,126.32 44.07,127.83 45.01,128.78 46.99,128.78 47.39,129.18 47.39,131.23 48.03,131.87 48.03,138.95 46.22,140.77 46.22,141.33 45.3,142.24 v1(44.7,142.24)
  BOTTOM w0.127: v1(44.7,142.24) 45.26,142.8 45.26,143.43 44.59,144.11 42,144.11 41.59,144.52 U64.36
EMIFBE1Z: length 121.7
  TOP w0.102: U24.H33 84.99,68.95 v2(85.02,68.95)
  L5 w0.102: v2(85.02,68.95) 83.94,68.95 83.62,68.63 82.93,68.63 82.42,69.13 82.42,69.37 81.03,70.76 78.42,70.76 78.14,70.48 58.3,70.48 58.26,70.52 52.14,70.52 51.82,70.84
  L5 w0.114: v1(43.7,145.4) 43.7,145.05 44.29,144.46 44.29,144.45 44.55,144.19 45.04,144.19 45.9,143.33 45.9,141.99 46.46,141.43 46.46,140.87 48.27,139.05 48.27,137.15 49.4,136.02 49.4,128.7 48.52,127.82 48.52,127.39 45.99,124.86 45.99,122.85 46.75,122.09 46.75,113.65 48.89,111.51 48.89,101.19 46.73,99.03 46.73,77.59 49.64,74.68 49.64,73.02 51.82,70.84
  BOTTOM w0.127: U64.35 41.45,145.02 42.1,144.37 42.47,144.37 43.49,145.4 v1(43.7,145.4)
EMIFCE0Z: length 135.2
  TOP w0.102: v2(85.99,68.98) 85.96,68.98 U24.G33
  TOP w0.127: v1(43.81,160.53) 43.81,160.78 44.27,161.23 R27.2
  L5 w0.102: 51.82,71.56 51.89,71.56 51.95,71.51 81.27,71.51 82.3,70.48 84.45,70.48 85.96,68.98 v2(85.99,68.98)
  L5 w0.114: 51.82,71.56 50.15,73.22 50.15,74.94 47.21,77.88 47.21,98.83 49.37,100.99 49.37,111.92 47.31,113.98 47.31,122.93 47.48,123.1 47.48,124.54 49.97,127.03 49.97,136.17 49.59,136.55 49.59,137.99 48.76,138.82 48.76,139.25 46.94,141.07 46.94,141.63 46.38,142.19 46.38,144.35 43.37,147.36 43.37,147.88 43.49,148.01 43.94,148.46 43.94,149.52 42.08,151.39 42.08,152.79 42.47,153.19 42.47,154.76 42.33,154.9 42.33,157.66 43.19,158.52 43.19,158.89 43.61,159.31 43.61,160.32 v1(43.81,160.53)
EMIFCE1Z: length 134.2
  TOP w0.102: U24.G32 v2(86.02,70.92)
  L5 w0.102: v2(86.02,70.92) 85.67,70.92 85.09,71.5 84.9,71.5 84.4,72 84.4,72.08 83.96,72.52 64.74,72.52 64.49,72.77 64.49,72.98 64,73.47 61,73.47 60.84,73.63 57.67,73.63 57.57,73.53 51.87,73.53 51.82,73.58
  L5 w0.114: 51.82,73.58 51.19,73.58 50.69,74.09 50.69,75.2 47.69,78.19 47.69,98.16 50.57,101.04 50.57,111.6 52.3,113.33 56.47,113.33 59.05,115.92 59.05,120.78 59.34,121.06 59.34,131.53 56.75,134.11 53.34,134.11 53.34,134.11 53.14,134.11 53.14,134.11 51.64,134.11 50.7,135.06 50.7,136.55 50.3,136.95 50.3,138.26 49.57,139 49.57,139.42 48.7,140.28 48.7,141.39 47.59,142.51 47.59,142.52 47.35,142.76 47.35,144.48 44.37,147.45 44.33,147.45 v1(44.13,147.65)
  BOTTOM w0.127: U64.33 41.53,146.02 42.3,145.26 42.72,145.26 43.9,146.44 43.9,147.43 44.12,147.65 v1(44.13,147.65)
EMIFCE2Z: length 138.8
  TOP w0.102: U24.G34 85.53,68.42 v2(86,67.94)
  L5 w0.102: 80.9,63.2 80.9,63.94 81.64,64.68 81.64,65.08 81.86,65.3 82.54,65.3 82.79,65.56 84.18,65.56 84.4,65.78 84.4,66.88 84.86,67.34 85.24,67.34 85.85,67.94 v2(86,67.94)
  L5 w0.114: 80.9,63.2 80.03,62.33 74.91,62.33 74.59,62.64 74.25,62.64 73.76,62.15 70.7,62.15 69.73,63.13 65.92,63.13 65.9,63.1 57.39,63.1 56.82,62.54 53.86,62.54 45.53,70.86 45.53,72.46 44.21,73.79 39.82,73.79 38.35,75.25 38.35,78.83 35.88,81.3 35.88,89.23 36.73,90.08 36.73,100.4 37.72,101.39 37.72,113.76 39.94,115.98 39.94,125.19 40.16,125.41 40.16,128.53 42.87,131.24 43.11,131.24 43.46,131.59 43.46,131.85 43.66,132.05 43.69,132.05 43.77,132.13 44.7,132.13 45.71,133.13 45.71,137.68 43.85,139.54 43.85,144.21 42.48,145.57 v1(42.48,145.75)
  BOTTOM w0.127: U64.32 41.46,146.52 42.27,145.72 42.46,145.72 42.46,145.75 v1(42.48,145.75)
EMIFCE3Z: length 207.4
  TOP w0.102: v2(88.01,65.94) 88,65.94 U24.E36
  L5 w0.102: v2(88.01,65.94) 88.43,65.52 88.43,64.68 88.97,64.15 88.97,62.47 89.36,62.08 89.36,61.59
  L5 w0.114: 89.36,61.59 89.36,58.05 83.04,51.73 48.03,51.73 47.23,50.93 41.29,50.93 40.76,50.4 18.06,50.4 17.66,50.8 14.87,50.8 14.15,51.53 14.15,51.56 13.86,51.85 13.86,61.99 14.95,63.08 14.95,71.84 15.86,72.74 15.86,73.12 19.28,76.55 19.28,86.43 16.35,89.36 16.35,93.08 15.02,94.42 15.02,102.59 16.92,104.49 16.92,106.29 20.68,110.05 24.65,110.05 25.99,111.39 27.12,111.39 27.73,112.01 27.73,113.13 28.6,114 28.6,133.43 29.26,134.09 31.47,134.09 33.23,135.84 33.23,136.79 34.21,137.78 34.52,137.78 35.54,138.79 35.54,139.16 36.46,140.08 38.47,140.08 39.8,141.41 39.86,141.41 40.75,142.3 40.75,147 41.59,147.83 42.04,147.83 v1(42.3,147.57)
  BOTTOM w0.127: v1(42.3,147.57) 42.25,147.52 U64.30
EMIFD0: length 133.6
  TOP w0.102: v2(81.02,69.95) 80.55,70.42 U24.M32
  TOP w0.127: U65.2 45.09,128.83 45.09,128.27 v2(45.09,128.27)
  L5 w0.102: 51.82,69.75 52.22,69.34 56.16,69.34 56.17,69.34 57.68,69.34 57.76,69.41 58.07,69.41 58.14,69.35 59.7,69.35 59.7,69.34 62.26,69.34 62.26,69.34 78.32,69.34 79.34,70.36 80.61,70.36 v2(81.02,69.95)
  L5 w0.114: v2(45.09,128.27) 45.17,128.18 45.17,123.82 45.51,123.49 45.51,122.65 46,122.16 46,113.7 48.27,111.42 48.27,101.25 46.25,99.23 46.25,77.38 49.1,74.53 49.1,72.46 51.82,69.75
  L10 w0.114: v2(42.04,159) 42.29,158.75 42.29,157.05 41.02,155.77 41.02,153.36 41.23,153.15 41.23,151.26 40.65,150.69 40.65,145.19 41.71,144.13 43.92,144.13 44.35,143.71 44.68,143.71 45.96,142.43 45.96,138.96 44.61,137.61 44.61,135.5 44.06,134.94 44.06,134.13 44.17,134.01 44.17,132.75 44.85,132.06 44.85,129.29 45.09,129.06 v2(45.09,128.27)
  BOTTOM w0.102: NAND1.H4 40.14,158.67 41.71,158.67 v2(42.04,159)
