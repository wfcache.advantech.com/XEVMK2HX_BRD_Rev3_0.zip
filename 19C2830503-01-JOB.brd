# Allegro board 19C2830503-01-JOB.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SOC_DDR3A_EDQ26: length 47.3
  TOP w0.102: v2(85.99,96.04) 86.37,96.42 U24.F6
  TOP w0.127: DIMM1.63 115.02,91.75 v1(115.72,92.44)
  L10 w0.102: 92.43,92.3 91.19,92.3 90.14,93.34 88.53,93.34 88.42,93.46 88.42,94.79 88.42,94.79 88.42,95.1 88.42,95.8 88.3,95.91 86.11,95.91 v2(85.99,96.04)
  L10 w0.114: v1(115.72,92.44) 115.72,92.05 115.6,91.93 109.53,91.93 108.8,92.66 106.49,92.66 106.38,92.77 106.38,93.38 106.26,93.5 103.84,93.5 103.72,93.38 103.72,92.34 103.61,92.23 103.38,92.23 103.27,92.34 103.27,93.41 103.15,93.52 102.92,93.52 102.81,93.41 102.81,92.34 102.69,92.23 102.47,92.23 102.35,92.34 102.35,92.93 102.24,93.04 102.01,93.04 101.89,92.93 101.89,92.34 101.78,92.23 101.55,92.23 101.44,92.34 101.44,92.54 101.32,92.66 101.09,92.66 100.98,92.54 100.98,92.34 100.87,92.23 100.64,92.23 100.52,92.34 100.52,92.54 100.41,92.66 100.18,92.66 100.07,92.54 100.07,92.34 99.95,92.23 99.72,92.23 99.61,92.34 99.61,92.54 99.49,92.66 99.26,92.66 99.15,92.54 99.15,92.34 99.04,92.23 98.81,92.23 98.69,92.34 98.69,92.54 98.58,92.66 98.35,92.66 98.24,92.54 98.24,92.34 98.12,92.23 97.89,92.23 97.78,92.34 97.78,92.54 97.66,92.66 97.44,92.66 97.32,92.54 97.32,92.34 97.21,92.23 96.98,92.23 96.86,92.34 96.86,92.54 96.75,92.66 96.52,92.66 96.41,92.54 96.41,92.34 96.29,92.23 96.06,92.23 95.95,92.34 95.95,92.54 95.84,92.66 95.61,92.66 95.49,92.54 95.49,92.34 95.38,92.23 95.15,92.23 95.04,92.34 95.04,92.54 94.92,92.66 94.69,92.66 94.58,92.54 94.58,92.34 94.46,92.23 94.24,92.23 94.12,92.34 94.12,92.54 94.01,92.66 92.79,92.66 92.43,92.3
SOC_DDR3A_EDQ27: length 47.4
  TOP w0.102: v2(91.92,93.93) 91.52,94.33 U24.A8
  TOP w0.127: DIMM1.65 115.19,91.15 116.29,92.25 116.29,93.43 v1(116.22,93.51)
  L10 w0.114: v1(116.22,93.51) 116.22,91.38 116.33,91.26 116.8,91.26 116.92,91.38 116.92,94.35 116.8,94.46 115.95,94.46 115.29,95.12 111.28,95.12 110.17,96.23 110.17,97.34 110.03,97.49 109.83,97.49 109.72,97.37 109.72,96.28 109.6,96.16 109.37,96.16 109.26,96.28 109.26,97.37 109.14,97.49 108.92,97.49 108.8,97.37 108.8,96.25 108.69,96.14 108.46,96.14 108.34,96.25 108.34,97.37 108.23,97.49 108,97.49 107.89,97.37 107.89,96.23 107.77,96.11 107.54,96.11 107.43,96.23 107.43,97.4 107.33,97.5 107.07,97.5 106.97,97.4 106.97,96.35 106.86,96.24 95.94,96.24 94.69,95 93.29,95 92.81,94.51 92.51,94.51 v2(91.92,93.93)
SOC_DDR3A_EDQ28: length 47.3
  TOP w0.102: U24.B8 90.52,94.42 91.02,93.92 v2(91.02,93.93)
  TOP w0.127: v1(119.32,94.04) 119.96,94.67 120.4,94.67 120.62,94.45 DIMM1.54
  L10 w0.102: 90.63,95.4 90.63,94.67 91.02,94.28 v2(91.02,93.93)
  L10 w0.114: v1(119.32,94.04) 119.32,94.79 119.48,94.95 121.37,94.95 121.49,95.06 121.49,97.19 121.37,97.31 117.2,97.31 116.47,96.58 115.13,96.58 114.77,96.94 114.77,97.52 114.43,97.87 111.76,97.87 110.29,99.34 108.49,99.34 108.38,99.23 108.38,99 108.26,98.88 107.87,98.88 107.76,99 107.76,99.23 107.64,99.34 107.26,99.34 107.15,99.23 107.15,99.02 107.03,98.91 106.64,98.91 106.53,99.02 106.53,99.23 106.41,99.34 106.02,99.34 105.9,99.23 105.9,99.02 105.79,98.91 105.4,98.91 105.28,99.02 105.28,99.23 105.17,99.34 104.77,99.34 104.66,99.23 104.66,99.02 104.55,98.91 104.15,98.91 104.04,99.02 104.04,99.23 103.92,99.34 101.75,99.34 101.42,99.01 101.42,98.43 100.86,97.87 94.34,97.87 92.95,96.48 91.71,96.48 90.63,95.4
SOC_DDR3A_EDQ29: length 47.3
  TOP w0.102: U24.G6 v2(86.02,96.92)
  TOP w0.127: DIMM1.56 120.35,93.85 v1(120.11,94.09)
  L10 w0.114: v1(120.11,94.09) 120.11,93.64 120.22,93.52 121.83,93.52 121.95,93.64 121.95,97.88 121.83,97.99 117.02,97.99 116.55,98.46 111.98,98.46 110.62,99.82 101.37,99.82 100.94,99.39 100.94,98.71 100.69,98.46 94.22,98.46 93.23,97.47 86.56,97.47 v2(86.02,96.92)
SOC_DDR3A_EDQ30: length 47.3
  TOP w0.102: v2(86.02,94.92) 85.52,95.42 U24.G7
  TOP w0.127: DIMM1.66 120.34,90.85 v1(120.28,90.79)
  L10 w0.102: v2(86.02,94.92) 86.58,94.36 86.58,92.68 86.93,92.33 90.3,92.33 90.98,91.64
  L10 w0.114: 90.98,91.64 92.61,91.64 93,91.25 108.88,91.25 110.13,90 112.34,90 112.45,90.11 112.45,90.84 112.56,90.96 112.79,90.96 112.91,90.84 112.91,90.11 113.02,90 113.25,90 113.36,90.11 113.36,90.84 113.48,90.96 113.71,90.96 113.82,90.84 113.82,90.11 113.94,90 114.16,90 114.28,90.11 114.28,90.74 114.39,90.86 114.62,90.86 114.74,90.74 114.74,90.11 114.85,90 115.02,90 115.14,90.11 115.14,90.67 115.25,90.78 115.48,90.78 115.6,90.67 115.6,90.11 115.71,90 115.94,90 116.05,90.11 116.05,90.18 116.17,90.3 116.4,90.3 116.51,90.18 116.51,90.11 116.62,90 116.85,90 116.97,90.11 116.97,90.18 117.08,90.3 117.31,90.3 117.42,90.18 117.42,90.11 117.54,90 117.77,90 117.88,90.11 117.88,90.18 118,90.3 118.22,90.3 118.34,90.18 118.34,90.11 118.45,90 118.68,90 118.8,90.11 118.8,90.18 118.91,90.3 119.14,90.3 119.25,90.18 119.25,90.11 119.37,90 119.79,90 120.28,90.49 v1(120.28,90.79)
SOC_DDR3A_EDQ31: length 47.4
  TOP w0.102: U24.D7 88.51,95.42 v2(88.04,94.95)
  TOP w0.127: DIMM1.68 120.03,90.25 119.64,90.64 v1(119.64,90.79)
  L10 w0.102: 91.01,91.97 90.45,92.53 87.76,92.53 87.55,92.74 87.55,94.46 88.04,94.94 v2(88.04,94.95)
  L10 w0.114: 91.01,91.97 92.86,91.97 93.12,91.72 104.25,91.72 104.37,91.83 104.37,92.93 104.48,93.04 104.71,93.04 104.82,92.93 104.82,91.83 104.94,91.72 105.17,91.72 105.28,91.83 105.28,92.93 105.39,93.04 105.62,93.04 105.74,92.93 105.74,91.83 105.85,91.72 106.08,91.72 106.19,91.83 106.19,92.04 106.31,92.15 106.54,92.15 106.65,92.04 106.65,91.83 106.77,91.72 107.05,91.72 107.19,91.86 107.19,92.04 107.31,92.15 107.53,92.15 107.65,92.04 107.65,91.86 107.79,91.72 107.97,91.72 108.11,91.86 108.11,92.04 108.22,92.15 108.45,92.15 108.56,92.04 108.56,91.86 108.7,91.72 109.09,91.72 109.4,91.41 110.49,91.41 110.61,91.3 110.61,90.77 110.72,90.65 110.95,90.65 111.06,90.77 111.06,91.3 111.18,91.41 111.41,91.41 111.52,91.3 111.52,90.74 111.63,90.63 111.86,90.63 111.98,90.74 111.98,91.3 112.09,91.41 115.49,91.41 116.12,90.79 v1(119.64,90.79)
SOC_DDR3A_EDQ32: length 53.9
  TOP w0.102: v2(88.02,85.92) 87.52,86.42 U24.E16
  TOP w0.127: v1(114.93,68.79) 114.93,68.74 114.54,68.35 DIMM1.133
  L10 w0.102: v2(88.02,85.92) 87.66,85.92 87.6,85.98 87.6,87.1 87.83,87.33 92.68,87.33
  L10 w0.114: 92.68,87.33 92.94,87.07 93.68,87.07 95.12,88.52 100.53,88.52 100.72,88.34 100.72,88.13 100.83,88.01 101.06,88.01 101.17,88.13 101.17,88.4 101.29,88.52 101.52,88.52 101.63,88.4 101.63,88.13 101.75,88.01 101.97,88.01 102.09,88.13 102.09,88.4 102.2,88.52 102.43,88.52 102.55,88.4 102.55,88.13 102.66,88.01 102.89,88.01 103,88.13 103,88.4 103.12,88.52 103.35,88.52 103.46,88.4 103.46,88.13 103.57,88.01 103.8,88.01 103.92,88.13 103.92,88.4 104.03,88.52 104.26,88.52 104.37,88.4 104.37,88.13 104.49,88.01 104.72,88.01 104.83,88.13 104.83,88.4 104.95,88.52 105.17,88.52 105.29,88.4 105.29,88.13 105.4,88.01 105.63,88.01 105.75,88.13 105.75,88.4 105.86,88.52 106.09,88.52 106.2,88.4 106.2,88.13 106.32,88.01 106.74,88.01 110.41,84.34 110.41,83.21 114.38,79.25 114.38,73.27 116.1,71.54 116.1,69.74 116.22,69.62 116.62,69.62 116.74,69.51 116.74,69.23 116.62,69.11 115.05,69.11 114.93,69 v1(114.93,68.79)
SOC_DDR3A_EDQ33: length 53.9
  TOP w0.102: v2(86.02,85.92) 85.52,86.42 U24.G16
  TOP w0.127: DIMM1.135 v1(115.17,67.75)
  L10 w0.102: 92.38,85.93 92,86.31 89.81,86.31 89.46,85.95 89.46,85.67 89.31,85.52 86.42,85.52 v2(86.02,85.92)
  L10 w0.114: v1(115.17,67.75) 115.43,67.75 115.54,67.63 115.54,67.35 115.43,67.23 114.81,67.23 113.36,68.68 113.36,78.69 105.55,86.5 105.55,86.86 105.44,86.97 105.21,86.97 105.1,86.86 105.1,85.99 104.98,85.88 104.75,85.88 104.64,85.99 104.64,86.86 104.52,86.97 104.3,86.97 104.18,86.86 104.18,86.5 104.07,86.39 103.84,86.39 103.72,86.5 103.72,86.86 103.61,86.97 103.38,86.97 103.27,86.86 103.27,86.27 103.15,86.16 102.92,86.16 102.81,86.27 102.81,86.86 102.7,86.97 102.47,86.97 102.35,86.86 102.35,86.22 102.24,86.11 101.97,86.11 101.89,86.19 101.89,86.89 101.77,87 94.99,87 93.92,85.93 92.38,85.93
SOC_DDR3A_EDQ34: length 54.2
  TOP w0.102: U24.F16 86.52,86.42 v2(87.02,85.92)
  TOP w0.127: DIMM1.145 116.21,64.75 v1(117.77,66.3)
  L10 w0.102: 92.72,87.69 92.56,87.53 87.73,87.53 87.4,87.2 87.4,86.31 v2(87.02,85.92)
  L10 w0.114: 92.72,87.69 93.61,87.69 94.89,88.98 106.43,88.98 110.87,84.53 110.87,83.4 114.83,79.44 114.83,73.46 117.77,70.52 v1(117.77,66.3)
SOC_DDR3A_EDQ35: length 53.8
  TOP w0.102: v2(86.08,84.99) 85.95,84.99 U24.G17
  TOP w0.127: v1(116.95,63.33) 116.14,64.15 DIMM1.147
  L10 w0.102: 92.71,83.06 92.46,83.31 88.98,83.31 88.49,83.79 88.49,83.99 88.15,84.33 86.74,84.33 v2(86.08,84.99)
  L10 w0.114: v1(116.95,63.33) 116.95,63.69 116.7,63.94 114.2,63.94 113.35,64.8 111.73,64.8 108.81,67.72 108.81,77.21 105.02,81 103.79,81 102.19,82.6 101.55,82.6 101.24,82.3 101.01,82.3 100.9,82.41 100.9,82.94 100.79,83.06 100.56,83.06 100.44,82.94 100.44,82.18 100.33,82.07 100.1,82.07 99.99,82.18 99.99,82.94 99.87,83.06 99.64,83.06 99.53,82.94 99.53,82.41 99.41,82.3 99.19,82.3 99.07,82.41 99.07,82.94 98.96,83.06 92.71,83.06
SOC_DDR3A_EDQ36: length 53.8
  TOP w0.102: U24.D16 88.52,86.42 v2(89.02,85.92)
  TOP w0.127: DIMM1.134 117.07,68.05 v1(116.77,67.75)
  L10 w0.102: v2(89.02,85.92) 89.61,86.51 92.2,86.51 92.3,86.41
  L10 w0.114: 92.3,86.41 93.75,86.41 94.89,87.55 105.56,87.55 105.91,87.21 106.07,87.21 106.27,87.42 106.44,87.42 106.6,87.26 106.6,87.09 106.39,86.89 106.39,86.73 106.55,86.56 106.71,86.56 106.92,86.77 107.08,86.77 107.24,86.61 107.24,86.45 107.04,86.24 107.04,86.08 107.2,85.92 107.36,85.92 107.57,86.12 107.73,86.12 107.89,85.96 107.89,85.8 107.68,85.59 107.68,85.43 107.85,85.27 108.01,85.27 108.21,85.48 108.38,85.48 108.54,85.32 108.54,85.15 108.33,84.95 108.33,84.79 108.49,84.62 108.65,84.62 108.86,84.83 109.02,84.83 109.18,84.67 109.18,84.51 108.98,84.3 108.98,83.8 113.82,78.96 113.82,69.1 114.63,68.29 116.6,68.29 116.84,68.53 117.16,68.53 117.27,68.41 117.27,67.87 117.16,67.75 v1(116.77,67.75)
SOC_DDR3A_EDQ37: length 53.8
  TOP w0.102: U24.D17 v2(89.02,84.92)
  TOP w0.127: DIMM1.136 119.67,67.45 v1(118.48,66.25)
  L10 w0.102: 93.18,84.53 90.87,84.53 90.6,84.8 90.6,85.19 90.45,85.34 89.84,85.34 89.42,84.92 v2(89.02,84.92)
  L10 w0.114: 93.18,84.53 102.31,84.53 103.89,82.96 104.16,82.96 104.28,82.84 104.28,82.51 104.39,82.4 104.62,82.4 104.74,82.51 104.74,82.84 104.8,82.91 105.49,82.91 106.12,82.27 106.12,81.87 109.98,78 111.76,78 111.87,77.89 111.87,68.21 112.21,67.87 114.77,65.31 116.47,65.31 116.58,65.43 116.58,67.17 116.7,67.28 116.93,67.28 117.04,67.17 117.04,65.43 117.16,65.31 118.26,65.31 118.48,65.53 v1(118.48,66.25)
SOC_DDR3A_EDQ38: length 53.8
  TOP w0.102: U24.F17 v2(87.02,84.92)
  TOP w0.127: DIMM1.142 120.23,65.65 v1(120.15,65.57)
  L10 w0.102: v2(87.02,84.92) 87.41,84.53 89.95,84.53 90.45,84.03 90.45,83.77 90.7,83.52 93.18,83.52
  L10 w0.114: 93.18,83.52 101.92,83.52 103.98,81.46 105.21,81.46 110.96,75.71 110.96,70.52 110.84,70.41 109.44,70.41 109.32,70.29 109.32,69.09 109.6,68.81 110.74,68.81 110.85,68.69 110.85,66.33 111.11,66.07 112.72,66.07 114.39,64.4 118.87,64.4 119.14,64.67 119.39,64.92 119.39,64.92 120.36,64.92 120.47,65.04 120.47,65.45 120.36,65.57 v1(120.15,65.57)
SOC_DDR3A_EDQ39: length 53.8
  TOP w0.102: U24.E18 v2(88.02,83.92)
  TOP w0.127: v1(119.59,64.04) 119.59,64.17 120.47,65.05 DIMM1.144
  L10 w0.102: 93.18,82.54 87.99,82.54 87.64,82.89 87.64,83.54 v2(88.02,83.92)
  L10 w0.114: v1(119.59,64.04) 119.59,63.72 119.71,63.6 120.74,63.6 120.85,63.49 120.85,63.26 120.74,63.14 118.58,63.14 118.3,62.87 114.47,62.87 113,64.34 111.55,64.34 108.36,67.53 108.36,75.84 106.32,77.88 106.32,79.05 104.83,80.54 103.6,80.54 102.42,81.72 100.92,81.72 100.71,81.51 98.45,81.51 97.42,82.54 93.18,82.54
SOC_DDR3A_EDQ40: length 53.3
  TOP w0.102: U24.C19 v2(90.02,82.92)
  TOP w0.127: v1(116.27,61.91) 116.27,62.06 115.38,62.95 DIMM1.151
  L8 w0.102: v2(90.02,82.92) 90.43,83.34 92.15,83.34 93.17,82.32 93.18,82.32
  L8 w0.114: 93.18,82.32 96.19,82.32 100.03,78.49 100.45,78.49 101.8,77.14 101.8,76.59 103.27,75.11 103.88,75.11 105.16,73.84 105.16,72.24 105.51,71.89 106.59,71.89 106.66,71.96 106.66,72.56 106.78,72.67 107.01,72.67 107.12,72.56 107.12,72.25 107.23,72.14 107.46,72.14 107.58,72.25 107.58,72.56 107.69,72.67 107.92,72.67 108.03,72.56 108.03,72.08 108.28,71.83 108.49,71.83 108.6,71.72 108.6,71.54 108.72,71.42 108.94,71.42 109.06,71.54 109.06,71.92 109.17,72.03 109.4,72.03 109.52,71.92 109.52,71.54 109.63,71.42 109.86,71.42 109.97,71.54 109.97,71.95 110.09,72.06 110.32,72.06 110.43,71.95 110.43,71.54 110.55,71.42 110.77,71.42 110.89,71.54 110.89,72.35 111,72.47 111.23,72.47 111.35,72.35 111.35,71.54 111.46,71.42 111.69,71.42 111.8,71.54 111.8,71.72 111.92,71.83 112.94,71.83 113.06,71.72 113.06,65.95 113.06,64.49 113.87,63.67 113.87,61.69 114.59,60.97 115.56,60.97 116.27,61.68 v1(116.27,61.91)
SOC_DDR3A_EDQ41: length 53.1
  TOP w0.102: U24.D19 v2(89.02,82.92)
  TOP w0.127: DIMM1.153 115.19,62.35 v1(115.63,61.91)
  L8 w0.102: v2(89.02,82.92) 89.63,83.54 92.35,83.54
  L8 w0.114: v1(115.63,61.91) 115.63,61.83 115.23,61.43 114.78,61.43 114.33,61.88 114.33,63.93 113.51,64.74 113.51,72.19 111.38,74.32 110.81,74.32 110.7,74.21 110.7,73.27 110.59,73.15 110.36,73.15 110.24,73.27 110.24,74.21 110.13,74.32 109.9,74.32 109.79,74.21 109.79,73.27 109.67,73.15 109.44,73.15 109.33,73.27 109.33,74.21 109.21,74.32 108.99,74.32 108.87,74.21 108.87,73.27 108.76,73.15 108.53,73.15 108.41,73.27 108.41,74.21 108.3,74.32 108.07,74.32 107.96,74.21 107.96,73.27 107.84,73.15 107.61,73.15 107.5,73.27 107.5,74.21 107.39,74.32 106.94,74.32 106.02,75.24 104.89,75.24 104.51,75.24 100.75,78.99 100.2,78.99 96.42,82.78 93.11,82.78 92.35,83.54
SOC_DDR3A_EDQ42: length 53.1
  TOP w0.102: U24.G18 v2(86.02,83.92)
  TOP w0.127: v1(115.61,59.62) 115.61,59.73 114.78,60.55 DIMM1.159
  L8 w0.102: v2(86.02,83.92) 86.49,83.45 86.49,82.68 86.84,82.32 89.23,82.32 89.53,82.02 89.53,81.56 89.79,81.31 92.18,81.31 93.18,80.3
  L8 w0.114: 93.18,80.3 93.92,80.3 99.26,74.96 99.26,72.64 99.45,72.46 101.9,72.46 102.07,72.29 102.08,72.29 102.08,70.1 102.87,69.32 104.17,69.32 105.47,68.01 108.42,68.01 108.51,67.93 108.51,66.87 108.62,66.75 108.89,66.75 108.89,66.75 109.27,66.75 109.27,66.75 109.78,66.75 110.13,66.39 110.13,62.3 111.81,60.63 112.3,60.63 114.12,58.8 115.06,58.8 115.13,58.74 115.13,57.9 115.24,57.78 115.49,57.78 115.61,57.9 115.61,58.43 115.72,58.54 116.04,58.54 116.15,58.66 116.15,58.89 116.04,59 115.72,59 115.61,59.11 v1(115.61,59.62)
SOC_DDR3A_EDQ43: length 53.1
  TOP w0.102: v2(87.08,83.05) 87.08,83.32 86.99,83.42 U24.F19
  TOP w0.127: v1(114.9,59.62) 114.57,59.95 DIMM1.161
  L8 w0.102: v2(87.08,83.05) 87.08,83.05 87.08,82.77 87.33,82.52 90.26,82.52 90.58,82.21 90.58,81.71 90.78,81.51 92.09,81.51 92.35,81.51 93.09,80.77 93.18,80.77
  L8 w0.114: v1(114.9,59.62) 114.9,59.5 114.78,59.39 114.18,59.39 112.49,61.08 112,61.08 110.59,62.49 110.59,66.91 110.3,67.21 109.08,67.21 108.97,67.32 108.97,68.44 109.08,68.55 110.63,68.55 110.74,68.67 110.74,69.05 110.63,69.16 108.6,69.16 108.49,69.05 108.49,68.59 108.37,68.48 108.15,68.48 108.03,68.59 108.03,69.28 107.92,69.39 107.69,69.39 107.57,69.28 107.57,68.57 107.48,68.47 107.21,68.47 107.12,68.57 107.12,69.18 107,69.29 106.77,69.29 106.66,69.18 106.66,68.54 106.59,68.47 106.27,68.47 106.2,68.54 106.2,69.05 106.09,69.16 105.59,69.16 103.77,70.98 103.77,71.65 103.77,72.52 103.54,72.75 102.49,72.75 100.94,74.3 99.83,74.3 99.72,74.41 99.72,75.14 99.44,75.42 94.09,80.77 93.18,80.77
SOC_DDR3A_EDQ44: length 53.3
  TOP w0.102: v2(85.95,82.85) 85.52,83.29 U24.G19
  TOP w0.127: v1(120.27,64.1) 120.53,63.85 DIMM1.148
  L8 w0.102: 93.03,85.52 86.08,85.52 85.64,85.08 85.64,83.17 v2(85.95,82.85)
  L8 w0.114: v1(120.27,64.1) 120.7,64.53 120.7,66.4 120.45,66.65 119.02,66.65 118.08,67.59 118.08,72.72 113.13,77.67 109.02,77.67 107.72,78.97 105.25,78.97 101.97,82.24 101.23,82.24 98.29,85.19 93.36,85.19 93.03,85.52
SOC_DDR3A_EDQ45: length 53.3
  TOP w0.102: U24.B18 v2(91.02,83.92)
  TOP w0.127: DIMM1.150 117.7,63.25 v1(117.64,63.31)
  L8 w0.102: v2(91.02,83.92) 91.4,84.3 92.58,84.3
  L8 w0.114: 92.58,84.3 93.12,83.77 97.77,83.77 100.32,81.21 100.32,80.84 103.64,77.52 103.7,77.52 104.22,77.52 105.08,76.65 106.24,76.65 106.59,76.3 110.69,76.3 114.43,72.57 114.43,70.99 114.54,70.87 115.74,70.87 115.83,70.78 115.83,70.51 115.74,70.41 114.54,70.41 114.43,70.3 114.43,70.07 114.54,69.96 115.71,69.96 115.82,69.84 115.82,69.61 115.71,69.5 114.54,69.5 114.43,69.39 114.43,68.39 114.54,68.28 115.73,68.28 115.83,68.17 115.83,67.14 115.71,67.03 114.59,67.03 114.48,66.92 114.48,65.44 114.59,65.33 114.98,65.33 115.1,65.21 115.1,64.96 115.21,64.85 115.44,64.85 115.56,64.96 115.56,65.21 115.67,65.33 116.33,65.33 117.64,64.02 v1(117.64,63.31)
SOC_DDR3A_EDQ46: length 53.2
  TOP w0.102: U24.D18 v2(89.02,83.92)
  TOP w0.127: v1(119.48,59.36) 120.37,60.25 DIMM1.160
  L8 w0.102: v2(89.02,83.92) 89.62,84.53 92.89,84.53
  L8 w0.114: v1(119.48,59.36) 119.9,59.78 119.9,60.01 119.78,60.12 119.6,60.12 119.48,60.24 119.48,60.46 119.6,60.58 119.77,60.58 119.89,60.69 119.89,61.35 119.77,61.46 119.47,61.46 119.35,61.58 119.35,61.81 119.47,61.92 119.78,61.92 119.9,62.03 119.9,62.41 119.01,63.3 118.76,63.3 118.64,63.18 118.64,62.73 118.55,62.63 118.23,62.63 118.14,62.73 118.14,64.17 116.87,65.44 116.87,66.85 116.29,67.44 116.29,71.36 110.88,76.76 106.78,76.76 105.56,77.98 103.89,77.98 100.78,81.08 100.78,81.4 97.96,84.23 97.38,84.23 93.19,84.23 92.89,84.53
SOC_DDR3A_EDQ47: length 53.6
  TOP w0.102: U24.F18 87,83.94 v2(87,83.82)
  TOP w0.127: DIMM1.162 120.51,59.65 v1(120.17,59.31)
  L8 w0.102: 93.18,84.72 92.6,85.3 86.86,85.3 86.64,85.08 86.64,84.18 v2(87,83.82)
  L8 w0.114: v1(120.17,59.31) 120.36,59.5 120.36,62.6 117.33,65.63 117.33,70.96 111.07,77.22 106.97,77.22 105.7,78.49 104.9,78.49 101.6,81.79 101.04,81.79 98.12,84.71 93.2,84.71 93.18,84.72
SOC_DDR3A_EDQ48: length 56
  TOP w0.102: U24.A20 v2(92.02,81.92)
  TOP w0.127: v1(116.27,59.6) 116.27,59.45 115.57,58.75 DIMM1.165
  L10 w0.114: v1(116.27,59.6) 116.38,59.49 116.98,59.49 117.09,59.6 117.09,61.18 116.83,61.44 116.21,61.44 116.1,61.33 116.1,60.19 115.98,60.07 115.75,60.07 115.64,60.19 115.64,61.35 115.52,61.47 115.3,61.47 115.18,61.35 115.18,60.19 115.07,60.07 114.84,60.07 114.72,60.19 114.72,61.06 114.61,61.17 114.14,61.17 114.02,61.29 114.02,61.81 113.91,61.93 113.68,61.93 113.56,61.81 113.56,61.25 113.45,61.14 113.22,61.14 113.11,61.25 113.11,61.81 112.99,61.93 112.76,61.93 112.65,61.81 112.65,61.29 112.54,61.17 111.9,61.17 110.82,62.26 110.82,63.77 107.44,67.15 107.44,69.85 106.55,70.74 106.55,74.74 104.98,76.32 104.98,77.83 102.93,79.87 102.47,79.87 102.41,79.81 102.41,79.59 102.29,79.48 102.06,79.48 101.95,79.59 101.95,80.02 101.84,80.14 101.61,80.14 101.49,80.02 101.49,79.59 101.38,79.48 101.15,79.48 101.04,79.59 101.04,80.02 100.92,80.14 99.72,80.14 99.6,80.02 99.6,79.57 99.49,79.45 99.26,79.45 99.15,79.57 99.15,80.02 99.03,80.14 98.51,80.14 97.07,81.58 92.9,81.58 92.56,81.92 v2(92.02,81.92)
SOC_DDR3A_EDQ49: length 56.1
  TOP w0.102: U24.B20 v2(91.02,81.92)
  TOP w0.127: v1(116.67,58.48) 116.34,58.15 DIMM1.167
  L10 w0.102: 92.57,81.51 91.43,81.51 v2(91.02,81.92)
  L10 w0.114: v1(116.67,58.48) 116.47,58.48 115.79,59.17 114.56,59.17 113.11,60.61 113.08,60.61 113.03,60.67 111.66,60.67 110.36,61.96 110.36,63.42 110.03,63.75 108.99,63.75 105.16,67.59 105.16,71.09 105.04,71.21 104.33,71.21 104.22,71.32 104.22,71.55 104.33,71.67 105.24,71.67 105.36,71.78 105.36,72.01 105.24,72.12 104.08,72.12 103.96,72.24 103.96,72.47 104.08,72.58 105.14,72.58 105.26,72.69 105.26,72.92 105.14,73.04 104.05,73.04 103.94,73.15 103.94,73.38 104.05,73.49 105.04,73.49 105.16,73.61 105.16,73.84 105.04,73.95 104.08,73.95 103.96,74.07 103.96,74.3 104.08,74.41 105.04,74.41 105.16,74.52 105.16,74.75 105.04,74.87 104.08,74.87 103.96,74.98 103.96,75.21 104.08,75.32 104.78,75.32 104.88,75.43 104.88,75.77 104.52,76.13 104.52,77.64 103.16,78.99 99.01,78.99 96.88,81.13 92.95,81.13 92.57,81.51
SOC_DDR3A_EDQ50: length 56
  TOP w0.102: U24.D20 v2(89.02,81.92)
  TOP w0.127: v1(116.88,56.6) 115.42,55.15 DIMM1.177
  L10 w0.102: 92.95,80.67 92.31,81.31 89.63,81.31 v2(89.02,81.92)
  L10 w0.114: 92.95,80.67 96.68,80.67 96.69,80.66 96.69,80.66 96.7,80.66 98.82,78.54 102.97,78.54 103.15,78.36 103.15,78.2 103.04,78.08 101.16,78.08 101.04,77.97 101.04,77.74 101.16,77.63 102.88,77.63 103,77.51 103,77.28 102.88,77.17 102.02,77.17 101.9,77.05 101.9,71.37 102.16,71.12 103.66,71.12 104.64,70.14 104.64,67.46 108.25,63.84 108.25,62.89 109.07,62.07 109.58,62.07 111.49,60.16 112.92,60.16 114.37,58.71 115.56,58.71 116.29,57.97 116.61,57.97 117.01,57.57 117.01,56.73 v1(116.88,56.6)
SOC_DDR3A_EDQ51: length 56.2
  TOP w0.102: v2(86.02,81.79) 86.02,81.92 U24.G20
  TOP w0.127: DIMM1.179 115.56,54.55 v1(117.56,56.55)
  L10 w0.102: 92.68,82.3 86.53,82.3 v2(86.02,81.79)
  L10 w0.114: 92.68,82.3 92.91,82.07 97.23,82.07 98.7,80.59 102.87,80.59 107.9,75.56 107.9,67.34 111.28,63.96 111.28,63.2 112.06,62.41 116.51,62.41 117.56,61.36 v1(117.56,56.55)
SOC_DDR3A_EDQ52: length 56
  TOP w0.102: U24.C21 v2(90.02,80.92)
  TOP w0.127: v1(118.98,57.79) 119.64,58.45 DIMM1.166
  L10 w0.102: v2(90.02,80.92) 90.63,80.31 90.63,79.77 90.87,79.53 92.46,79.53
  L10 w0.114: 92.46,79.53 92.71,79.27 95.61,79.27 98.88,76 98.88,69.02 99.57,68.33 101.32,68.33 102.06,67.59 102.06,62.99 104.37,60.68 105.79,60.68 108.42,58.05 112.46,58.05 114.51,55.99 117.71,55.99 118.15,56.43 118.15,59.96 118.26,60.07 118.83,60.07 118.95,59.96 118.95,57.83 v1(118.98,57.79)
SOC_DDR3A_EDQ53: length 56.2
  TOP w0.102: U24.E20 v2(88.02,81.92)
  TOP w0.127: v1(120.28,57.85) DIMM1.168
  L10 w0.102: v2(88.02,81.92) 88.62,81.32 88.62,79.78 88.87,79.53 89.95,79.53 90.4,79.08 90.4,78.84
  L10 w0.114: v1(120.28,57.85) 120.65,57.48 120.65,56.52 120.26,56.12 119.29,56.12 118.1,54.92 113.9,54.92 112.43,56.4 111.52,56.4 111.12,56 108.1,56 104.33,59.77 103.33,59.77 100.9,62.2 100.9,67.06 100.64,67.32 98.7,67.32 97.92,68.1 97.92,74.73 94.28,78.36 90.88,78.36 90.4,78.84
SOC_DDR3A_EDQ54: length 56
  TOP w0.102: U24.F20 v2(87.02,81.92)
  TOP w0.127: v1(119.52,55.46) 120.11,56.05 DIMM1.174
  L10 w0.102: v2(87.02,81.92) 87.53,81.41 88.16,81.41 88.42,81.15 88.42,79.63 88.72,79.32 89.15,79.32 89.41,79.07 89.41,78.87 89.74,78.54 90.32,78.54
  L10 w0.114: v1(119.52,55.46) 118.5,54.44 113.68,54.44 112.77,55.35 108.1,55.35 104.14,59.31 103.14,59.31 99.82,62.63 99.82,66.45 99.54,66.73 98.58,66.73 97.46,67.84 97.46,69.92 97.35,70.04 96.71,70.04 96.6,70.15 96.6,70.38 96.71,70.49 97.35,70.49 97.46,70.61 97.46,74.51 94.12,77.85 91.01,77.85 90.32,78.54
SOC_DDR3A_EDQ55: length 56.2
  TOP w0.102: U24.G21 v2(86.02,80.92)
  TOP w0.127: v1(120.19,55.45) DIMM1.176
  L10 w0.102: v2(86.02,80.92) 86.5,80.44 87.05,80.44 87.55,79.94 87.55,79.76 87.83,79.48 88.09,79.48 88.57,78.99 88.57,78.79 89.05,78.31 90.2,78.31
  L10 w0.114: v1(120.19,55.45) 120.36,55.45 120.47,55.33 120.47,54.78 120.36,54.66 119.37,54.66 118.67,53.96 113.42,53.96 112.49,54.89 107.67,54.89 104.9,57.66 104.01,57.66 99.31,62.36 99.31,65 98.91,65.41 96.01,65.41 95.83,65.59 95.83,74.71 93.07,77.47 91.03,77.47 90.2,78.31
SOC_DDR3A_EDQ56: length 54.4
  TOP w0.102: U24.C23 v2(90.02,78.92)
  TOP w0.127: DIMM1.183 114.97,53.35 v1(115.02,53.4)
  L8 w0.114: v2(90.02,78.92) 90.86,78.08 91.9,78.08 93.24,76.73 93.24,72.52 92.56,71.83 92.56,68.01 92.87,67.69 98.61,67.69 98.98,67.32 98.98,66.73 98.81,66.55 96.32,66.55 96.19,66.42 96.19,65.72 96.31,65.6 97.06,65.6 97.18,65.49 97.18,64.73 97.32,64.59 97.52,64.59 97.64,64.71 97.64,65.49 97.75,65.61 97.98,65.61 98.09,65.49 98.09,64.68 98.21,64.57 98.44,64.57 98.55,64.68 98.55,65.27 98.67,65.38 98.89,65.38 99.01,65.27 99.01,64.63 99.12,64.52 99.86,64.52 99.97,64.4 99.97,64 100.09,63.88 101.1,63.88 104.08,60.9 106.06,60.9 108.95,58.01 108.95,57.57 111.89,54.64 113.79,54.64 v1(115.02,53.4)
SOC_DDR3A_EDQ57: length 54.2
  TOP w0.102: v2(86.04,79.92) 85.53,80.42 U24.G22
  TOP w0.127: DIMM1.185 115.13,52.75 115.43,53.05 115.97,53.05 116.6,52.41 v1(116.6,50.96)
  L8 w0.114: v1(116.6,50.96) 115.67,50.03 111.08,50.03 106.4,54.72 106.02,54.72 100.79,59.94 97.28,59.94 90.65,66.57 90.65,71.42 89.4,72.67 89.4,73.08 88.06,74.43 87.94,74.43 87.53,74.84 87.53,77.96 87.18,78.31 87.13,78.31 86.54,78.89 86.54,79.41 v2(86.04,79.92)
SOC_DDR3A_EDQ58: length 54.5
  TOP w0.102: U24.D23 v2(89.02,78.92)
  TOP w0.127: DIMM1.191 v1(115.19,50.95)
  L8 w0.102: 88.64,77.65 88.64,78.54 v2(89.02,78.92)
  L8 w0.114: v1(115.19,50.95) 114.14,50.95 114.03,51.06 114.03,52.21 113.88,52.35 113.68,52.35 113.57,52.24 113.57,51.09 113.45,50.98 113.23,50.98 113.11,51.09 113.11,52.44 113,52.54 112.76,52.54 112.65,52.44 112.65,51.12 112.54,51 111.65,51 111.54,51.12 111.54,52.43 111.03,52.93 110.56,52.93 110.44,53.05 110.44,53.33 110.33,53.44 110.1,53.44 109.99,53.33 109.99,53.05 109.87,52.93 109.48,52.93 109.18,53.24 109.18,54.79 108.9,55.07 108.01,55.07 106.88,56.2 106.88,57.21 104.74,59.36 102.92,59.36 101.37,60.91 98.36,60.91 93.21,66.07 92.55,66.07 91.49,67.12 91.49,72.85 89.56,74.78 89.56,77.06 89.16,77.46 88.82,77.46 88.64,77.65
SOC_DDR3A_EDQ59: length 54.3
  TOP w0.102: U24.F22 86.53,80.42 v2(87.02,79.93)
  TOP w0.127: v1(115.89,50.99) 115.25,50.35 DIMM1.193
  L8 w0.114: v2(87.02,79.93) 87.58,79.38 88.11,79.38 88.42,79.07 88.42,74.97 89.73,73.66 89.83,73.66 91.03,72.45 91.03,66.93 92.33,65.63 92.98,65.63 98.16,60.45 101.18,60.45 102.73,58.9 103.39,58.9 103.5,58.79 103.5,57.88 103.62,57.76 103.84,57.76 103.96,57.87 103.96,58.79 104.07,58.9 104.55,58.9 105.04,58.41 105.04,57.66 104.93,57.54 104.61,57.54 104.5,57.43 104.5,57.2 104.61,57.08 105.35,57.08 108.28,54.15 108.28,53.48 111.27,50.49 115.39,50.49 v1(115.89,50.99)
SOC_DDR3A_EDQ60: length 54.3
  TOP w0.102: U24.E22 v2(88.02,79.92)
  TOP w0.127: DIMM1.180 119.91,54.25 v1(119.31,53.65)
  L8 w0.102: 93.18,79.29 92.16,80.31 88.41,80.31 v2(88.02,79.92)
  L8 w0.114: v1(119.31,53.65) 117.56,53.65 112.62,58.6 111.44,58.6 110.79,59.25 110.79,60.02 108.53,62.28 108.53,65.66 108.36,65.84 105.23,65.84 103.23,67.84 102.49,67.84 100.15,70.18 99.79,70.18 98.18,71.79 97.55,71.79 97.43,71.9 97.43,72.13 97.55,72.24 98.18,72.24 98.3,72.36 98.3,72.59 98.18,72.7 97.55,72.7 97.43,72.81 97.43,73.04 97.55,73.16 98.18,73.16 98.3,73.27 98.3,73.5 98.18,73.61 97.55,73.61 97.43,73.73 97.43,73.96 97.55,74.07 98.18,74.07 98.3,74.19 98.3,74.49 93.53,79.26 93.22,79.26 93.18,79.29
SOC_DDR3A_EDQ61: length 54.4
  TOP w0.102: U24.B22 v2(91.02,79.92)
  TOP w0.127: DIMM1.182 120.04,53.65 118.63,52.23 v1(118.63,51.27)
  L8 w0.102: 89.92,78.46 89.64,78.74 89.64,79.08 90.01,79.45 90.54,79.45 v2(91.02,79.92)
  L8 w0.114: 89.92,78.46 90.03,78.46 91.56,76.93 91.56,76.77 92.84,75.49 92.84,73 92.25,72.42 92.25,67.67 92.84,67.07 94.19,67.07 99.29,61.98 102.36,61.98 103.89,60.44 105.88,60.44 107.8,58.52 107.8,56.58 108.39,55.98 109.28,55.98 111.79,53.47 111.81,53.47 111.82,53.46 114.08,53.46 115.48,52.05 117.13,52.05 117.92,51.27 v1(118.63,51.27)
SOC_DDR3A_EDQ62: length 54.5
  TOP w0.102: U24.F21 v2(87.02,80.92)
  TOP w0.127: v1(120.14,50.65) DIMM1.192
  L8 w0.102: 93.18,79.81 93.07,79.81 92.36,80.52 92.25,80.52 87.42,80.52 v2(87.02,80.92)
  L8 w0.114: v1(120.14,50.65) 120.57,51.07 120.57,53.58 119.95,54.19 117.69,54.19 112.82,59.05 111.63,59.05 111.25,59.44 111.25,60.21 109.68,61.78 109.68,65.84 109.22,66.29 108.7,66.29 106.32,66.29 103.76,68.86 102.67,68.86 100.18,71.35 99.67,71.35 98.81,72.21 98.81,74.7 93.7,79.81 93.18,79.81
SOC_DDR3A_EDQ63: length 54.3
  TOP w0.102: U24.D22 v2(89.02,79.92)
  TOP w0.127: v1(119.49,50.63) 120.08,50.05 DIMM1.194
  L8 w0.102: v2(89.02,79.92) 89.41,79.53 89.41,77.88
  L8 w0.114: v1(119.49,50.63) 119.49,49.52 119.38,49.4 119.06,49.4 118.95,49.52 118.95,50.34 118.7,50.59 117.95,50.59 116.97,51.57 115.31,51.57 113.88,53 111.63,53 111.62,53.01 111.6,53.01 109.09,55.52 108.2,55.52 107.34,56.39 107.34,57.4 104.93,59.82 103.11,59.82 101.56,61.37 99.24,61.37 94.01,66.6 92.67,66.6 91.91,67.36 91.91,73.44 90.47,74.88 90.47,77 90.13,77.35 89.94,77.35 89.41,77.88
SOC_DDR3A_EDQSN_0: length 47.5
  TOP w0.102: U24.D1 88.29,101.65 88.29,102.51 87.86,102.93 87.26,102.93 v2(87.1,103.1)
  TOP w0.127: DIMM1.10 120.65,107.65 120.48,107.47 120.24,107.47 v1(119.98,107.73)
  L8 w0.114: v2(87.1,103.1) 87.27,102.92 87.87,102.92 88.9,103.95 103.28,103.95 107.66,108.33 108.84,108.33 109.07,108.56 109.07,109.92 109.32,110.17 109.92,110.17 110.17,109.92 110.17,109.05 110.29,108.94 110.68,108.94 110.79,109.05 110.79,109.94 111.05,110.2 111.64,110.2 111.9,109.94 111.9,108.98 112.01,108.86 112.41,108.86 112.52,108.98 112.52,109.97 112.75,110.2 113.4,110.2 113.63,109.97 113.63,108.85 115.05,107.43 119.68,107.43 v1(119.98,107.73)
SOC_DDR3A_EDQSN_1: length 47.5
  TOP w0.102: v2(89.94,99.9) 89.52,99.47 U24.C3
  TOP w0.127: DIMM1.25 114.55,103.15 114.7,103.01 114.93,103.01 v1(115.21,103.29)
  L10 w0.114: v2(89.94,99.9) 89.97,99.9 90.18,100.11 90.18,100.23 90.49,100.53 91.23,100.53 93.72,103.03 103.77,103.03 103.89,103.15 103.89,104.28 104.14,104.53 104.74,104.53 104.99,104.28 104.99,102.73 105.07,102.65 105.53,102.65 105.61,102.73 105.61,104.94 105.87,105.19 106.46,105.19 106.72,104.94 106.72,102.78 106.83,102.67 107.23,102.67 107.34,102.78 107.34,104.94 107.6,105.19 108.19,105.19 108.45,104.94 108.45,103.01 108.56,102.9 108.95,102.9 109.07,103.01 109.07,104.86 109.32,105.12 109.92,105.12 110.17,104.86 110.17,103.11 110.29,103 111.07,103 111.18,103.11 111.18,104.06 111.44,104.32 112.03,104.32 112.29,104.06 112.29,103.11 112.4,103 115.09,103 115.21,103.11 v1(115.21,103.29)
SOC_DDR3A_EDQSN_2: length 47.5
  TOP w0.102: U24.B5 90.54,97.42 v2(91.03,96.93)
  TOP w0.127: v1(115.18,97.82) 114.93,97.57 114.68,97.57 114.5,97.75 DIMM1.43
  L8 w0.114: v2(91.03,96.93) 91.17,97.07 91.17,97.34 91.43,97.6 93.32,97.6 93.74,98.02 93.74,98.21 94.03,98.5 94.76,98.5 95.02,98.25 95.02,97.94 95.13,97.83 95.52,97.83 95.64,97.94 95.64,98.25 95.89,98.5 96.49,98.5 96.74,98.25 96.74,97.94 96.86,97.83 97.25,97.83 97.37,97.94 97.37,98.25 97.62,98.5 98.22,98.5 98.47,98.25 98.47,97.9 98.59,97.79 98.98,97.79 99.09,97.9 99.09,98.25 99.35,98.5 99.94,98.5 100.2,98.25 100.2,97.94 100.31,97.83 100.71,97.83 100.82,97.94 100.82,98.25 101.08,98.5 101.67,98.5 101.93,98.25 101.93,97.94 102.04,97.83 102.43,97.83 102.55,97.94 102.55,98.25 102.8,98.5 104.17,98.5 104.47,98.2 104.47,98.01 104.58,97.89 105.72,97.89 105.83,98.01 105.83,98.22 106.09,98.48 106.68,98.48 106.71,98.45 106.94,98.22 106.94,97.75 107.05,97.64 107.44,97.64 107.56,97.75 107.56,98.22 107.81,98.48 108.41,98.48 108.66,98.22 108.66,97.6 108.76,97.5 109.19,97.5 109.29,97.6 109.29,99.45 109.57,99.73 110.13,99.73 110.39,99.48 110.39,97.62 110.5,97.51 110.9,97.51 111.01,97.62 111.01,99.07 111.27,99.33 111.86,99.33 112.12,99.07 112.12,97.35 112.2,97.27 112.81,97.27 112.89,97.35 112.89,99.83 113.15,100.09 113.74,100.09 114,99.83 114,97.73 114.11,97.61 114.97,97.61 v1(115.18,97.82)
SOC_DDR3A_EDQSN_3: length 47.5
  TOP w0.102: U24.A7 91.52,95.42 v2(92.02,94.92)
  TOP w0.127: v1(119.47,92.92) 119.26,92.72 119.26,92.52 119.34,92.44 120.46,92.44 120.66,92.65 DIMM1.60
  L10 w0.114: v1(119.47,92.92) 119.39,92.92 119.28,92.81 119.28,92.51 118.93,92.16 117.86,92.16 117.54,92.48 117.54,93.89 117.75,94.11 118.3,94.11 118.41,94.22 118.41,94.61 118.3,94.73 117.92,94.73 117.67,94.98 117.67,95.4 117.35,95.72 114.26,95.72 113.96,96.02 113.96,96.96 113.87,97.05 113.42,97.05 113.34,96.96 113.34,96 113.05,95.72 112.43,95.72 112.18,95.97 112.18,96.89 112.05,97.02 111.3,97.02 110.25,98.07 106.52,98.07 106.4,97.95 106.4,97.14 106.15,96.89 105.56,96.89 105.3,97.14 105.3,97.82 105.3,97.83 105.3,97.96 105.19,98.07 104.55,98.07 104.44,97.96 104.44,97.04 104.21,96.81 103.56,96.81 103.33,97.04 103.33,98.26 103.22,98.37 102.78,98.37 102.67,98.26 102.67,97.18 102.35,96.86 95.73,96.86 94.69,95.82 92.07,95.82 91.5,95.25 91.5,95.04 91.62,94.92 v2(92.02,94.92)
SOC_DDR3A_EDQSN_4: length 54
  TOP w0.102: U24.B17 v2(91.02,84.92)
  TOP w0.127: v1(115.33,66.56) 115.12,66.35 114.72,66.35 114.53,66.55 DIMM1.139
  L10 w0.114: v2(91.02,84.92) 91.11,84.92 91.2,85.01 91.2,85.5 91.45,85.75 92.24,85.75 92.64,85.34 94.7,85.34 94.88,85.52 94.88,86.09 95.23,86.43 95.88,86.43 96.13,86.17 96.13,85.47 96.25,85.36 96.64,85.36 96.76,85.47 96.76,86.17 97.01,86.43 97.6,86.43 97.86,86.17 97.86,85.47 97.97,85.36 98.37,85.36 98.48,85.47 98.48,86.22 98.69,86.43 99.38,86.43 99.59,86.22 99.59,85.47 99.7,85.36 100.1,85.36 100.21,85.47 100.21,86.14 100.47,86.4 101.06,86.4 101.31,86.14 101.31,85.55 101.48,85.38 103.19,85.38 103.6,85.8 103.96,85.8 104.39,85.38 104.39,85.02 103.78,84.41 103.78,84.25 104.06,83.97 104.22,83.97 104.62,84.37 104.62,84.6 105.05,85.04 105.82,85.04 106.15,84.7 106.15,83.44 106.38,83.21 106.68,83.21 106.93,82.95 106.93,82.25 107.05,82.13 107.44,82.13 107.55,82.25 107.55,82.59 107.81,82.84 108.4,82.84 108.72,82.52 108.72,81.13 109.07,80.78 110.46,80.78 112.69,78.56 112.69,68.55 114.81,66.42 115.23,66.42 115.33,66.52 v1(115.33,66.56)
SOC_DDR3A_EDQSN_5: length 53.3
  TOP w0.102: U24.A19 v2(92.02,82.92)
  TOP w0.127: DIMM1.154 120.64,62.05 120.45,61.86 118.63,61.86 v1(118.43,62.06)
  L8 w0.102: 93.18,81.71 92.36,82.53 91.66,82.53 91.54,82.65 91.54,82.83 91.64,82.92 v2(92.02,82.92)
  L8 w0.114: 93.18,81.71 93.2,81.69 93.23,81.69 95.16,81.69 99.57,77.29 100.41,77.29 101.21,76.48 101.21,75.28 102.25,74.24 103.95,74.24 104.58,73.6 104.58,71.32 105.58,70.32 107.57,70.32 108.09,70.84 111.36,70.84 111.66,70.55 111.66,67.84 111.4,67.59 111.4,65 113.15,63.25 113.15,61.6 114.36,60.4 116.6,60.4 116.95,60.04 116.95,59.22 117.07,59.11 117.46,59.11 117.58,59.22 117.58,59.66 117.84,59.93 118.55,59.93 118.67,60.05 118.67,60.33 118.55,60.44 117.83,60.44 117.58,60.69 117.58,61.49 117.84,61.76 118.16,61.76 118.27,61.87 118.3,61.87 118.43,61.99 v1(118.43,62.06)
SOC_DDR3A_EDQSN_6: length 56.1
  TOP w0.102: v2(91.02,80.92) U24.B21
  TOP w0.127: v1(115.2,57.34) 115.4,57.13 115.4,56.94 115.25,56.78 114.7,56.78 114.53,56.95 DIMM1.171
  L10 w0.102: v2(91.02,80.92) 91.47,80.92 91.62,80.77 91.62,80.54 91.86,80.3 92.37,80.3 92.81,79.86 93.17,79.86 93.18,79.84
  L10 w0.114: v1(115.2,57.34) 115.25,57.34 115.43,57.52 115.43,57.68 115.26,57.86 114.06,57.86 113.28,58.63 110.95,58.63 110.69,58.89 110.69,59.77 110.58,59.88 110.18,59.88 110.07,59.77 110.07,58.89 109.82,58.63 108.94,58.63 108.68,58.9 108.68,59.97 109.52,60.82 109.52,60.98 109.24,61.26 109.08,61.26 108.81,60.99 107.9,60.99 107.65,61.24 107.65,62.35 107.44,62.55 106.89,62.55 106.78,62.44 106.78,61.69 106.34,61.25 105.56,61.25 105.17,61.64 105.17,63.11 105.46,63.4 106.16,63.4 106.27,63.51 106.27,64.1 106.16,64.21 103.9,64.21 103.64,64.47 103.64,65.06 103.9,65.32 104.61,65.32 104.72,65.43 104.72,66.22 104.61,66.33 103.91,66.33 103.44,66.8 103.44,68.66 103.25,68.85 101.72,68.85 101.09,69.47 101.09,76.18 100.18,77.09 99.12,77.09 96.36,79.84 93.18,79.84
SOC_DDR3A_EDQSN_7: length 54.4
  TOP w0.102: U24.B23 v2(91.02,78.92)
  TOP w0.127: DIMM1.186 120.67,52.45 120.48,52.26 119.8,52.26 v1(119.62,52.44)
  L8 w0.102: v2(91.02,78.92) 91.24,78.92 91.34,79.02 91.34,79.15 91.69,79.5 92.36,79.5 93.16,78.7 93.17,78.7 93.18,78.68
  L8 w0.114: v1(119.62,52.44) 119.5,52.31 118.07,52.31 113.69,56.69 111.86,56.69 110.22,58.33 110.22,59.78 103.47,66.54 102.19,66.54 100.84,67.88 100.39,67.88 98.71,69.56 98.71,70.33 98.44,70.6 97.87,70.6 97.61,70.33 97.61,69.22 97.48,69.09 97.11,69.09 96.98,69.22 96.98,69.92 96.65,70.26 96.1,70.26 95.64,70.71 95.64,71.3 95.39,71.56 94.68,71.56 94.59,71.65 94.59,72.09 94.68,72.18 95.53,72.18 95.78,72.44 95.78,73.03 95.53,73.29 94.68,73.29 94.59,73.38 94.59,73.82 94.68,73.91 95.53,73.91 95.78,74.17 95.78,74.76 95.53,75.01 94.68,75.01 94.59,75.1 94.59,77.28 93.18,78.68
SOC_DDR3A_EDQSN_8: length 47.6
  TOP w0.102: v2(91.92,86.89) 91.59,86.89 91.34,87.15 91.34,87.32 91.44,87.42 U24.A15
  TOP w0.127: v1(115.48,86.5) 115.71,86.5 115.82,86.39 115.82,85.78 115.63,85.58 114.7,85.58 114.53,85.75 DIMM1.75
  L8 w0.102: 93.18,88.24 92.22,87.27 91.54,87.27 91.41,87.15 91.41,86.94 91.47,86.89 v2(91.92,86.89)
  L8 w0.114: v1(115.48,86.5) 115.81,86.5 115.85,86.54 115.85,86.79 115.58,87.06 113.92,87.06 112.51,85.65 112.51,82.81 112.2,82.5 111.6,82.5 111.35,82.75 111.35,82.82 111.23,82.93 110.84,82.93 110.73,82.82 110.73,82.69 110.5,82.46 109.85,82.46 109.62,82.69 109.62,82.94 109.51,83.06 109.11,83.06 109,82.94 109,82.64 108.74,82.38 108.15,82.38 107.89,82.64 107.89,82.8 107.78,82.92 107.39,82.92 107.27,82.8 107.27,82.13 107.06,81.91 106.36,81.91 106.15,82.13 106.15,82.97 106.06,83.06 104.98,83.06 104.74,83.3 104.74,84.29 104.46,84.57 104.3,84.57 103.88,84.15 103.52,84.15 103.1,84.57 103.1,84.94 103.5,85.34 103.5,85.5 103.08,85.93 102.91,85.93 102.17,85.18 101.81,85.18 101.38,85.6 101.38,85.96 102.14,86.72 102.14,86.88 101.87,87.16 101.7,87.16 101.03,86.49 100.49,86.49 99.35,87.63 99.35,88.25 99.24,88.37 98.5,88.37 98.39,88.25 98.39,88.09 98.13,87.83 97.54,87.83 97.28,88.09 97.28,88.27 97.17,88.38 96.78,88.38 96.66,88.27 96.66,88.05 96.43,87.82 95.79,87.82 95.56,88.05 95.56,88.27 95.44,88.38 95.05,88.38 94.94,88.27 94.94,88.09 94.68,87.83 94.09,87.83 93.83,88.09 93.83,88.27 93.72,88.38 93.33,88.38 93.18,88.24
SOC_DDR3A_EDQSP_0: length 47.5
  TOP w0.102: U24.E1 87.83,101.42 88.06,101.65 88.06,102.41 87.77,102.7 87.26,102.7 v2(87.07,102.51)
  TOP w0.127: v1(119.98,106.91) 120.29,107.22 120.49,107.22 120.66,107.05 DIMM1.12
  L8 w0.114: v1(119.98,106.91) 119.71,107.19 114.95,107.19 113.38,108.75 113.38,109.87 113.3,109.96 112.85,109.96 112.76,109.87 112.76,108.88 112.51,108.62 111.91,108.62 111.66,108.88 111.66,109.84 111.54,109.96 111.15,109.96 111.04,109.84 111.04,108.95 110.78,108.7 110.19,108.7 109.93,108.95 109.93,109.82 109.82,109.93 109.42,109.93 109.31,109.82 109.31,108.46 108.94,108.09 107.76,108.09 103.38,103.71 89,103.71 87.97,102.68 87.24,102.68 v2(87.07,102.51)
SOC_DDR3A_EDQSP_1: length 47.5
  TOP w0.102: U24.B3 90.52,99.46 v2(90.93,99.87)
  TOP w0.127: v1(115.21,102.47) 114.93,102.75 114.76,102.75 114.55,102.55 DIMM1.27
  L10 w0.114: v1(115.21,102.47) 115.21,102.67 115.13,102.76 112.3,102.76 112.05,103.01 112.05,103.96 111.93,104.08 111.54,104.08 111.43,103.96 111.43,103.01 111.17,102.76 110.19,102.76 109.93,103.01 109.93,104.76 109.82,104.88 109.42,104.88 109.31,104.76 109.31,102.91 109.05,102.65 108.46,102.65 108.2,102.91 108.2,104.84 108.09,104.95 107.7,104.95 107.58,104.84 107.58,102.68 107.33,102.43 106.73,102.43 106.48,102.68 106.48,104.84 106.36,104.95 105.97,104.95 105.85,104.84 105.85,102.63 105.63,102.41 104.97,102.41 104.75,102.63 104.75,104.18 104.64,104.29 104.24,104.29 104.13,104.18 104.13,103.05 103.87,102.79 93.82,102.79 91.33,100.29 90.59,100.29 90.42,100.13 90.42,99.95 90.5,99.87 v2(90.93,99.87)
SOC_DDR3A_EDQSP_2: length 47.5
  TOP w0.102: v2(91.92,96.93) 91.92,97.02 U24.A5
  TOP w0.127: v1(115.21,97.14) 115.03,97.32 114.68,97.32 114.51,97.15 DIMM1.45
  L8 w0.114: v2(91.92,96.93) 91.53,96.93 91.41,97.04 91.41,97.24 91.53,97.36 93.42,97.36 93.99,97.92 93.99,98.11 94.13,98.26 94.66,98.26 94.78,98.15 94.78,97.84 95.03,97.59 95.62,97.59 95.88,97.84 95.88,98.15 95.99,98.26 96.39,98.26 96.5,98.15 96.5,97.84 96.76,97.59 97.35,97.59 97.61,97.84 97.61,98.15 97.72,98.26 98.12,98.26 98.23,98.15 98.23,97.8 98.49,97.55 99.08,97.55 99.33,97.8 99.33,98.15 99.45,98.26 99.84,98.26 99.96,98.15 99.96,97.84 100.21,97.59 100.81,97.59 101.06,97.84 101.06,98.15 101.18,98.26 101.57,98.26 101.68,98.15 101.68,97.84 101.94,97.59 102.53,97.59 102.79,97.84 102.79,98.15 102.9,98.26 104.07,98.26 104.23,98.1 104.23,97.91 104.48,97.65 105.82,97.65 106.07,97.91 106.07,98.12 106.19,98.23 106.58,98.23 106.69,98.12 106.69,97.65 106.95,97.4 107.54,97.4 107.8,97.65 107.8,98.12 107.91,98.23 108.31,98.23 108.42,98.12 108.42,97.5 108.66,97.26 109.29,97.26 109.53,97.5 109.53,99.35 109.67,99.49 110.03,99.49 110.15,99.38 110.15,97.52 110.4,97.27 111,97.27 111.25,97.52 111.25,98.97 111.37,99.09 111.76,99.09 111.88,98.97 111.88,97.25 112.1,97.03 112.91,97.03 113.13,97.25 113.13,99.73 113.25,99.85 113.64,99.85 113.76,99.73 113.76,97.63 114.01,97.37 115.05,97.37 115.21,97.21 v1(115.21,97.14)
SOC_DDR3A_EDQSP_3: length 47.5
  TOP w0.102: U24.B7 90.52,95.42 v2(91.02,94.92)
  TOP w0.127: v1(118.83,92.9) 119.01,92.72 119.01,92.42 119.24,92.19 120.5,92.19 120.64,92.05 DIMM1.62
  L10 w0.114: v1(118.83,92.9) 119.04,92.69 119.04,92.61 118.83,92.4 117.96,92.4 117.78,92.58 117.78,93.79 117.85,93.86 118.4,93.86 118.66,94.12 118.66,94.71 118.4,94.97 118.02,94.97 117.91,95.08 117.91,95.5 117.45,95.96 114.36,95.96 114.2,96.12 114.2,97.06 113.97,97.29 113.32,97.29 113.09,97.06 113.09,96.1 112.95,95.96 112.53,95.96 112.42,96.07 112.42,96.99 112.15,97.26 111.4,97.26 110.35,98.31 106.42,98.31 106.16,98.05 106.16,97.24 106.05,97.13 105.66,97.13 105.54,97.24 105.54,97.72 105.54,98.06 105.29,98.31 104.45,98.31 104.2,98.06 104.2,97.14 104.11,97.05 103.66,97.05 103.58,97.14 103.58,98.36 103.32,98.62 102.68,98.62 102.43,98.36 102.43,97.28 102.25,97.1 95.63,97.1 94.59,96.06 91.97,96.06 91.26,95.35 91.26,95.05 91.14,94.92 v2(91.02,94.92)
SOC_DDR3A_EDQSP_4: length 54
  TOP w0.102: U24.A17 v2(92.02,84.92)
  TOP w0.127: DIMM1.141 114.54,65.95 114.69,66.1 115.15,66.1 v1(115.33,65.92)
  L10 w0.114: v1(115.33,65.92) 115.33,65.95 115.1,66.18 114.71,66.18 112.44,68.45 112.44,78.46 110.36,80.54 108.97,80.54 108.48,81.03 108.48,82.42 108.3,82.6 107.91,82.6 107.8,82.49 107.8,82.15 107.54,81.89 106.95,81.89 106.69,82.15 106.69,82.85 106.58,82.97 106.28,82.97 105.91,83.34 105.91,84.6 105.72,84.8 105.15,84.8 104.86,84.5 104.86,84.27 104.32,83.73 103.96,83.73 103.54,84.15 103.54,84.51 104.14,85.12 104.14,85.28 103.86,85.56 103.7,85.56 103.29,85.14 101.38,85.14 101.07,85.45 101.07,86.04 100.96,86.16 100.57,86.16 100.45,86.04 100.45,85.37 100.2,85.12 99.6,85.12 99.35,85.37 99.35,86.12 99.28,86.19 98.79,86.19 98.72,86.12 98.72,85.37 98.47,85.12 97.87,85.12 97.62,85.37 97.62,86.07 97.5,86.19 97.11,86.19 97,86.07 97,85.37 96.74,85.12 96.15,85.12 95.89,85.37 95.89,86.07 95.78,86.19 95.33,86.19 95.12,85.99 95.12,85.42 94.8,85.1 92.54,85.1 92.14,85.51 91.55,85.51 91.44,85.4 91.44,85.04 91.56,84.92 v2(92.02,84.92)
SOC_DDR3A_EDQSP_5: length 53.4
  TOP w0.102: U24.B19 v2(91.02,82.92)
  TOP w0.127: DIMM1.156 120.6,61.45 120.45,61.6 118.6,61.6 118.45,61.45 v1(118.45,61.43)
  L8 w0.102: 93.12,81.45 92.26,82.3 91.57,82.3 91.31,82.56 91.31,82.75 91.14,82.92 v2(91.02,82.92)
  L8 w0.114: v1(118.45,61.43) 118.36,61.52 117.94,61.52 117.82,61.39 117.82,60.79 117.93,60.68 118.65,60.68 118.91,60.43 118.91,59.95 118.65,59.69 117.94,59.69 117.82,59.56 117.82,59.12 117.56,58.86 116.97,58.86 116.71,59.12 116.71,59.94 116.5,60.16 114.26,60.16 112.91,61.5 112.91,63.15 111.16,64.9 111.16,67.69 111.42,67.94 111.42,70.45 111.26,70.6 108.19,70.6 107.67,70.08 105.48,70.08 104.34,71.22 104.34,73.5 103.85,74 102.15,74 100.97,75.18 100.97,76.38 100.31,77.05 99.47,77.05 95.07,81.45 93.12,81.45
SOC_DDR3A_EDQSP_6: length 56.1
  TOP w0.102: U24.A21 v2(92.02,80.92)
  TOP w0.127: DIMM1.173 114.51,56.35 114.69,56.52 115.35,56.52 115.66,56.83 115.66,57.16 v1(115.83,57.34)
  L10 w0.102: 93.18,80.09 92.91,80.09 92.46,80.53 91.95,80.53 91.85,80.64 91.85,80.83 91.94,80.92 v2(92.02,80.92)
  L10 w0.114: v1(115.83,57.34) 115.79,57.34 115.67,57.45 115.67,57.78 115.36,58.1 114.16,58.1 113.38,58.87 111.05,58.87 110.93,58.99 110.93,59.87 110.68,60.12 110.08,60.12 109.83,59.87 109.83,58.99 109.72,58.87 109.04,58.87 108.92,59 108.92,59.87 109.76,60.72 109.76,61.08 109.34,61.5 109.31,61.5 108.98,61.5 108.71,61.23 108,61.23 107.89,61.34 107.89,62.45 107.54,62.79 106.79,62.79 106.53,62.54 106.53,61.79 106.24,61.49 105.66,61.49 105.42,61.74 105.42,63.01 105.56,63.16 106.26,63.16 106.51,63.41 106.51,64.2 106.26,64.45 104,64.45 103.89,64.57 103.89,64.96 104,65.08 104.71,65.08 104.97,65.33 104.97,66.32 104.71,66.57 104.01,66.57 103.68,66.9 103.68,68.76 103.35,69.09 101.82,69.09 101.33,69.57 101.33,76.28 100.29,77.33 99.22,77.33 96.46,80.09 93.18,80.09
SOC_DDR3A_EDQSP_7: length 54.4
  TOP w0.102: U24.A23 92.02,78.92 v2(92.02,78.89)
  TOP w0.127: DIMM1.188 120.68,51.85 120.52,52 119.8,52 v1(119.59,51.8)
  L8 w0.102: v2(92.02,78.89) 91.95,78.82 91.64,78.82 91.57,78.89 91.57,79.06 91.78,79.27 92.26,79.27 93.17,78.37 93.17,78.36
  L8 w0.114: v1(119.59,51.8) 119.59,51.81 119.33,52.07 117.97,52.07 113.59,56.45 111.76,56.45 109.98,58.23 109.98,59.68 103.37,66.29 102.09,66.29 100.74,67.64 100.29,67.64 98.47,69.46 98.47,70.23 98.34,70.36 97.97,70.36 97.85,70.23 97.85,69.11 97.58,68.85 97.01,68.85 96.74,69.11 96.74,69.82 96.55,70.02 96,70.02 95.4,70.61 95.4,71.2 95.29,71.32 94.58,71.32 94.35,71.55 94.35,72.19 94.58,72.42 95.43,72.42 95.54,72.54 95.54,72.93 95.43,73.05 94.58,73.05 94.35,73.28 94.35,73.92 94.58,74.15 95.43,74.15 95.54,74.27 95.54,74.66 95.43,74.77 94.58,74.77 94.35,75 94.35,77.18 93.17,78.36
SOC_DDR3A_EDQSP_8: length 47.6
  TOP w0.102: v2(91.02,86.92) 90.52,87.42 U24.B15
  TOP w0.127: v1(116.28,86.46) 116.08,86.26 116.08,85.67 115.73,85.33 114.66,85.33 114.48,85.15 DIMM1.77
  L8 w0.102: v2(91.02,86.92) 91.09,86.92 91.19,87.02 91.19,87.24 91.45,87.5 91.64,87.5 91.64,87.5 92.13,87.5 92.94,88.32
  L8 w0.114: v1(116.28,86.46) 116.26,86.46 116.09,86.63 116.09,86.89 115.68,87.3 113.82,87.3 112.27,85.75 112.27,82.91 112.1,82.74 111.7,82.74 111.59,82.85 111.59,82.92 111.34,83.17 110.74,83.17 110.49,82.92 110.49,82.79 110.4,82.7 109.95,82.7 109.86,82.79 109.86,83.04 109.61,83.3 109.01,83.3 108.76,83.04 108.76,82.74 108.64,82.63 108.25,82.63 108.14,82.74 108.14,82.9 107.88,83.16 107.29,83.16 107.03,82.9 107.03,82.23 106.96,82.16 106.46,82.16 106.39,82.23 106.39,83.07 106.16,83.3 105.08,83.3 104.98,83.4 104.98,84.39 104.56,84.81 104.2,84.81 103.78,84.39 103.62,84.39 103.34,84.67 103.34,84.83 103.74,85.24 103.74,85.6 103.18,86.17 102.81,86.17 102.07,85.42 101.91,85.42 101.63,85.7 101.63,85.86 102.39,86.62 102.39,86.98 101.97,87.4 101.6,87.4 100.93,86.73 100.59,86.73 99.59,87.73 99.59,88.35 99.34,88.61 98.4,88.61 98.15,88.35 98.15,88.19 98.03,88.07 97.64,88.07 97.53,88.19 97.53,88.37 97.27,88.62 96.68,88.62 96.42,88.37 96.42,88.15 96.33,88.06 95.89,88.06 95.8,88.15 95.8,88.37 95.54,88.62 94.95,88.62 94.69,88.37 94.69,88.19 94.58,88.07 94.19,88.07 94.07,88.19 94.07,88.37 93.82,88.62 93.23,88.62 92.94,88.34 92.94,88.32
SOC_DDR3A_EMRESETN: length 45.2
  TOP w0.102: v2(91.02,87.92) 90.52,88.42 U24.B14
  TOP w0.127: v1(119.93,101.65) DIMM1.30
  BOTTOM w0.102: 93.18,88.29 91.38,88.29 v2(91.02,87.92)
  BOTTOM w0.127: 93.18,88.29 93.21,88.27 R648.1 98.1,88.27 98.74,88.9 119.3,88.9 121.16,90.75 121.16,100.42 v1(119.93,101.65)
SOC_DDR3A_EODT_0: length 59.7
  TOP w0.102: U24.E12 87.52,90.42 v2(88.02,89.92)
  TOP w0.127: v1(118.88,71.87) 120.3,70.45 DIMM1.126
  L3 w0.114: v2(88.02,89.92) 88.02,89.58 88.49,89.1 88.49,86.59 88.72,86.36 92.94,86.36 96.12,83.18 98.9,83.18 99.35,82.72 106.49,82.72 107.48,81.73 109.23,81.73 112.61,78.35 112.61,72.21 112.97,71.85 116.24,71.85 116.71,71.37 117.11,71.37 117.22,71.26 117.22,70.27 117.34,70.15 117.68,70.15 117.79,70.27 117.79,72 117.9,72.11 118.13,72.11 118.25,72 118.25,71.49 118.36,71.37 118.94,71.37 119.06,71.26 119.06,70.4 119.17,70.28 119.4,70.28 119.52,70.4 119.52,71.27 119.62,71.37 119.86,71.37 119.97,71.26 119.97,70.17 120.09,70.05 120.34,70.05 120.45,70.17 120.45,71.99 120.38,72.06 119,72.06 118.88,71.95 v1(118.88,71.87)
SOC_DDR3A_EODT_1: length 59.9
  TOP w0.102: U24.G13 85.52,89.28 v2(86.03,88.77)
  TOP w0.127: DIMM1.128 120.27,69.85 119.77,70.34 119.38,70.34 v1(118.88,69.85)
  L3 w0.114: v2(86.03,88.77) 85.82,88.77 85.62,88.58 85.62,84.89 85.9,84.61 85.91,84.61 85.92,84.6 86.34,84.6 86.73,84.21 87.16,84.21 87.83,83.54 92.18,83.54 94.89,80.82 105.46,80.82 111.05,75.23 111.05,71.04 112,70.09 112.57,70.09 112.66,70 112.66,69.08 112.78,68.96 113.01,68.96 113.12,69.08 113.12,69.94 113.23,70.05 113.46,70.05 113.58,69.94 113.58,69.1 113.69,68.99 113.92,68.99 114.04,69.1 114.04,69.96 114.15,70.08 114.38,70.08 114.49,69.96 114.49,69.38 114.61,69.27 114.84,69.27 114.95,69.38 114.95,69.94 115.06,70.05 115.29,70.05 115.41,69.94 115.41,69.23 115.52,69.11 115.75,69.11 115.86,69.23 115.86,69.94 115.98,70.05 116.21,70.05 116.32,69.94 116.32,69.25 116.44,69.14 116.66,69.14 116.78,69.25 116.78,69.63 116.89,69.75 117.12,69.75 117.24,69.63 117.24,69.25 117.35,69.14 117.58,69.14 117.69,69.25 117.69,69.66 117.79,69.75 118.04,69.75 118.15,69.64 118.15,69.35 118.26,69.24 118.49,69.24 118.61,69.35 118.61,69.6 118.72,69.71 118.75,69.71 v1(118.88,69.85)
SOC_DDR3A_ERAS#: length 59.9
  TOP w0.102: U24.A14 91.52,88.34 v2(91.95,87.91)
  TOP w0.127: DIMM1.122 119.95,71.65 118.98,72.61 v1(118.98,73.06)
  L3 w0.114: v1(118.98,73.06) 122.11,73.06 122.22,72.95 122.22,69.68 122.11,69.57 121.88,69.57 121.77,69.68 121.77,72.4 121.65,72.52 121.42,72.52 121.31,72.4 121.31,69.58 121.2,69.47 120.97,69.47 120.85,69.58 120.85,72.4 120.74,72.52 116.87,72.52 116.71,72.67 113.53,72.67 113.41,72.78 113.41,78.68 109.56,82.53 109.12,82.53 108.36,83.29 108.36,83.73 107.61,84.48 96.01,84.48 92.58,87.91 v2(91.95,87.91)
SOC_DDR3A_EWE#: length 60.3
  TOP w0.102: U24.F12 86.52,90.42 v2(87.02,89.92)
  TOP w0.127: v1(115.27,71.32) 114.64,71.95 DIMM1.121
  L3 w0.114: v1(115.27,71.32) 114.79,71.32 114.68,71.21 114.68,71.01 114.57,70.89 114.33,70.89 114.22,71.01 114.22,71.31 114.11,71.42 113.88,71.42 113.76,71.31 113.76,71.06 113.65,70.94 113.42,70.94 113.31,71.06 113.31,71.31 113.19,71.42 112.33,71.42 112.21,71.54 112.21,78.18 110.39,80.01 109.18,80.01 109.07,80.12 109.07,81.22 108.95,81.33 108.68,81.33 108.56,81.22 108.56,79.92 108.45,79.81 108.22,79.81 108.11,79.92 108.11,81.22 107.99,81.33 107.31,81.33 106.32,82.32 99.99,82.32 99.87,82.21 99.87,81.75 99.76,81.64 99.43,81.64 99.31,81.75 99.31,82.19 98.73,82.78 97.82,82.78 97.7,82.66 97.7,81.75 97.59,81.64 97.36,81.64 97.25,81.75 97.25,82.66 97.13,82.78 96.9,82.78 96.79,82.66 96.79,81.75 96.68,81.64 96.45,81.64 96.33,81.75 96.33,82.61 96.22,82.73 96.01,82.73 95.9,82.61 95.9,81.72 95.8,81.63 95.54,81.63 95.44,81.73 95.44,82.61 95.33,82.73 94.5,82.73 94.39,82.84 94.39,83.07 94.5,83.18 95.11,83.18 95.22,83.3 95.22,83.51 95.09,83.64 94.68,83.64 94.56,83.76 94.56,84.17 94.38,84.35 94.06,84.35 93.94,84.24 93.94,83.76 93.83,83.64 93.6,83.64 93.48,83.76 93.48,84.95 92.96,85.47 87.78,85.47 87.5,85.75 87.5,89.44 v2(87.02,89.92)
