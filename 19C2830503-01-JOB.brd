# Allegro board 19C2830503-01-JOB.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SOC_DDR3B_ECKP_0: length 126.5
  TOP w0.102: v2(94.82,42.08) 94.76,42.08 94.44,41.76 U43.J7 ; v2(59.77,42.1) 59.77,42.06 59.41,41.7 U40.J7 ; U24.AD38 68.52,64.17 68.76,63.93 68.93,63.93 69.12,63.73 69.12,62.88 70.08,61.92 70.08,61.65 70.1,61.62 70.1,61.59 ; U39.J7 47.7,41.76 48.05,42.1 v2(48.08,42.1) ; v2(83.13,42.1) 83.12,42.1 82.75,41.73 U42.J7 ; U41.J7 71.02,41.73 71.39,42.1 v2(71.4,42.1)
  TOP w0.127: 70.1,61.59 70.1,59.56 69.67,59.13 69.29,59.13 v1(69.09,58.93) ; R445.1 99.88,42.79 99.77,42.9 99.45,42.9 v1(99.17,42.63)
  L10 w0.114: v1(69.09,58.93) 69.09,58.95 68.94,59.11 68.3,59.11 68.21,59.02 68.21,55.58 68.33,55.46 69.09,55.46 69.34,55.21 69.34,54.62 69.09,54.36 68.33,54.36 68.21,54.25 68.21,53.65 67.53,52.97 67.53,52.81 70.04,50.3 70.04,49.92 69.64,49.51 69.26,49.51 66.75,52.02 66.59,52.02 66.31,51.75 66.31,51.58 67.59,50.31 67.59,49.93 67.19,49.52 66.81,49.52 65.53,50.8 65.37,50.8 64.76,50.19 64.76,46.84 65.17,46.42 65.89,46.42 66.15,46.15 66.15,45.51 65.89,45.24 63,45.24 62.88,45.11 62.88,44.88 62.32,44.32 59.05,44.32 58.42,44.96 56.13,44.96 55.17,45.92 48.97,45.92 47.12,44.07 47.12,41.97 47.32,41.77 47.75,41.77 47.88,41.9 47.88,41.9 v2(48.08,42.1) 48.28,41.91 49.16,41.91 49.29,41.77 52.82,41.77 53.47,42.42 55.5,42.42 56.01,42.93 57.66,42.93 58.85,41.73 59.39,41.73 v2(59.77,42.1) 59.94,41.93 61.61,41.93 62.1,42.42 65.28,42.42 65.41,42.29 67.44,42.29 68.07,42.93 69.13,42.93 70.3,41.76 71.05,41.76 v2(71.4,42.1) 71.5,42 72.68,42 73.03,41.66 73.91,41.66 74.41,42.15 74.51,42.15 75.25,42.15 75.76,41.64 77.42,41.64 78.27,42.49 79.45,42.49 79.76,42.8 80.64,42.8 81.79,41.66 82.69,41.66 v2(83.13,42.1) 83.25,41.99 83.7,41.99 83.87,42.15 86.68,42.15 86.93,42.4 91.04,42.4 91.57,42.93 92.2,42.93 93.45,41.68 94.42,41.68 v2(94.82,42.08) 94.82,41.96 94.97,41.81 95.18,41.81 95.5,42.13 98.01,42.13 98.91,41.22 99.8,41.22 100.23,41.66 100.23,42.69 99.9,43.03 99.57,43.03 99.17,42.63 v1(99.17,42.63)
SOC_DDR3B_ECS_0#: length 132.5
  TOP w0.102: U42.L2 79.15,39.71 v2(79.15,39.69) ; U43.L2 90.83,39.71 v2(90.83,39.69) ; v2(67.41,39.69) 67.02,40.09 U41.L2 ; U24.AB34 70.02,67.92 v2(70.01,67.92) ; v2(55.78,39.69) 55.78,39.71 U40.L2
  TOP w0.127: U39.L2 43.31,39.71 v2(43.31,39.64)
  L3 w0.102: v2(90.83,39.69) 91.24,39.29 92.4,39.29 93.21,38.47 96.58,38.47 96.59,38.47 ; 42.14,42 42.14,42.66 ; 67.4,67.89 67.4,68.93 67.84,69.37 69.09,69.37 70.01,68.45 v2(70.01,67.92)
  L3 w0.114: 96.59,38.47 97.3,38.47 97.54,38.22 99.7,38.22 100.39,37.53 102.88,37.53 103.53,38.18 104.44,38.18 v1(105.16,37.47) ; 42.14,42.66 42.14,43.38 41.94,43.59 41.26,43.59 41.15,43.7 41.15,43.93 41.26,44.05 41.94,44.05 42.06,44.17 42.06,44.38 41.94,44.5 41.26,44.5 41.15,44.62 41.15,44.85 41.26,44.96 41.99,44.96 42.11,45.08 42.11,45.3 41.99,45.42 41.26,45.42 41.15,45.53 41.15,45.76 41.26,45.88 41.69,45.88 41.81,45.99 41.81,49.5 42.44,50.13 46.57,50.13 50.93,54.48 50.93,54.64 50.87,54.7 50.87,54.86 51.03,55.02 51.2,55.02 51.25,54.97 51.41,54.97 51.57,55.13 51.57,55.29 51.52,55.35 51.52,55.51 51.68,55.67 51.84,55.67 51.9,55.61 52.03,55.61 55.24,58.83 57.73,58.83 59.3,60.39 59.3,61.46 60.26,62.42 60.26,64.02 60.73,64.49 62.61,64.49 62.72,64.38 62.72,63.97 62.84,63.86 63.06,63.86 63.18,63.97 63.18,64.38 63.29,64.49 64.82,64.49 64.95,64.62 64.95,64.92 65.07,65.05 65.35,65.05 65.48,64.92 65.48,64.07 65.59,63.96 66.8,63.96 66.93,64.08 66.93,64.36 66.8,64.49 66.6,64.49 66.47,64.62 66.47,65.3 66.6,65.43 67.28,65.43 67.41,65.56 67.41,67.89 67.4,67.89 ; 42.14,42 42.14,41.7 42.55,41.3 42.55,40.4 v2(43.31,39.64)
  L5 w0.114: v2(90.83,39.69) 90.41,39.27 89.28,39.27 89.08,39.47 84.77,39.47 84.59,39.29 79.55,39.29 v2(79.15,39.69) 78.75,39.29 71.26,39.29 71.25,39.27 70.26,39.27 70.15,39.16 70.15,38.98 70.03,38.86 69.8,38.86 69.69,38.98 69.69,39.16 69.57,39.27 69.35,39.27 69.23,39.16 69.23,38.98 69.12,38.86 68.89,38.86 68.77,38.98 68.77,39.16 68.66,39.27 68.42,39.27 68.4,39.29 67.81,39.29 v2(67.41,39.69) 67.01,39.29 66.89,39.29 66.78,39.18 66.78,39 66.66,38.89 66.43,38.89 66.32,39 66.32,39.18 66.2,39.29 65.98,39.29 65.86,39.18 65.86,39 65.75,38.89 65.52,38.89 65.4,39 65.4,39.18 65.29,39.29 65.06,39.29 64.95,39.18 64.95,39 64.83,38.89 64.6,38.89 64.49,39 64.49,39.18 64.38,39.29 56.18,39.29 v2(55.78,39.69) 55.38,39.29 44.27,39.29 44.25,39.31 43.64,39.31 v2(43.31,39.64)
  BOTTOM w0.127: R786.1 105.16,37.65 v1(105.16,37.47)
SOC_DDR3B_EDM_0: length 37.6
  TOP w0.102: U24.N39 80.01,62.93 v2(80.09,62.93) ; v2(91.74,45.03) 91.75,45.03 91.75,44.55 91.88,44.42 93.78,44.42 93.9,44.55 93.9,44.78 94.03,44.9 U43.E7
  L8 w0.114: v2(80.09,62.93) 80.09,63.02 80.21,63.14 81.08,63.14 81.2,63.02 81.2,62.42 81.81,61.81 81.81,57.68 83.39,56.11 83.55,56.11 83.81,56.36 83.97,56.36 84.13,56.2 84.13,56.04 83.88,55.78 83.88,55.62 84.04,55.46 84.2,55.46 84.46,55.72 84.62,55.72 87.5,52.83 87.5,52.3 87.62,52.18 88.1,52.18 88.21,52.07 88.21,51.84 88.1,51.72 87.62,51.72 87.5,51.61 87.5,51.38 87.62,51.27 89.08,51.27 89.2,51.14 89.2,50.94 89.08,50.81 87.62,50.81 87.5,50.7 87.5,50.47 87.62,50.35 89,50.35 89.13,50.23 89.13,48.97 89.33,48.77 89.33,48.39 88.9,47.96 88.39,47.96 88.27,47.83 88.27,45.87 88.39,45.74 89.35,45.74 89.57,45.52 89.57,45.26 89.88,44.95 91.67,44.95 v2(91.74,45.03)
SOC_DDR3B_EDM_1: length 37.5
  TOP w0.102: U43.D3 91.29,45.7 91.72,46.14 v2(91.72,46.86) ; U24.P34 78.52,68.42 v2(79.02,67.92)
  L10 w0.102: v2(79.02,67.92) 79.63,67.31 80.26,67.31 80.4,67.18 80.4,63.16 81.03,62.53
  L10 w0.114: v2(91.72,46.86) 92.15,46.86 92.28,46.99 92.28,47.37 92.15,47.5 91.88,47.5 91.76,47.62 91.76,50.34 91.47,50.63 91.47,51.69 91.1,52.06 90.93,52.06 90.58,51.71 90.4,51.71 90.26,51.85 90.26,52.03 90.61,52.38 90.61,52.54 90.45,52.71 90.29,52.71 89.94,52.36 89.78,52.36 89.62,52.52 89.62,52.68 89.96,53.03 89.96,53.19 89.8,53.35 89.64,53.35 89.29,53.01 89.13,53.01 88.97,53.17 88.97,53.33 89.32,53.68 89.32,53.84 86.89,56.26 83.61,56.26 81.03,58.84 81.03,59.3 81.14,59.42 81.45,59.42 81.56,59.53 81.56,59.76 81.45,59.87 81.14,59.87 81.03,59.99 81.03,60.22 81.14,60.33 81.45,60.33 81.56,60.45 81.56,60.67 81.45,60.79 81.14,60.79 81.03,60.9 81.03,61.13 81.14,61.25 81.45,61.25 81.56,61.36 81.56,61.59 81.45,61.7 81.14,61.7 81.03,61.82 81.03,62.53
SOC_DDR3B_EDM_2: length 32.9
  TOP w0.102: U42.E7 82,44.9 v2(81.87,45.04)
  TOP w0.127: U24.U39 75.52,62.41 75.87,62.05 75.87,59.03 75.95,58.95 76.73,58.95 76.86,59.08 76.86,59.8 76.99,59.92 77.72,59.92 v1(77.82,59.82)
  L8 w0.114: v2(81.87,45.04) 81.53,45.37 81.53,46.33 81.31,46.56 81.31,49.58 80.89,50 80.89,50.4 81.39,50.91 81.39,51.07 81.23,51.23 81.07,51.23 80.56,50.73 80.4,50.73 80.24,50.89 80.24,51.05 81.08,51.89 81.08,52.07 80.94,52.21 80.76,52.21 79.92,51.37 79.75,51.37 79.51,51.61 79.51,52.25 79.63,52.36 80.15,52.36 80.26,52.48 80.26,52.71 80.15,52.82 79.63,52.82 79.51,52.94 79.51,53.16 79.63,53.28 80.15,53.28 80.26,53.39 80.26,53.62 80.15,53.74 79.63,53.74 79.51,53.85 79.51,54.08 79.63,54.19 80.15,54.19 80.26,54.31 80.26,54.54 80.15,54.65 79.63,54.65 79.51,54.76 79.51,55.23 78.54,56.21 78.54,59.55 78.26,59.82 v1(77.82,59.82)
SOC_DDR3B_EDM_3: length 35.3
  TOP w0.102: U24.U32 75.57,70.42 v2(76.02,69.98) ; v2(79.98,46.12) 79.97,46.12 U42.D3
  L10 w0.114: v2(79.98,46.12) 79.68,45.82 76.53,45.82 74.65,47.7 74.65,48.34 69.94,53.05 69.94,60.43 71.74,62.23 71.89,62.23 72.83,63.17 72.83,68.38 73.88,69.43 75.47,69.43 v2(76.02,69.98)
SOC_DDR3B_EDM_4: length 37.4
  TOP w0.102: U40.E7 58.24,44.9 v2(57.66,44.32) ; U24.AG33 v2(65.02,68.92)
  L8 w0.102: v2(65.02,68.92) 64.65,68.92 64.43,68.71 64.43,66.54 64.64,66.34 64.64,63.57
  L8 w0.114: 64.64,63.57 64.19,63.12 63.44,63.12 62.76,62.45 62.76,60.03 58.29,55.56 58.29,52.37 57.95,52.03 57.79,52.03 57.67,52.15 57.51,52.15 57.35,51.99 57.35,51.83 57.47,51.71 57.47,51.54 55.18,49.26 55.18,48.26 55.37,48.07 55.37,47.54 55.37,45.51 55.38,45.5 55.38,45.18 55.37,45.17 55.37,44.58 55.24,44.45 55.24,43.56 55.75,43.05 57.28,43.05 57.78,43.56 57.78,44.2 v2(57.66,44.32)
SOC_DDR3B_EDM_5: length 32.8
  TOP w0.102: U40.D3 56.86,45.7 57.29,46.14 58.37,46.14 58.5,46.27 58.5,46.7 58.37,46.83 v2(56.58,46.83)
  TOP w0.127: v2(63.3,62.41) 63.3,62.33 63.91,61.72 63.91,60.78 64.01,60.68 65.15,60.68 65.22,60.75 65.22,62.13 65.52,62.43 U24.AG39
  L10 w0.114: v2(63.3,62.41) 63.3,62.87 63.17,62.99 62.74,62.99 62.61,62.87 62.61,57.52 60.25,55.16 60.25,53.34 58.46,51.56 58.46,46.95 58.34,46.83 57.89,46.83 57.78,46.94 57.78,47.33 57.67,47.45 57.44,47.45 57.32,47.33 57.32,46.94 57.21,46.83 v2(56.58,46.83)
SOC_DDR3B_EDM_6: length 40.2
  TOP w0.102: v2(47.19,45.37) 47.24,45.37 U39.E7 ; U24.AK34 v2(62.02,67.92)
  L8 w0.102: 62.61,64.62 62.61,67.33 v2(62.02,67.92)
  L8 w0.114: v2(47.19,45.37) 47.5,45.68 49.08,45.68 49.3,45.45 49.3,43.84 49.61,43.54 51.71,43.54 51.84,43.66 51.84,44.22 51.71,44.35 50.62,44.35 50.5,44.47 50.5,44.68 50.62,44.81 51.8,44.81 51.91,44.92 51.91,49.31 56.21,53.61 56.21,57.35 56.44,57.58 57.72,57.58 60.45,60.32 60.45,61.69 62.61,63.85 62.61,64.62
SOC_DDR3B_EDM_7: length 37.6
  TOP w0.127: U24.AM39 60.52,62.12 60.04,61.65 59.36,61.65 59.23,61.77 59.23,62.03 v2(59.26,62.06) ; v2(44.9,46.1) 44.2,46.1 44.07,45.98 44.07,45.47 44.2,45.34 44.37,45.34 44.5,45.47 U39.D3
  L10 w0.114: v2(59.26,62.06) 59.26,62.3 59,62.56 57.83,62.56 57.71,62.45 57.71,61.53 57.6,61.42 57.37,61.42 57.26,61.53 57.26,62.45 57.14,62.56 56.87,62.56 56.74,62.43 56.74,61.73 56.62,61.61 55.92,61.61 55.22,60.91 54.41,60.91 54.19,60.69 54.19,60.53 54.58,60.14 54.58,59.96 54.45,59.83 54.24,59.83 53.87,60.21 53.7,60.21 52.43,58.93 52.43,56.16 52.76,55.83 54.66,55.83 54.79,55.7 54.79,55.23 54.66,55.11 53.2,55.11 46.34,48.25 46.34,47.55 v2(44.9,46.1)
SOC_DDR3B_EDM_8: length 37.2
  TOP w0.102: v2(67.02,64.92) 67.02,64.92 67.52,65.42 U24.AE37 ; U41.E7 68.43,44.9 68.25,44.73 68.25,44.22 v2(68.86,43.61)
  L8 w0.102: 67.36,42.34 68.07,43.05 68.3,43.05 v2(68.86,43.61)
  L8 w0.114: 67.36,42.34 65.76,42.34 64.87,43.24 64.87,43.4 65.35,43.88 65.35,44.05 65.19,44.21 65.03,44.21 64.54,43.72 64.38,43.72 64.24,43.87 64.24,44.98 64.01,45.21 64.01,45.76 63.89,45.87 63.45,45.87 63.32,46 63.32,46.2 63.45,46.33 63.89,46.33 64.01,46.44 64.01,46.67 63.89,46.79 63.49,46.79 63.37,46.9 63.37,47.13 63.49,47.24 63.89,47.24 64.01,47.36 64.01,49.48 66.81,52.29 66.81,55.84 67.51,56.53 67.51,61.75 67.02,62.24 v2(67.02,64.92)
SOC_DDR3B_EDQ0: length 37.8
  TOP w0.102: U43.E3 91.24,45.21 91.11,45.34 v2(90.81,45.34) ; v2(82.02,63.92) 81.52,64.42 U24.L38
  L8 w0.114: v2(82.02,63.92) 82.02,64.43 81.89,64.56 81.61,64.56 81.55,64.5 81.48,64.43 81.48,62.6 82.32,61.76 82.32,61.49 82.44,61.37 83.52,61.37 83.65,61.24 83.65,61.04 83.52,60.91 82.44,60.91 82.32,60.8 82.32,58.14 83.5,56.96 84.04,56.96 89.8,51.2 90.59,51.2 90.7,51.08 90.7,50.85 90.59,50.74 89.87,50.74 89.74,50.61 89.74,50.41 89.87,50.28 91.04,50.28 91.21,50.11 91.21,49.95 91.08,49.83 89.92,49.83 89.79,49.7 89.79,49.49 89.92,49.37 90.59,49.37 90.7,49.25 90.7,49.03 90.37,48.69 90.37,47.92 90.43,47.85 90.43,47.51 90.22,47.29 88.9,47.29 88.72,47.12 88.72,46.66 89.15,46.23 91.47,46.23 91.59,46.1 91.59,45.47 91.47,45.34 v2(90.81,45.34)
SOC_DDR3B_EDQ1: length 37.7
  TOP w0.102: U24.N34 79.52,68.42 v2(80.02,67.92)
  TOP w0.127: U43.F7 94.83,43.71 v2(94.85,43.71)
  L8 w0.102: 97.6,48.75 97.6,48.75
  L8 w0.114: 97.6,48.75 87.35,59 87.35,59.52 84.44,62.43 83.82,62.43 83.57,62.69 83.57,66.01 83.08,66.5 82.88,66.5 82.47,66.9 82.47,67.11 82.12,67.46 80.48,67.46 v2(80.02,67.92) ; v2(94.85,43.71) 95.41,43.15 97.16,43.15 97.89,43.89 97.89,48.46 97.6,48.75
SOC_DDR3B_EDQ2: length 37.5
  TOP w0.102: U43.F2 90.83,44.5 v2(90.83,44.53) ; v2(81.02,64.92) 80.52,65.42 U24.M37
  L8 w0.102: v2(81.02,64.92) 81.02,63.54 80.9,63.42 79.91,63.42 79.7,63.22 79.7,62.78 80,62.48 80.57,62.48
  L8 w0.114: 80.57,62.48 81.36,61.7 81.36,57.45 84.18,54.63 84.34,54.63 84.6,54.89 84.76,54.89 84.92,54.72 84.92,54.56 84.67,54.3 84.67,54.14 84.83,53.98 84.99,53.98 85.25,54.24 85.41,54.24 85.57,54.08 85.57,53.92 85.31,53.66 85.31,53.5 85.48,53.33 85.64,53.33 85.89,53.59 86.06,53.59 86.22,53.43 86.22,53.27 85.96,53.01 85.96,52.85 86.12,52.69 86.28,52.69 86.54,52.95 86.7,52.95 86.86,52.78 86.86,52.62 86.61,52.36 86.61,52.2 86.87,51.94 86.87,49.95 86.98,49.83 88.52,49.83 88.65,49.71 88.65,49.5 88.52,49.38 86.98,49.38 86.87,49.26 86.87,49.03 86.98,48.92 88.24,48.92 88.37,48.79 88.37,48.59 88.24,48.46 87.86,48.46 87.76,48.36 87.76,45.27 88.09,44.94 89.37,44.94 89.79,44.53 v2(90.83,44.53)
SOC_DDR3B_EDQ3: length 37.9
  TOP w0.102: v2(82.04,62.93) 82.01,62.93 U24.L39
  TOP w0.127: U43.F8 95.64,44.51 v2(95.64,44.53)
  L8 w0.114: v2(82.04,62.93) 82.04,62.54 82.83,61.75 83.79,61.75 86.13,59.41 86.13,58.09 87.07,57.15 87.9,57.15 93.1,51.95 93.1,51.07 94.08,50.09 94.08,49.12 94.36,48.84 94.36,47.29 94.49,47.17 95.17,47.17 95.3,47.29 95.3,48.26 95.43,48.39 95.92,48.39 96.04,48.26 96.04,46.11 95.81,45.87 95.33,45.87 95.2,45.75 95.2,44.98 95.07,44.86 94.51,44.86 94.39,44.98 94.39,46.15 94.26,46.28 93.85,46.28 93.73,46.15 93.73,44.98 93.6,44.86 93.24,44.86 93.12,44.73 93.12,44.25 93.26,44.1 95.21,44.1 v2(95.64,44.53)
SOC_DDR3B_EDQ4: length 37.8
  TOP w0.102: v2(90.84,42.9) 91.24,42.5 U43.H3 ; U24.N33 79.98,68.96 v2(80.02,68.96)
  L8 w0.102: 78.92,62.47 78.92,64.28 79.4,64.77 79.4,68.35 80.01,68.96 v2(80.02,68.96)
  L8 w0.114: v2(90.84,42.9) 90.22,42.29 88.85,42.29 88.74,42.41 88.74,42.76 88.62,42.88 88.4,42.88 88.28,42.76 88.28,42.41 88.17,42.29 87.94,42.29 87.82,42.41 87.82,42.76 87.71,42.88 87.48,42.88 87.37,42.76 87.37,42.41 87.25,42.29 86.74,42.29 85.31,43.72 85.31,50.51 82,53.81 82,54.83 79.96,56.87 79.96,61.43 78.92,62.47
SOC_DDR3B_EDQ5: length 37.8
  TOP w0.102: U24.N37 79.52,65.42 v2(80.02,64.92) ; U43.H8 95.61,42.88 96.16,42.88 96.49,43.21 96.49,43.64 v2(96.42,43.71)
  L8 w0.114: v2(80.02,64.92) 80.02,65.03 80.39,65.41 82.22,65.41 82.52,65.1 82.52,62.64 83.11,62.05 84.18,62.05 86.77,59.46 86.77,58.34 87.4,57.71 87.99,57.71 94.46,51.23 94.46,51.02 94.24,50.8 94.24,50.64 94.4,50.48 94.56,50.48 94.78,50.7 94.95,50.7 95.14,50.5 95.14,50.34 94.61,49.8 94.61,49.64 94.77,49.48 94.93,49.48 95.47,50.01 95.63,50.01 95.84,49.81 95.84,49.65 95.54,49.35 95.54,49.19 95.7,49.03 95.86,49.03 96.16,49.32 96.32,49.32 97.03,48.62 97.03,44.32 v2(96.42,43.71)
SOC_DDR3B_EDQ6: length 37.7
  TOP w0.102: U43.G2 90.46,43.32 90.46,43.73 90.41,43.77 90.07,43.77 v2(90,43.7) ; v2(80.02,65.92) 79.52,66.42 U24.N36
  L8 w0.102: 79.78,62.05 79.17,62.66 79.17,64.11 79.6,64.54 79.6,66.12 79.72,66.24 79.9,66.24 80.02,66.12 v2(80.02,65.92)
  L8 w0.114: 79.78,62.05 79.98,62.05 80.42,61.61 80.42,57.07 82.92,54.57 82.92,54.41 82.64,54.12 82.64,53.96 82.8,53.8 82.96,53.8 83.25,54.08 83.41,54.08 83.57,53.92 83.57,53.76 83.29,53.48 83.29,53.32 83.45,53.15 83.61,53.15 83.89,53.44 84.05,53.44 84.22,53.27 84.22,53.11 83.93,52.83 83.93,52.67 84.09,52.51 84.26,52.51 84.54,52.79 84.7,52.79 84.86,52.63 84.86,52.47 84.58,52.18 84.58,52.02 84.74,51.86 84.9,51.86 85.19,52.14 85.35,52.14 85.76,51.73 85.76,43.98 86.31,43.43 86.7,43.43 86.81,43.55 86.81,44.28 86.93,44.4 87.15,44.4 87.27,44.28 87.27,43.55 87.38,43.43 89.73,43.43 v2(90,43.7)
SOC_DDR3B_EDQ7: length 37.9
  TOP w0.102: U43.H7 94.12,42.5 v2(93.85,42.77) ; v2(79.98,63.92) 79.98,63.96 U24.N38
  L8 w0.102: 80.36,62.26 79.86,62.26 79.38,62.75 79.38,63.31 v2(79.98,63.92)
  L8 w0.114: 80.36,62.26 80.9,61.72 80.9,57.25 86.23,51.92 86.23,48.5 86.35,48.39 87.19,48.39 87.3,48.28 87.3,48.05 87.19,47.93 86.35,47.93 86.23,47.82 86.23,47.59 86.35,47.48 87.19,47.48 87.3,47.36 87.3,47.13 87.19,47.02 86.35,47.02 86.23,46.9 86.23,46.68 86.35,46.56 87.19,46.56 87.3,46.45 87.3,46.22 87.19,46.1 86.35,46.1 86.23,45.99 86.23,45.76 86.35,45.65 87.19,45.65 87.3,45.53 87.3,45.06 88.29,44.07 89.82,44.07 89.84,44.09 90.16,44.09 90.39,43.86 90.39,43.85 90.42,43.81 90.42,43.54 90.68,43.29 91.07,43.29 91.22,43.14 93.48,43.14 v2(93.85,42.77)
SOC_DDR3B_EDQ8: length 37.3
  TOP w0.102: v2(94.84,46.1) 94.44,45.7 U43.D7 ; U24.T32 76.95,69.99 v2(77.01,69.99)
  L10 w0.102: v2(94.84,46.1) 94.58,45.85 90.81,45.85 90.42,46.23 90.42,46.99 90.42,47 90.42,47.06 90.2,47.29 88.83,47.29 88.11,48.01 ; 77.6,62.63 77.6,67.32 77.4,67.52 77.4,69.67 77.08,69.99 v2(77.01,69.99)
  L10 w0.114: 88.11,48.01 87.12,49 87.12,50.16 86.89,50.39 86.89,51.87 85.57,53.19 84.1,53.19 78.54,58.75 78.54,59.61 78.97,60.05 78.97,61.26 77.6,62.63
SOC_DDR3B_EDQ9: length 37.3
  TOP w0.102: v2(78.01,69.98) 77.96,69.98 U24.R32 ; U43.C3 91.16,46.5 v2(90.81,46.86)
  L10 w0.102: v2(78.01,69.98) 78.01,70.02 77.9,70.13 77.8,70.13 77.64,69.97 77.64,67.77 77.86,67.54 77.94,67.54 78.4,67.08 78.4,64.59 ; 90.17,48.41 90.42,48.16 90.42,47.5 90.81,47.12 v2(90.81,46.86)
  L10 w0.114: 90.17,48.41 90.06,48.53 89.89,48.53 89.57,48.21 89.41,48.21 89.25,48.37 89.25,48.53 89.57,48.85 89.57,49.01 89.39,49.19 89.23,49.19 88.96,48.92 88.78,48.92 88.63,49.06 88.63,49.24 89,49.61 89,49.79 88.86,49.93 88.68,49.93 88.15,49.4 87.97,49.4 87.82,49.54 87.82,49.72 88.27,50.17 88.27,50.35 88.13,50.5 87.95,50.5 87.79,50.34 87.61,50.34 87.47,50.48 87.47,50.66 87.61,50.81 87.61,50.97 87.48,51.1 87.48,52.12 85.93,53.67 85.72,53.67 85.6,53.78 85.6,54.03 85.47,54.15 85.27,54.15 85.14,54.03 85.14,53.78 85.03,53.67 84.26,53.67 79.43,58.5 79.43,58.79 79.32,58.9 79.11,58.9 78.99,59.02 78.99,59.25 79.11,59.36 79.32,59.36 79.43,59.48 79.43,61.54 78.18,62.79 78.18,64.37 78.4,64.59
SOC_DDR3B_EDQ10: length 37.3
  TOP w0.102: v2(79.02,66.92) 78.52,67.42 U24.P35 ; U43.C8 95.24,46.51 v2(95.64,46.9)
  L10 w0.102: 91.3,48.77 91.3,46.49 91.57,46.23 92.79,46.23 92.89,46.33 92.89,46.58 92.99,46.69 93.2,46.69 93.3,46.58 93.3,46.33 93.4,46.23 94.11,46.23 94.49,46.61 95.34,46.61 v2(95.64,46.9)
  L10 w0.114: v2(79.02,66.92) 79.63,66.31 79.63,64.57 79.2,64.13 79.2,63.2 80.36,62.04 80.36,58.87 83.42,55.8 83.85,55.8 83.96,55.69 83.96,55.33 84.07,55.22 84.3,55.22 84.42,55.33 84.42,55.69 84.53,55.8 84.76,55.8 84.87,55.69 84.87,55.33 84.99,55.22 85.22,55.22 85.33,55.33 85.33,55.69 85.45,55.8 85.67,55.8 85.79,55.69 85.79,55.22 85.92,55.09 86.12,55.09 86.25,55.22 86.25,55.69 86.36,55.8 86.59,55.8 88.44,53.95 88.44,53.01 91.3,50.15 91.3,48.77
SOC_DDR3B_EDQ11: length 37.2
  TOP w0.102: U43.C2 v2(90.04,46.9) ; U24.R39 77.27,63.42 76.96,63.12 v2(76.96,62.93)
  L10 w0.114: v2(76.96,62.93) 76.96,62.61 77.34,62.23 77.34,58.97 78.1,58.21 78.4,58.21 84.04,52.57 84.2,52.57 84.34,52.72 84.52,52.72 84.66,52.57 84.66,52.39 84.52,52.25 84.52,52.09 84.68,51.93 84.84,51.93 85.42,52.5 85.6,52.5 85.74,52.36 85.74,52.18 85.17,51.6 85.17,51.44 85.33,51.28 85.49,51.28 86.04,51.83 86.22,51.83 86.36,51.69 86.36,51.51 85.81,50.96 85.81,50.8 86.66,49.95 86.66,48.75 86.82,48.59 86.82,48.43 86.55,48.16 86.55,47.99 86.71,47.83 86.87,47.83 87.14,48.1 87.3,48.1 87.47,47.94 87.47,47.78 86.51,46.82 86.51,46.64 86.65,46.5 86.83,46.5 87.79,47.46 87.95,47.46 88.11,47.29 88.11,47.13 86.91,45.93 86.91,45.75 87.06,45.61 87.24,45.61 88.44,46.81 88.6,46.81 89.04,46.37 89.04,45.94 89.15,45.82 89.56,45.82 89.69,45.95 89.69,46.78 89.81,46.9 v2(90.04,46.9)
SOC_DDR3B_EDQ12: length 37.3
  TOP w0.102: v2(93.09,45.42) 93.09,47.55 93.65,48.1 U43.A7 ; U24.R38 77.52,64.41 77.04,63.93 v2(77.04,63.92)
  L10 w0.114: v2(93.09,45.42) 91.77,44.09 89.84,44.09 89.69,43.94 87.76,43.94 87.4,44.29 87.4,44.46 88.01,45.06 88.01,45.22 87.84,45.38 87.68,45.38 87.08,44.78 86.92,44.78 86.05,45.65 86.05,49.85 78.17,57.73 77.94,57.73 76.89,58.79 76.89,61.59 76.89,61.9 76.56,62.23 76.56,63.55 76.93,63.92 v2(77.04,63.92)
SOC_DDR3B_EDQ13: length 37.3
  TOP w0.102: U24.N32 79.96,69.98 v2(80.02,69.98)
  TOP w0.127: v2(92.58,48.41) 91.92,49.07 90.65,49.07 90.32,48.74 90.32,48.22 U43.A2
  L10 w0.102: 82.07,61.67 82.07,61.96 80.62,63.41 80.62,69.38 v2(80.02,69.98)
  L10 w0.114: v2(92.58,48.41) 92.31,48.69 92.31,49.43 92.42,49.54 93.5,49.54 93.62,49.67 93.62,49.87 93.5,50 92.42,50 92.31,50.11 92.31,50.34 92.42,50.46 92.88,50.46 92.99,50.57 92.99,50.8 92.88,50.91 92.42,50.91 92.31,51.03 92.31,51.53 87.07,56.77 83.75,56.77 82.85,57.67 82.85,57.67 82.51,58.01 82.07,58.45 82.07,59.54 82.18,59.65 82.36,59.65 82.47,59.77 82.47,60 82.36,60.11 82.18,60.11 82.07,60.22 82.07,60.45 82.18,60.57 82.36,60.57 82.47,60.68 82.47,60.91 82.36,61.02 82.18,61.02 82.07,61.14 82.07,61.67
SOC_DDR3B_EDQ14: length 37.5
  TOP w0.102: U43.B8 94.89,47.65 94.89,47.68 v2(94.89,47.68) ; U24.R33 77.52,69.42 v2(78.02,68.92)
  L10 w0.114: v2(94.89,47.68) 95.63,48.42 95.63,50.29 92.15,53.77 92.15,55.8 88.36,59.59 88.2,59.59 87.83,59.22 87.67,59.22 87.51,59.38 87.51,59.54 87.88,59.91 87.88,60.08 87.76,60.2 86.86,60.2 86.07,60.99 83.34,60.99 81.53,62.79 81.53,70.05 81.1,70.48 79.58,70.48 v2(78.02,68.92)
SOC_DDR3B_EDQ15: length 37.3
  TOP w0.102: U24.P36 78.52,66.42 v2(79.02,65.92)
  TOP w0.114: v2(90.81,48.5) 90.81,48.62 90.93,48.74 91.69,48.74 91.82,48.62 91.82,48.23 91.69,48.1 U43.A3
  L10 w0.102: 78.61,64.43 78.61,65.52 v2(79.02,65.92)
  L10 w0.114: v2(90.81,48.5) 90.81,48.89 90.68,49.02 90.25,49.02 89.97,49.3 89.97,49.59 90.12,49.74 90.47,50.09 90.47,50.27 90.33,50.41 90.15,50.41 89.69,49.96 89.51,49.96 89.37,50.1 89.37,50.28 89.82,50.74 89.82,50.92 89.68,51.06 89.5,51.06 88.97,50.53 88.79,50.53 88.65,50.67 88.65,50.85 89.18,51.38 89.18,51.56 89.03,51.71 88.85,51.71 88.33,51.19 88.16,51.19 88.01,51.33 88.01,51.51 88.33,51.83 88.33,51.99 87.71,52.62 87.71,52.78 87.98,53.06 87.98,53.24 87.84,53.38 87.66,53.38 87.38,53.11 87.22,53.11 87.06,53.27 87.06,53.43 87.59,53.96 87.59,54.14 87.45,54.28 87.27,54.28 86.74,53.75 86.57,53.75 86.41,53.91 86.41,54.08 86.93,54.6 86.93,54.77 86.79,54.92 86.61,54.92 86.09,54.4 85.93,54.4 85.56,54.76 84.88,54.76 84.76,54.65 84.76,54.31 84.61,54.15 84.46,54.15 84.31,54.31 84.31,54.65 84.19,54.76 83.81,54.76 79.89,58.69 79.89,61.81 78.61,63.08 78.61,64.43
SOC_DDR3B_EDQ16: length 32.8
  TOP w0.102: v2(77.02,67.92) 76.52,68.42 U24.T34 ; v2(79.13,44.5) 79.53,44.9 U42.E3
  L8 w0.102: v2(77.02,67.92) 76.46,68.48 76.46,69.07 76.76,69.37 77.51,69.37 77.64,69.24 77.64,65.66 77.43,65.46 77.43,64.8 77.18,64.54 77.11,64.54
  L8 w0.114: 77.11,64.54 76.58,64.01 76.58,63.73 76.78,63.53 76.78,63.32 76.66,63.2 76.08,63.2 75.95,63.07 75.95,55 75.39,54.43 75.39,50.56 76.94,49.01 76.94,45.21 77.19,44.96 78.92,44.96 79.13,44.75 v2(79.13,44.5)
SOC_DDR3B_EDQ17: length 32.9
  TOP w0.102: v2(78.02,67.92) 77.52,68.42 U24.R34 ; U42.F7 82.75,44.42 82.83,44.5 v2(83.15,44.5)
  L8 w0.114: v2(78.02,67.92) 78.54,67.4 78.54,62.2 79.45,61.29 79.45,56.69 81.41,54.74 81.41,53.57 83.57,51.41 83.57,50.82 83.68,50.7 84.21,50.7 84.33,50.59 84.33,50.36 84.21,50.25 83.68,50.25 83.57,50.13 83.57,49.9 83.68,49.79 84.21,49.79 84.33,49.68 84.33,49.45 84.21,49.33 83.68,49.33 83.57,49.22 83.57,48.99 83.68,48.88 84.21,48.88 84.33,48.76 84.33,48.53 84.21,48.42 83.68,48.42 83.57,48.3 83.57,47.87 83.57,47.86 83.57,46.56 84.34,45.78 84.34,44.35 84.11,44.12 83.54,44.12 v2(83.15,44.5)
SOC_DDR3B_EDQ18: length 32.9
  TOP w0.102: v2(78.35,44.5) 78.44,44.42 U42.F2 ; U24.T35 76.52,67.42 v2(77.02,66.92)
  L8 w0.102: v2(77.02,66.92) 77.02,67.06 76.89,67.18 76.56,67.18 76.43,67.06 76.43,66.55 76.58,66.4 77.14,66.4 77.4,66.14 77.4,65.77 77.04,65.41 76.96,65.41 76.62,65.06 76.62,64.45 76.56,64.39
  L8 w0.114: 76.56,64.39 75.5,63.33 75.5,58.92 75.38,58.8 75.07,58.8 74.96,58.69 74.96,58.46 75.07,58.34 75.37,58.34 75.5,58.22 75.5,58.01 75.37,57.89 75.06,57.89 74.93,57.76 74.93,57.56 75.06,57.43 75.37,57.43 75.5,57.3 75.5,57.1 75.37,56.97 75.06,56.97 74.93,56.85 74.93,56.64 75.06,56.52 75.37,56.52 75.5,56.39 75.5,56.19 75.37,56.06 75.06,56.06 74.93,55.93 74.93,55.73 75.06,55.6 75.38,55.6 75.5,55.49 75.5,55.26 75.38,55.14 75.06,55.14 74.93,55.02 74.93,50.34 76.45,48.82 76.45,45.14 76.66,44.93 76.66,44.25 76.81,44.09 77.94,44.09 v2(78.35,44.5)
SOC_DDR3B_EDQ19: length 33
  TOP w0.102: U42.F8 83.55,44.11 v2(83.95,44.5) ; v2(78.02,64.92) 77.52,65.42 U24.R37
  L8 w0.114: v2(78.02,64.92) 78.02,62.07 78.99,61.1 78.99,56.45 80.75,54.7 80.75,53.29 81.89,52.15 81.89,51.66 82,51.55 82.77,51.55 82.88,51.43 82.88,51.21 82.77,51.09 82,51.09 81.89,50.98 81.89,50.75 82,50.63 82.77,50.63 82.88,50.52 82.88,50.29 82.77,50.18 82,50.18 81.89,50.06 81.89,49.83 82,49.72 82.77,49.72 82.88,49.61 82.88,49.38 82.77,49.26 82,49.26 81.89,49.15 81.89,48.92 82,48.81 82.77,48.81 82.88,48.69 82.88,48.46 82.77,48.35 82,48.35 81.89,48.23 81.89,47.52 82.12,47.29 82.51,47.29 82.77,47.04 82.77,46.36 82.89,46.23 83.21,46.23 83.34,46.1 83.34,45.69 83.21,45.57 82.63,45.57 82.5,45.44 82.5,45.03 82.63,44.91 83.54,44.91 v2(83.95,44.5)
SOC_DDR3B_EDQ20: length 33.1
  TOP w0.102: U42.H3 v2(79.15,42.9) ; v2(78.02,65.92) 77.52,66.42 U24.R36
  L8 w0.102: 77.64,64.55 77.64,65.15 78.02,65.53 v2(78.02,65.92)
  L8 w0.114: 77.64,64.55 77.64,62.73 77.46,62.55 76.56,62.55 76.43,62.42 76.43,62.15 76.56,62.02 77.34,62.02 77.47,61.89 77.47,61.69 77.34,61.56 76.54,61.56 76.41,61.43 76.41,54.57 75.95,54.1 75.95,50.7 76.6,50.05 76.76,50.05 76.95,50.24 77.11,50.24 77.28,50.08 77.28,49.92 77.08,49.72 77.08,49.56 77.24,49.4 77.4,49.4 77.7,49.7 77.88,49.7 78.03,49.56 78.03,49.38 77.73,49.08 77.73,48.92 77.95,48.69 77.95,45.8 78.28,45.47 78.87,45.47 79.65,44.68 80.06,44.68 80.16,44.58 80.16,44.24 80.04,44.12 78.99,44.12 78.74,43.87 78.74,43.13 78.97,42.9 v2(79.15,42.9)
SOC_DDR3B_EDQ21: length 33.1
  TOP w0.102: U42.H8 v2(83.93,42.88) ; v2(76.02,64.92) 75.8,65.14 75.52,65.42 U24.U37
  L8 w0.102: v2(83.93,42.88) 83.93,42.78 83.63,42.49 82.99,42.49 82.99,42.48 80.96,42.48
  L8 w0.114: 80.96,42.48 80.95,42.49 79.82,42.49 79.62,42.29 77.32,42.29 74.8,44.81 74.8,48.06 73.89,48.97 73.89,62.79 v2(76.02,64.92)
SOC_DDR3B_EDQ22: length 33
  TOP w0.102: v2(77.02,65.92) 76.81,66.14 76.52,66.42 U24.T36 ; U42.G2 v2(78.35,43.7)
  L8 w0.102: v2(77.02,65.92) 76.4,65.3 76.4,64.66
  L8 w0.114: v2(78.35,43.7) 78.35,43.48 78.05,43.18 77.1,43.18 75.94,44.34 75.94,44.5 76.1,44.66 76.1,44.83 75.94,44.99 75.78,44.99 75.62,44.82 75.46,44.82 75.29,45 75.29,45.7 75.4,45.82 75.88,45.82 76,45.93 76,46.16 75.88,46.28 75.4,46.28 75.29,46.39 75.29,46.62 75.4,46.73 75.88,46.73 76,46.85 76,47.08 75.88,47.19 75.4,47.19 75.29,47.3 75.29,47.53 75.4,47.65 75.88,47.65 76,47.76 76,47.99 75.88,48.1 75.4,48.1 75.29,48.22 75.29,48.67 75.51,48.89 75.51,49.05 75.35,49.22 75.18,49.22 74.83,48.86 74.66,48.86 74.47,49.05 74.47,58.85 75.04,59.42 75.04,63.3 76.4,64.66
SOC_DDR3B_EDQ23: length 32.7
  TOP w0.102: U42.H7 82.78,42.5 v2(83.14,42.87)
  TOP w0.127: U24.U38 75.08,63.99 75.08,62.08 75.36,61.8 75.36,58.78 75.69,58.45 77.64,58.45 77.8,58.61 v1(77.8,59.14)
  L8 w0.114: v2(83.14,42.87) 81.56,42.87 81.43,42.99 81.43,43.31 81.56,43.44 82.54,43.44 82.65,43.55 82.65,43.78 82.54,43.89 81.56,43.89 81.43,44.02 81.43,44.98 81.15,45.26 81.15,46.1 80.34,46.91 80.34,47.48 80.45,47.59 80.73,47.59 80.85,47.71 80.85,47.93 80.73,48.05 80.45,48.05 80.34,48.16 80.34,48.39 80.45,48.51 80.73,48.51 80.85,48.62 80.85,48.85 80.73,48.96 80.45,48.96 80.34,49.08 80.34,49.58 79.06,50.86 79.06,54.88 77.79,56.15 77.79,59.13 v1(77.8,59.14)
SOC_DDR3B_EDQ24: length 35.2
  TOP w0.102: U24.V35 74.52,67.42 v2(75.02,66.92) ; v2(82.1,46.17) 82.56,45.7 U42.D7
  L10 w0.102: 83.57,48.05 83.57,47.57 83.32,47.32 83.03,47.32 82.73,47.02 82.73,46.75 82.51,46.52 82.45,46.52 v2(82.1,46.17) ; 75.43,63.8 76.4,64.77 76.4,66.08 76.18,66.3 75.64,66.3 v2(75.02,66.92)
  L10 w0.114: 75.43,63.8 75.43,63.08 75.32,62.97 74.96,62.97 74.83,62.84 74.83,62.64 75.43,62.03 75.43,60.68 75.32,60.56 75.12,60.56 75.01,60.45 75.01,60.22 75.12,60.1 75.32,60.1 75.43,59.99 75.43,58.3 77.09,56.64 77.09,55.3 79.65,52.73 80.18,52.73 80.29,52.84 80.29,53.2 80.4,53.31 80.63,53.31 80.75,53.2 80.75,52.84 80.86,52.73 81.23,52.73 81.37,52.59 81.47,52.49 81.47,52.33 81.28,52.13 81.28,51.97 81.44,51.81 81.6,51.81 81.79,52 81.95,52 82.12,51.84 82.12,51.68 81.92,51.49 81.92,51.33 82.08,51.16 82.25,51.16 82.44,51.36 82.6,51.36 82.76,51.2 82.76,51.03 82.57,50.84 82.57,50.68 82.73,50.52 82.89,50.52 83.09,50.71 83.25,50.71 83.43,50.53 83.43,50.3 83.13,50.01 83.13,49.68 83.25,49.56 84.09,49.56 84.2,49.45 84.2,49.22 84.09,49.11 83.25,49.11 83.13,48.99 83.13,48.49 83.57,48.05
SOC_DDR3B_EDQ25: length 35.1
  TOP w0.102: U42.C3 80.22,46.5 80.44,46.28 81.43,46.28 81.64,46.48 81.64,47.22 81.43,47.42 80.31,47.42 79.95,47.06 v2(79.95,46.9) ; v2(76.02,65.92) 75.52,66.42 U24.U36
  L10 w0.102: v2(79.95,46.9) 79.69,46.9 79.5,47.09 79.5,47.88 80.11,48.49 80.11,48.77
  L10 w0.114: v2(76.02,65.92) 75.72,65.92 75.49,65.7 75.49,64.24 73.1,61.85 73.1,61.65 71.42,59.97 71.42,53.63 75.24,49.81 75.47,49.81 75.58,49.69 75.58,49.59 75.7,49.48 75.92,49.48 76.04,49.59 76.04,49.69 76.15,49.81 76.38,49.81 76.5,49.69 76.5,49.59 76.61,49.48 76.84,49.48 76.95,49.59 76.95,49.69 77.07,49.81 77.3,49.81 77.41,49.69 77.41,49.59 77.52,49.48 77.75,49.48 77.87,49.59 77.87,49.69 77.98,49.81 78.21,49.81 78.32,49.69 78.32,49.59 78.44,49.48 78.67,49.48 78.78,49.59 78.78,49.69 78.9,49.81 79.53,49.81 80.11,49.23 80.11,48.77
SOC_DDR3B_EDQ26: length 35.2
  TOP w0.102: U24.U34 75.52,68.42 v2(76.02,67.92) ; v2(83.15,46.9) 83.55,46.5 U42.C8
  L10 w0.102: 84.73,48.77 84.73,48.41 84.33,48.01 84.33,47.55 84.11,47.32 83.82,47.32 83.4,46.9 v2(83.15,46.9) ; v2(76.02,67.92) 76.6,67.34 76.6,64.56 75.89,63.85
  L10 w0.114: 75.89,63.85 75.89,58.49 77.71,56.67 77.94,56.67 78.17,56.44 78.17,56.28 77.61,55.72 77.61,55.54 77.75,55.4 77.93,55.4 78.49,55.95 78.65,55.95 78.81,55.79 78.81,55.63 78.19,55.01 78.19,54.84 78.35,54.69 78.51,54.69 79.14,55.31 79.3,55.31 79.46,55.15 79.46,54.98 78.84,54.36 78.84,54.19 78.99,54.04 79.16,54.04 79.78,54.66 79.94,54.66 80.11,54.5 80.11,54.34 79.51,53.74 79.51,53.56 79.65,53.42 79.83,53.42 80.43,54.01 80.59,54.01 84.73,49.87 84.73,48.77
SOC_DDR3B_EDQ27: length 35.3
  TOP w0.102: U24.W38 73.51,64.41 72.9,63.8 72.9,61.87 72.62,61.59 ; U42.C2 v2(78.35,46.9)
  TOP w0.127: 72.62,61.59 72.62,59.64 72.75,59.51 73.1,59.51 73.2,59.61 v1(73.2,60.48)
  L10 w0.102: 80.77,48.77 80.77,47.18 80.11,46.52 78.73,46.52 v2(78.35,46.9)
  L10 w0.114: v1(73.2,60.48) 72.72,60.48 71.88,59.63 71.88,54.6 72,54.49 72.38,54.49 72.49,54.38 72.49,54.15 72.38,54.03 72,54.03 71.88,53.92 71.88,53.82 73.24,52.46 73.4,52.46 73.55,52.6 73.71,52.6 73.87,52.44 73.87,52.28 73.73,52.13 73.73,51.97 73.89,51.81 74.05,51.81 74.19,51.96 74.36,51.96 74.52,51.8 74.52,51.63 74.37,51.49 74.37,51.33 74.53,51.16 74.7,51.16 74.96,51.43 75.14,51.43 75.28,51.29 75.28,51.11 75.02,50.84 75.02,50.68 75.43,50.26 75.85,50.26 75.96,50.38 75.96,50.71 76.08,50.83 76.3,50.83 76.42,50.71 76.42,50.38 76.53,50.26 76.76,50.26 76.88,50.38 76.88,50.71 76.99,50.83 77.22,50.83 77.33,50.71 77.33,50.38 77.45,50.26 79.78,50.26 80.77,49.28 80.77,48.77
SOC_DDR3B_EDQ28: length 35.3
  TOP w0.102: U24.W39 73.13,63.03 73.13,61.59 ; U42.A7 83.16,47.7 v2(83.16,47.7)
  TOP w0.127: v1(74.47,59.56) 74.27,59.56 73.71,60.12 73.71,60.73 73.13,61.32 73.13,61.59
  L10 w0.102: 82.53,48.77 82.53,48.33 v2(83.16,47.7)
  L10 w0.114: v1(74.47,59.56) 73.94,59.03 73.94,58.84 74.07,58.71 74.84,58.71 74.96,58.6 74.96,58.37 74.84,58.25 74.23,58.25 74.12,58.14 74.12,57.02 74.24,56.9 74.55,56.9 74.68,57.02 74.68,57.49 74.8,57.62 75.43,57.62 75.59,57.46 75.59,57.29 75.02,56.73 75.02,56.55 75.17,56.4 75.35,56.4 75.91,56.97 76.07,56.97 76.24,56.81 76.24,56.65 75.74,56.15 75.74,55.99 75.91,55.82 75.91,55.65 75.53,55.28 75.53,55.1 75.68,54.95 75.86,54.95 76.32,55.42 76.5,55.42 76.63,55.3 76.63,55.08 76.02,54.47 76.02,54.31 76.18,54.15 76.34,54.15 76.88,54.68 77.04,54.68 77.2,54.52 77.2,54.36 76.75,53.91 76.75,53.73 76.89,53.59 77.07,53.59 77.53,54.04 77.69,54.04 77.85,53.88 77.85,53.71 77.38,53.25 77.38,53.07 77.53,52.93 77.71,52.93 78.17,53.39 78.33,53.39 78.5,53.23 78.5,53.07 77.96,52.53 77.96,52.35 78.11,52.21 78.29,52.21 78.82,52.74 78.98,52.74 79.48,52.25 80.34,52.25 82.53,50.06 82.53,48.77
SOC_DDR3B_EDQ29: length 35.3
  TOP w0.102: v2(76.02,68.92) 75.52,69.42 U24.U33 ; U42.A2 78.75,48.3 78.55,48.5 v2(78.35,48.5)
  L10 w0.114: v2(76.02,68.92) 75.63,68.53 73.46,68.53 73.25,68.33 73.25,63.09 70.4,60.24 70.4,53.25 75.15,48.5 75.15,47.85 76.11,46.89 76.81,46.89 77.06,47.14 77.06,47.85 77.33,48.12 77.79,48.12 77.97,47.94 77.97,47.54 78.19,47.32 78.79,47.32 78.99,47.52 78.99,48.26 78.75,48.5 v2(78.35,48.5)
SOC_DDR3B_EDQ30: length 35.3
  TOP w0.102: v2(75.06,69.98) 74.93,69.98 74.52,70.39 U24.V32 ; U42.B8 v2(83.95,46.9)
  L10 w0.102: 76.23,63.88 76.89,64.54 77.24,64.54 77.4,64.7 77.4,67.08 77.18,67.3 77.09,67.3 76.52,67.88 76.52,70.02 76.17,70.36 75.44,70.36 v2(75.06,69.98)
  L10 w0.114: v2(83.95,46.9) 83.95,46.43 83.83,46.3 83.62,46.3 83.49,46.18 83.49,45.95 83.62,45.82 85.01,45.82 85.42,46.23 85.42,49.83 78.1,57.15 77.87,57.15 76.34,58.68 76.34,61.78 76.23,61.9 76.23,63.88
SOC_DDR3B_EDQ31: length 35.3
  TOP w0.102: v2(75.02,65.92) 74.52,66.42 U24.V36
  TOP w0.127: U42.A3 80.69,48.1 80.85,48.26 80.85,49.12 80.7,49.28 79.45,49.28 79.3,49.12 79.3,48.67 79.36,48.61 v2(79.6,48.61)
  L10 w0.114: v2(75.02,65.92) 74.79,65.92 74.57,66.14 74.57,67.34 74.45,67.46 73.84,67.46 73.61,67.23 73.61,62.8 70.97,60.16 70.97,53.39 75.36,49 75.76,49 75.88,48.88 75.88,48.25 75.99,48.13 76.22,48.13 76.33,48.25 76.33,48.88 76.45,49 79.38,49 79.6,48.77 v2(79.6,48.61)
SOC_DDR3B_EDQ32: length 37.4
  TOP w0.102: v2(57.41,45.72) 57.91,45.72 58.04,45.59 58.04,45.03 57.91,44.9 57.58,44.9 57.48,45.01 57.48,45.14 57.38,45.24 57.18,45.24 57.07,45.14 57.07,44.92 56.96,44.81 56.79,44.81 56.67,44.92 56.67,45.19 56.54,45.31 56.3,45.31 56.19,45.2 U40.E3 ; v2(65.02,64.08) 65.02,64.12 65.02,64.13 65.02,65.23 65.22,65.42 U24.AG37
  L8 w0.114: v2(65.02,64.08) 65.02,62.27 64.65,61.9 64.65,58.3 61.9,55.55 61.9,53.36 62.01,53.24 63,53.24 63.12,53.13 63.12,52.9 63,52.79 62.01,52.79 61.9,52.67 61.9,52.13 60.8,51.03 59.81,51.03 59.71,50.92 59.71,50.76 60.28,50.19 60.28,50.01 60.13,49.87 59.95,49.87 59.29,50.53 59.11,50.53 58.97,50.39 58.97,50.21 59.38,49.79 59.38,49.63 59.22,49.47 59.06,49.47 58.74,49.79 58.57,49.79 58.45,49.66 58.45,49.15 58.57,49.02 58.9,49.02 59.03,48.89 59.03,48.62 58.9,48.49 57.91,48.49 57.78,48.36 57.78,48.15 57.9,48.04 58.42,48.04 58.55,47.91 58.55,47.71 58.42,47.58 57.9,47.58 57.78,47.47 57.78,47.24 57.9,47.13 58.42,47.13 58.55,47 58.55,46.79 58.42,46.67 57.9,46.67 57.78,46.55 57.78,45.9 57.61,45.72 v2(57.41,45.72)
SOC_DDR3B_EDQ33: length 37.4
  TOP w0.102: v2(66.02,65.92) U24.AF36 ; v2(59,43.66) 59,43.72 U40.F7
  L8 w0.102: 66.42,64.49 66.42,65.52 v2(66.02,65.92)
  L8 w0.114: 66.42,64.49 66.27,64.34 66.27,61.93 66.48,61.72 66.48,57.1 65.79,56.41 65.79,52.83 61.98,49.02 61.98,45.72 62.31,45.39 62.31,44.81 62.17,44.67 61.62,44.67 61.49,44.54 61.49,44.34 61.62,44.21 61.9,44.21 62.03,44.08 62.03,43.79 62.15,43.66 62.81,43.66 62.94,43.54 62.94,43.33 62.81,43.21 62.08,43.21 61.95,43.08 61.95,42.82 62.08,42.7 63.55,42.7 63.68,42.57 63.68,42.34 63.55,42.21 61.16,42.21 61.04,42.34 61.04,43.17 60.91,43.29 60.43,43.29 60.39,43.26 59.13,43.26 59,43.38 v2(59,43.66)
SOC_DDR3B_EDQ34: length 37.7
  TOP w0.102: v2(63.89,62.34) 63.89,62.04 64.13,61.8 64.59,61.8 65.14,62.35 65.14,63.58 65.52,63.96 U24.AG38 ; v2(56.77,44.32) 56.77,44.42 56.64,44.55 55.04,44.55 54.91,44.42 54.91,44.23 55.04,44.1 U40.F2
  L8 w0.114: v2(56.77,44.32) 56.89,44.44 56.89,45.86 57.42,46.39 57.42,49.5 59.43,51.5 60.63,51.5 61.43,52.31 61.43,52.77 61.31,52.89 60.29,52.89 60.17,53 60.17,53.23 60.29,53.34 61.31,53.34 61.43,53.46 61.43,53.69 61.31,53.8 60.29,53.8 60.17,53.92 60.17,54.14 60.29,54.26 61.31,54.26 61.43,54.37 61.43,54.6 61.31,54.72 60.29,54.72 60.17,54.83 60.17,55.06 60.29,55.17 61.31,55.17 61.43,55.29 61.43,55.76 61.82,56.16 61.82,56.39 61.56,56.65 61.56,56.86 61.78,57.08 61.94,57.08 62.27,56.75 62.44,56.75 62.6,56.91 62.6,57.07 62.27,57.39 62.27,57.57 62.43,57.73 62.61,57.73 62.88,57.46 63.14,57.46 64.19,58.51 64.19,62.04 v2(63.89,62.34)
SOC_DDR3B_EDQ35: length 37.3
  TOP w0.102: U24.AG34 v2(65.02,67.92) ; v2(59.77,45.31) 59.77,44.35 60.01,44.1 U40.F8
  L8 w0.102: 65.71,64.31 65.43,64.6 65.43,66.05 65.06,66.42 65.06,66.42 64.98,66.42 64.64,66.77 64.64,68.24 64.75,68.35 64.91,68.35 65.02,68.24 v2(65.02,67.92)
  L8 w0.114: v2(59.77,45.31) 59.77,45.16 59.89,45.03 60.27,45.03 60.4,44.91 60.4,44.65 60.27,44.53 58.95,44.53 58.83,44.65 58.83,45.19 59.49,45.85 60.38,45.85 60.5,45.97 60.5,46.25 60.38,46.38 60.07,46.38 59.94,46.51 59.94,48.82 60.07,48.95 60.55,48.95 64.87,53.26 64.87,54.02 64.76,54.13 64.33,54.13 64.21,54.25 64.21,54.48 64.33,54.59 64.76,54.59 64.87,54.7 64.87,54.93 64.76,55.05 64.33,55.05 64.21,55.16 64.21,55.39 64.33,55.5 64.76,55.5 64.87,55.62 64.87,55.85 64.76,55.96 64.33,55.96 64.21,56.08 64.21,56.3 64.33,56.42 64.76,56.42 64.87,56.53 64.87,57.02 65.56,57.71 65.56,61.75 65.71,61.9 65.71,64.31
SOC_DDR3B_EDQ36: length 37.4
  TOP w0.102: U24.AG36 v2(65.02,65.92) ; U40.H3 57.77,42.5 57.89,42.62 57.89,43.57 57.77,43.69 v2(57.28,43.69)
  L8 w0.114: v2(65.02,65.92) 65.02,64.64 65.4,64.26 65.4,64.25 65.41,64.24 65.41,62.11 65.11,61.81 65.11,57.98 63.75,56.63 63.75,56.23 63.64,56.11 63.12,56.11 62.99,55.98 62.99,55.78 63.12,55.65 63.64,55.65 63.75,55.54 63.75,55.31 63.64,55.2 62.51,55.2 62.38,55.07 62.38,54.87 62.51,54.74 63.64,54.74 63.75,54.62 63.75,54.4 63.64,54.28 62.48,54.28 62.36,54.16 62.36,53.95 62.48,53.82 63.64,53.82 63.75,53.71 63.75,52.83 60.33,49.4 59.82,49.4 59.49,49.07 59.49,46.36 59.36,46.23 58.32,46.23 58.19,46.1 58.19,45.03 58.06,44.91 57.35,44.91 57.27,44.83 57.27,44.16 57.28,44.16 v2(57.28,43.69)
SOC_DDR3B_EDQ37: length 37.6
  TOP w0.102: U24.AH34 v2(64.02,67.92) ; U40.H8 v2(60.59,42.9)
  L8 w0.102: 63.63,63.99 63.63,67.53 v2(64.02,67.92)
  L8 w0.114: 63.63,63.99 61.37,61.73 61.37,59.92 57.2,55.76 57.2,53.25 53.35,49.4 53.35,43.81 53.85,43.31 55.13,43.31 55.37,43.06 55.37,43.05 55.75,42.67 60.35,42.67 v2(60.59,42.9)
SOC_DDR3B_EDQ38: length 37.4
  TOP w0.102: U24.AH35 v2(64.02,66.92) ; U40.G2 55.38,43.67 55.32,43.74 v2(54.13,43.74)
  L8 w0.114: v2(64.02,66.92) 64.02,66.59 64.43,66.18 64.43,63.79 64.01,63.37 63.37,63.37 61.82,61.82 61.82,61.66 61.94,61.55 62.17,61.55 62.28,61.43 62.28,61.2 62.17,61.09 61.94,61.09 61.82,60.97 61.82,60.75 61.94,60.63 62.17,60.63 62.28,60.52 62.28,60.29 62.17,60.17 61.94,60.17 61.82,60.06 61.82,59.73 57.66,55.57 57.66,52.96 56.55,51.85 56.55,51.69 56.63,51.61 56.63,51.44 56.46,51.28 56.3,51.28 56.22,51.36 56.06,51.36 55.9,51.2 55.9,51.04 55.98,50.96 55.98,50.8 55.82,50.64 55.66,50.64 55.58,50.72 55.41,50.72 53.8,49.1 53.8,48.71 53.71,48.62 53.71,48.23 53.84,48.11 54.46,48.11 54.58,47.98 54.58,47.42 54.46,47.29 53.89,47.29 53.71,47.12 53.71,46.52 53.83,46.4 54.75,46.4 54.86,46.29 54.86,46.02 54.74,45.9 53.84,45.9 53.71,45.77 53.71,45.11 53.92,44.91 54.61,44.91 54.74,44.78 54.74,43.87 54.61,43.74 v2(54.13,43.74)
SOC_DDR3B_EDQ39: length 37.4
  TOP w0.102: U24.AG32 65.02,69.93 v2(65.02,69.9) ; v2(58.29,44.35) 58.22,44.28 58.22,42.19 58.38,42.03 59.22,42.03 59.38,42.2 U40.H7
  L8 w0.102: v2(65.02,69.9) 65.02,70.33 64.95,70.41 64.74,70.41 64.52,70.18 64.52,69.6 64.67,69.44 65.35,69.44 65.41,69.39 65.41,66.51 65.64,66.28 65.64,64.77 65.86,64.54 66.02,64.38
  L8 w0.114: v2(58.29,44.35) 58.47,44.17 60.81,44.17 61,44.36 61,48.69 65.33,53.02 65.33,56.81 66.02,57.51 66.02,64.38
SOC_DDR3B_EDQ40: length 32.7
  TOP w0.102: v2(64.01,69.85) 64.52,70.36 U24.AH32 ; U40.D7 59.35,45.74 58.68,45.74 v2(58.67,45.74)
  L10 w0.102: v2(64.01,69.85) 64.24,69.85 64.64,69.45 64.64,65.28
  L10 w0.114: v2(58.67,45.74) 58.91,45.97 62.23,45.97 62.87,46.61 62.87,49.63 67.39,54.15 67.39,62.53 64.64,65.28
SOC_DDR3B_EDQ41: length 33.1
  TOP w0.102: U24.AJ33 63.33,69.42 v2(62.87,68.96) ; U40.C3 v2(56.58,46.1)
  L10 w0.102: 64.41,67.09 64.41,67.08
  L10 w0.114: 64.41,67.09 64.11,67.39 63.96,67.39 63.6,67.74 63.6,68.23 v2(62.87,68.96) ; v2(56.58,46.1) 56.84,46.36 61.59,46.36 62.23,46.99 62.23,49.86 66.93,54.56 66.93,61.62 64.41,64.14 64.41,67.08
SOC_DDR3B_EDQ42: length 32.8
  TOP w0.102: U40.C8 60.19,46.33 60.13,46.28 59.82,46.28 59.72,46.38 59.72,46.87 59.82,46.97 60.5,46.97 v2(60.58,46.9) ; v2(64.02,65.92) U24.AH36
  L10 w0.102: v2(60.58,46.9) 60.07,47.41 60.07,48.51 59.94,48.64 59.94,48.89 ; v2(64.02,65.92) 64.02,66.09 63.89,66.22 63.75,66.22 63.63,66.09 63.63,63.55
  L10 w0.114: 63.63,63.55 63.8,63.37 64.31,63.37 65.43,62.26 65.43,61.78 65.32,61.67 65.04,61.67 64.92,61.55 64.92,61.33 65.04,61.21 65.32,61.21 65.43,61.1 65.43,56.92 65.3,56.79 64.97,56.79 64.85,56.66 64.85,56.46 64.97,56.33 65.3,56.33 65.43,56.21 65.43,55.37 61.21,51.16 60.2,51.16 60.07,51.03 60.07,50.78 60.2,50.66 61.19,50.66 61.32,50.53 61.32,50.33 61.19,50.2 59.99,50.2 59.87,50.07 59.87,49.88 59.99,49.75 60.91,49.75 61.04,49.63 61.04,49.42 60.91,49.3 60.06,49.3 59.94,49.18 59.94,48.89
SOC_DDR3B_EDQ43: length 32.8
  TOP w0.102: U40.C2 55.03,46.86 54.99,46.86 v2(54.97,46.89) ; U24.AJ34 v2(63.02,67.92)
  L10 w0.102: 63.4,64.59 63.4,67.54 63.25,67.69 v2(63.02,67.92)
  L10 w0.114: v2(54.97,46.89) 54.97,47.17 55.14,47.35 55.55,47.35 55.68,47.22 55.68,46.36 55.8,46.23 56.03,46.23 56.16,46.36 56.16,47.52 56.52,47.88 57.94,47.88 58.06,48.01 58.06,48.34 57.94,48.46 57.66,48.46 57.53,48.59 57.53,49.23 57.12,49.63 56.03,49.63 55.91,49.51 55.73,49.51 55.33,49.9 55.33,50.08 59.33,54.08 59.33,55.55 61.7,57.92 61.7,62.03 61.94,62.27 61.94,63.13 63.4,64.59
SOC_DDR3B_EDQ44: length 32.9
  TOP w0.102: v2(63.02,65.92) U24.AJ36
  TOP w0.127: v2(56.47,48.64) 56.24,48.87 56.24,49.68 56.36,49.81 57.28,49.81 57.4,49.68 57.4,49.05 57.68,48.77 59.26,48.77 59.38,48.64 U40.A7
  L10 w0.114: v2(63.02,65.92) 63.02,66.4 62.89,66.52 61.8,66.52 61.47,66.19 61.47,64.69 61.13,64.35 61.13,62.27 60.78,61.93 60.78,58.3 58.42,55.93 58.42,54.58 53.67,49.83 53.67,48.23 53.8,48.11 55.99,48.11 56.47,48.59 v2(56.47,48.64)
SOC_DDR3B_EDQ45: length 32.9
  TOP w0.102: v2(64.45,62.36) 64.64,62.36 64.77,62.49 64.77,62.79 64.64,62.92 64.03,62.92 63.91,63.04 63.91,63.3 64.03,63.42 U24.AH39
  TOP w0.127: U40.A2 55.38,48.91 55.26,49.04 54.79,49.04 54.66,49.17 54.66,49.42 54.79,49.55 55.26,49.55 55.38,49.67 55.38,50.55 55.51,50.67 57.94,50.67 58.06,50.55 58.06,49.31 v1(58.01,49.25)
  L10 w0.114: v1(58.01,49.25) 58.01,49.96 57.88,50.09 56.49,50.09 56.36,50.22 56.36,50.42 56.49,50.55 57.86,50.55 57.99,50.67 57.99,50.88 57.86,51 57.4,51 57.28,51.13 57.28,51.33 57.4,51.46 57.86,51.46 57.99,51.59 57.99,52.07 59.79,53.87 59.79,55.35 62.15,57.71 62.15,61.98 62.36,62.18 62.36,63.14 62.48,63.27 63.42,63.27 63.75,62.94 64.39,62.94 64.45,62.88 v2(64.45,62.36)
SOC_DDR3B_EDQ46: length 32.7
  TOP w0.102: v2(60.58,47.7) 60.39,47.7 60.19,47.5 U40.B8 ; U24.AH38 64.02,63.92 v2(64.01,63.92)
  L10 w0.114: v2(60.58,47.7) 60.97,48.09 60.97,48.68 61.67,49.38 61.67,50.01 62.53,50.88 62.53,51.04 62.25,51.32 62.25,51.48 62.41,51.64 62.57,51.64 62.86,51.36 63.02,51.36 63.18,51.52 63.18,51.68 62.9,51.97 62.9,52.13 63.06,52.29 63.22,52.29 63.5,52.01 63.67,52.01 63.83,52.17 63.83,52.33 63.54,52.61 63.54,52.77 63.71,52.94 63.87,52.94 64.15,52.65 64.31,52.65 64.47,52.82 64.47,52.98 64.19,53.26 64.19,53.42 64.35,53.58 64.51,53.58 64.8,53.3 64.96,53.3 65.12,53.46 65.12,53.62 64.84,53.91 64.84,54.07 65,54.23 65.16,54.23 65.44,53.95 65.61,53.95 65.77,54.11 65.77,54.27 65.48,54.55 65.48,54.71 65.65,54.88 65.81,54.88 66.09,54.59 66.25,54.59 66.47,54.81 66.47,55.87 66.36,55.98 66,55.98 65.89,56.09 65.89,56.32 66,56.44 66.36,56.44 66.47,56.55 66.47,56.78 66.36,56.89 66,56.89 65.89,57.01 65.89,57.24 66,57.35 66.36,57.35 66.47,57.47 66.47,57.69 66.36,57.81 66,57.81 65.89,57.92 65.89,58.15 66,58.27 66.36,58.27 66.47,58.38 66.47,58.61 66.36,58.72 66,58.72 65.89,58.84 65.89,59.07 66,59.18 66.36,59.18 66.47,59.29 66.47,59.52 66.36,59.64 66,59.64 65.89,59.75 65.89,59.98 66,60.09 66.36,60.09 66.47,60.21 66.47,60.44 66.36,60.55 66,60.55 65.89,60.67 65.89,60.89 66,61.01 66.36,61.01 66.47,61.12 66.47,61.43 66.34,61.56 65.99,61.56 65.86,61.68 65.86,62.28 64.22,63.92 v2(64.01,63.92)
SOC_DDR3B_EDQ47: length 32.9
  TOP w0.102: U24.AJ37 v2(63.02,64.92)
  TOP w0.127: v2(57.03,48.43) 57.26,48.21 58.45,48.21 58.57,48.08 58.57,47.29 58.45,47.17 57.25,47.17 57.12,47.29 57.12,47.83 57.04,47.92 56.37,47.92 U40.A3
  L10 w0.114: v2(63.02,64.92) 63.14,65.05 63.14,65.46 63.07,65.53 62.5,65.53 62.42,65.46 62.42,64.52 62.29,64.39 61.73,64.39 61.6,64.26 61.6,62.34 61.24,61.98 61.24,58.11 58.88,55.74 58.88,54.31 54.15,49.58 54.15,49.1 54.64,48.62 54.88,48.62 54.99,48.73 54.99,49.03 55.1,49.15 55.33,49.15 55.45,49.03 55.45,48.62 55.57,48.49 55.83,48.49 55.96,48.62 55.96,48.89 56.24,49.17 56.91,49.17 57.03,49.05 v2(57.03,48.43)
SOC_DDR3B_EDQ48: length 40.1
  TOP w0.102: U24.AK39 62.52,63.3 61.47,62.26 61.47,61.59
  TOP w0.127: v2(44.92,45.34) 46.1,45.34 46.23,45.21 46.23,44.65 46.1,44.53 44.63,44.53 44.5,44.65 U39.E3 ; v1(57.21,59.27) 57.21,58.93 57.33,58.8 60.48,58.8 61.47,59.79 61.47,61.59
  L8 w0.114: v1(57.21,59.27) 57.21,59.11 57.12,59.03 55.86,59.03 55.75,59.14 55.75,59.42 55.63,59.54 55.41,59.54 55.29,59.42 55.29,59.14 55.18,59.03 54.91,59.03 54.2,58.32 54.2,53.73 50.4,49.93 50.4,48.59 50.28,48.46 49.3,48.46 49.17,48.59 49.17,49.15 49.05,49.28 48.78,49.28 48.65,49.15 48.65,48.48 48.54,48.36 48.31,48.36 48.2,48.48 48.2,49.15 48.07,49.28 47.9,49.28 47.78,49.15 47.78,48.92 47.57,48.72 46.3,48.72 45.59,48.01 45.59,45.16 45.47,45.03 45.22,45.03 v2(44.92,45.34)
SOC_DDR3B_EDQ49: length 40.1
  TOP w0.102: U24.AK38 62.14,64.04 v2(62.14,63.92) ; U39.F7 48.08,44.48 v2(48.1,44.48)
  L8 w0.114: v2(48.1,44.48) 48,44.58 46.84,44.58 46.71,44.7 46.71,46.28 47.03,46.6 47.79,46.6 48.26,46.13 49.91,46.13 50.04,46 50.04,45.52 50.19,45.36 51.16,45.36 51.38,45.59 51.38,45.96 51.27,46.07 50.95,46.07 50.83,46.2 50.83,46.4 50.95,46.53 51.27,46.53 51.38,46.65 51.38,46.87 51.27,46.99 50.79,46.99 50.67,47.1 50.67,47.33 50.79,47.45 51.27,47.45 51.38,47.56 51.38,49.61 55.12,53.35 55.12,53.97 55.23,54.08 55.64,54.08 55.75,54.2 55.75,54.43 55.64,54.54 55.23,54.54 55.12,54.65 55.12,54.88 55.23,55 55.64,55 55.75,55.11 55.75,55.34 55.64,55.46 55.23,55.46 55.12,55.57 55.12,55.8 55.23,55.91 55.64,55.91 55.75,56.03 55.75,56.26 55.64,56.37 55.23,56.37 55.12,56.48 55.12,56.71 55.15,56.74 55.23,56.83 55.64,56.83 55.75,56.94 55.75,57.17 55.64,57.28 55.23,57.28 55.12,57.4 55.12,57.89 55.27,58.04 57.53,58.04 59.98,60.49 59.98,61.77 62.13,63.92 v2(62.14,63.92)
SOC_DDR3B_EDQ50: length 40.4
  TOP w0.102: v2(62.02,65.92) U24.AK36
  TOP w0.127: U39.F2 v2(43.3,44.5)
  L8 w0.114: v2(62.02,65.92) 62.02,66.2 61.93,66.29 61.72,66.29 61.62,66.19 61.62,64.49 59.99,62.87 58.67,62.87 57.63,61.82 55.7,61.82 51.68,57.8 51.68,57.64 52.02,57.29 52.02,57.13 51.86,56.97 51.7,56.97 51.35,57.32 51.19,57.32 50.83,56.95 50.83,56.54 50.94,56.43 51.51,56.43 51.64,56.3 51.64,56.1 51.51,55.97 50.94,55.97 50.83,55.86 50.83,55.63 50.94,55.51 51.49,55.51 51.61,55.39 51.61,55.18 51.49,55.06 50.94,55.06 50.83,54.94 50.83,54.71 50.94,54.6 51.31,54.6 51.44,54.47 51.44,54.27 51.31,54.14 50.6,54.14 48.55,52.09 48.55,51.93 48.87,51.61 48.87,51.43 48.72,51.29 48.54,51.29 48.22,51.61 48.06,51.61 46.65,50.19 44.88,50.19 43.69,49 43.69,48.53 43.83,48.39 43.83,45.04 v2(43.3,44.5)
SOC_DDR3B_EDQ51: length 40.2
  TOP w0.102: U39.F8 48.5,44.11 48.91,44.52 v2(48.91,44.53) ; U24.AK35 v2(62.02,66.92)
  L8 w0.102: 61.72,64.09 62.41,64.77 62.41,66.83 62.31,66.92 v2(62.02,66.92)
  L8 w0.114: v2(48.91,44.53) 48.45,44.08 47.95,44.08 47.94,44.07 46.86,44.07 46.23,44.7 46.23,47.75 46.6,48.13 47.09,48.13 47.22,48 47.22,47.27 47.34,47.14 47.55,47.14 47.72,47.32 48.39,47.32 48.51,47.19 48.51,46.91 48.95,46.48 49.96,46.48 50.32,46.84 50.32,47.73 50.44,47.85 50.77,47.85 50.9,47.98 50.9,49.78 54.66,53.54 54.66,58.09 55.07,58.5 57.34,58.5 59.33,60.49 59.33,61.57 61.34,63.58 61.34,63.71 61.72,64.09
SOC_DDR3B_EDQ52: length 40.2
  TOP w0.102: U24.AL34 61.5,68.42 v2(61.02,67.94)
  TOP w0.127: v2(44.09,42.93) 44.09,42.92 44.5,42.5 U39.H3
  L8 w0.102: v2(44.09,42.93) 43.61,42.44 43.05,42.44 42.95,42.55 42.19,42.55 41.76,42.98
  L8 w0.114: 41.76,42.98 41.55,43.18 41.55,48.95 44.17,51.56 45.97,51.56 47.15,52.73 47.16,52.74 47.59,53.17 47.6,53.19 48.93,54.52 48.93,57.1 54.58,62.76 54.58,63.14 54.99,63.55 57.71,63.55 57.96,63.8 58.52,63.8 59.63,64.91 59.63,65.08 59.86,65.31 60.03,65.31 60.53,65.81 60.53,67.46 v2(61.02,67.94)
SOC_DDR3B_EDQ53: length 40.5
  TOP w0.102: v2(48.9,42.91) 48.9,42.91 U39.H8 ; v2(61.02,65.92) U24.AL36
  L8 w0.102: v2(48.9,42.91) 48.53,43.28 48.08,43.28 48.06,43.31 43.94,43.31 43.68,43.57 43.68,43.86 43.46,44.09 43.18,44.09 42.88,44.38 42.88,48.77 ; v2(61.02,65.92) 61.25,65.69 61.4,65.54 61.4,64.76
  L8 w0.114: 61.4,64.76 59.84,63.2 58.47,63.2 57.43,62.15 55.38,62.15 50.37,57.14 50.37,54.56 46.46,50.65 44.68,50.65 42.88,48.85 42.88,48.77
SOC_DDR3B_EDQ54: length 40.4
  TOP w0.102: U24.AL37 v2(61.02,64.92)
  TOP w0.127: U39.G2 v2(43.3,43.7)
  L8 w0.114: v2(61.02,64.92) 61.02,64.83 60.35,64.16 60.19,64.16 59.92,64.43 59.76,64.43 59.6,64.27 59.6,64.11 59.87,63.84 59.87,63.68 59.69,63.5 58.22,63.5 57.84,63.12 57.4,63.12 57.28,62.99 57.28,62.56 57.15,62.43 56.94,62.43 56.83,62.55 56.83,62.99 56.7,63.12 56.5,63.12 56.37,62.99 56.37,62.55 56.26,62.43 56.03,62.43 55.91,62.55 55.91,63 55.8,63.12 55.57,63.12 55.46,63 55.46,62.55 55.34,62.43 55.01,62.43 49.38,56.81 49.38,56.56 49.5,56.45 49.77,56.45 49.89,56.33 49.89,56.1 49.77,55.99 49.5,55.99 49.38,55.88 49.38,55.65 49.5,55.53 49.77,55.53 49.89,55.42 49.89,55.19 49.77,55.08 49.5,55.08 49.38,54.96 49.38,54.33 47.95,52.89 47.94,52.88 47.45,52.39 47.44,52.38 46.16,51.1 44.37,51.1 42.01,48.74 42.01,43.41 42.24,43.18 42.93,43.18 43.3,43.56 v2(43.3,43.7)
SOC_DDR3B_EDQ55: length 40.4
  TOP w0.102: U24.AL33 v2(61.02,68.92) ; v2(48.1,42.9) 47.7,42.5 U39.H7
  L8 w0.102: 63.4,64.16 63.4,68.08 63.15,68.33 61.62,68.33 v2(61.02,68.92)
  L8 w0.114: v2(48.1,42.9) 48.74,42.27 50.1,42.27 50.22,42.38 50.22,42.62 50.34,42.75 50.55,42.75 50.67,42.62 50.67,42.38 50.79,42.27 51.02,42.27 51.13,42.38 51.13,42.79 51.24,42.9 51.47,42.9 51.59,42.79 51.59,42.38 51.7,42.27 52.04,42.27 52.31,42.53 52.31,42.9 52.43,43.01 52.43,49.17 56.69,53.44 56.69,55.91 60.91,60.13 60.91,61.59 60.91,61.67 63.4,64.16
SOC_DDR3B_EDQ56: length 38
  TOP w0.102: U24.AN34 v2(59.02,67.92) ; v2(47.22,46.14) 47.65,45.7 U39.D7
  L10 w0.102: v2(47.22,46.14) 46.8,45.72 44.4,45.72 43.61,46.51 42.34,46.51 41.58,47.27 41.58,48.77
  L10 w0.114: 41.58,48.77 41.58,48.95 43.05,50.42 45.06,50.42 49.01,54.37 49.01,59.8 53.76,64.55 54.24,64.55 56.06,66.37 57.01,66.37 57.56,66.91 57.56,67.01 57.96,67.41 58.51,67.41 v2(59.02,67.92)
