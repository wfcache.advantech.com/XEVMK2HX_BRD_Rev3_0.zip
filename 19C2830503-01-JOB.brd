# Allegro board 19C2830503-01-JOB.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GND_3: length 19.9
  TOP w0.279: U13.36 126.66,129.24 124.6,131.31 124.6,131.96 123.51,133.04 B8.1 v1(123.51,134.32) ; v1(124.84,122.89) 125.05,123.1 U13.47
  L3 w0.508: v1(124.84,122.89) 124.84,131.87 123.51,133.2 v1(123.51,134.32)
GND_SHIELD: length 107.6
  TOP w0.508: 166.62,102.02 CN16.H4 ; CN16.H4 166.62,99.89 ; CN16.H4 168.76,102.02 ; CN16.H3 168.76,69.37 ; CN16.H3 166.62,69.37 ; CN16.H3 166.62,71.5
  L2_GND w0.508: CN16.H3 168.59,69.53 ; CN16.H3 166.79,69.53 ; CN16.H3 166.79,71.34 ; 166.79,100.05 CN16.H4 ; CN16.H4 168.59,100.05 ; CN16.H4 168.59,101.86 ; CN16.H4 166.79,101.86
  L3 w0.508: 166.79,101.86 CN16.H4 ; CN16.H4 166.79,100.05 ; CN16.H4 168.59,101.86 ; CN16.H4 168.59,100.05 ; CN16.H3 168.59,69.53 ; CN16.H3 166.79,71.34 ; CN16.H3 166.79,69.53
  L4_PWR w0.508: 166.79,69.53 CN16.H3 ; CN16.H3 168.59,69.53 ; CN16.H3 166.79,71.34 ; 166.79,100.05 CN16.H4 ; CN16.H4 168.59,101.86 ; CN16.H4 168.59,100.05 ; CN16.H4 166.79,101.86
  L5 w0.508: 166.79,101.86 CN16.H4 ; CN16.H4 168.59,100.05 ; CN16.H4 168.59,101.86 ; CN16.H4 166.79,100.05 ; 166.79,69.53 CN16.H3 ; CN16.H3 166.79,71.34 ; CN16.H3 168.59,69.53
  L6_GND w0.508: 166.79,71.34 CN16.H3 ; CN16.H3 168.59,69.53 ; CN16.H3 166.79,69.53 ; 166.79,101.86 CN16.H4 ; CN16.H4 166.79,100.05 ; CN16.H4 168.59,101.86 ; CN16.H4 168.59,100.05
  L7_GND w0.508: CN16.H4 168.59,101.86 ; CN16.H4 166.79,101.86 ; CN16.H4 168.59,100.05 ; CN16.H4 166.79,100.05 ; 166.79,69.53 CN16.H3 ; CN16.H3 168.59,69.53 ; CN16.H3 166.79,71.34
  L8 w0.508: 166.79,69.53 CN16.H3 ; CN16.H3 168.59,69.53 ; CN16.H3 166.79,71.34 ; 166.79,101.86 CN16.H4 ; CN16.H4 166.79,100.05 ; CN16.H4 168.59,101.86 ; CN16.H4 168.59,100.05
  L9_PWR w0.508: 166.79,100.05 CN16.H4 ; CN16.H4 168.59,101.86 ; CN16.H4 166.79,101.86 ; CN16.H4 168.59,100.05 ; 166.79,69.53 CN16.H3 ; CN16.H3 168.59,69.53 ; CN16.H3 166.79,71.34
  L10 w0.508: CN16.H3 168.59,69.53 ; CN16.H3 166.79,69.53 ; CN16.H3 166.79,71.34 ; 166.79,100.05 CN16.H4 ; CN16.H4 168.59,100.05 ; CN16.H4 168.59,101.86 ; CN16.H4 166.79,101.86
  L11_GND w0.508: 166.79,100.05 CN16.H4 ; CN16.H4 166.79,101.86 ; CN16.H4 168.59,100.05 ; CN16.H4 168.59,101.86 ; 166.79,69.53 CN16.H3 ; CN16.H3 166.79,71.34 ; CN16.H3 168.59,69.53
  BOTTOM w0.508: 166.62,71.5 CN16.H3 ; CN16.H3 166.62,69.37 ; CN16.H3 168.76,69.37 ; CN16.H4 168.76,102.02 ; CN16.H4 166.62,99.89 ; CN16.H4 166.62,102.02
  vias: v3(165.18,101.4) v3(166.55,68.4) v3(166.65,72.87) v3(167.59,98.58) v3(167.64,88.57) v3(167.64,85.22) v3(167.64,78.54) v3(167.64,75.18) v3(167.67,95.28) v3(167.67,91.92) v3(167.67,81.89) v3(168.61,68.4) v3(173.38,95.25) v3(173.38,91.9) v3(173.35,88.54) v3(173.35,85.19) v3(173.38,81.86) v3(173.35,78.51) v3(173.35,75.16) v3(178.74,88.57) v3(178.74,85.22) v3(178.74,78.54) v3(178.74,75.18) v3(178.77,95.28) v3(178.77,91.92) v3(178.77,81.89)
GND_USB1: length 0.7
  TOP w0.381: v3(169.54,163.5) 169.54,163.5 D1.4
  vias: v3(169.29,170.31) v3(169.49,169.6) v3(169.49,168.86) v3(169.49,168.12) v3(169.52,167.39) v3(170.03,160.25) v3(170.81,161.62) v3(170.84,160.88) v3(170.87,160.12)
VBAT: length 25.8
  TOP w0.279: U7.55 164.52,143.19 164.62,143.1 165.32,143.1 165.99,143.76
  TOP w0.508: CN2.2 166.5,131.83 166.5,133.99 167.69,135.18 169.79,135.18 OSC1.4 OSC1.1 169.82,141.91 168.61,141.91 168.08,142.44 C55.2 168.08,143.2 167.51,143.76 165.99,143.76
VBUS: length 112.1
  TOP w0.381: R799.2 78.26,111.58 77.85,111.99 v1(77.85,112.14) ; v1(132.94,110.43) 133.21,110.43 133.86,111.07 133.86,113.33 133.12,114.07 122.28,114.07 120.72,112.52 v1(118.9,112.52) ; v1(97.92,115.29) 97.92,114.71 99.14,113.49 102.92,113.49 v1(104.09,112.32)
  TOP w0.508: 167.93,106.85 SOC_USB.1 167.93,108.47
  L8 w0.381: v1(97.92,115.29) 97.89,115.29 97.55,115.64 96.26,115.64 96.24,115.66 92.95,115.66 92.1,116.51 92.1,121.26 91.53,121.83 83.4,121.83 82.46,120.89 82.46,117.51 81.98,117.03 81.27,117.03 81.27,117.03 81.01,117.03 79.77,115.79 79.77,115.26 78.38,113.87 78.03,113.87 77.34,113.18 77.34,112.65 v1(77.85,112.14)
  BOTTOM w0.381: v1(104.09,112.32) 104.14,112.27 105.13,112.27 105.64,111.76 115.48,111.76 117.1,113.37 118.33,113.37 118.9,112.79 v1(118.9,112.52) ; U59.1 157.69,107.23 156.79,108.13 153.29,108.13 152.43,108.99 152.43,109.45 151.87,110.01 151.31,110.01 150.54,110.77 148.55,110.77 148.21,110.43 145.24,110.43 141.74,113.92 133.99,113.92 132.94,112.88 v1(132.94,110.43)
  BOTTOM w0.508: U59.1 158.44,106.74 v1(158.62,106.55)
VCC0V75_EN: length 221.6
  TOP w0.254: v1(103.23,47.97) 103.23,47.27 103.39,47.11 U38.7 ; R164.1 135.56,134.19 136.49,135.12 v1(142.37,135.12)
  L5 w0.254: v1(103.23,47.97) 104.5,46.69 104.5,45.64 106.07,44.07 106.25,43.89 108.05,43.89 108.46,44.3 120.01,44.3 128.37,52.66 128.37,65.46 131.57,68.66 131.57,112.99 132.04,113.45 135.17,116.59 138.4,119.82 140.42,119.82 143.56,122.96 143.56,127.05 141.58,129.03 141.58,134.33 v1(142.37,135.12)
  L8 w0.254: v1(34.29,37.94) 35.91,36.32 37.85,36.32 39.83,34.34 57.37,34.34 57.96,34.92 58.82,34.92 59.01,34.73 60.91,34.73 61.2,34.44 99.44,34.44 100.1,35.1 100.6,35.1 101.19,35.69 101.61,35.69 101.88,35.41 102.98,35.41 103.43,35.86 106.18,35.86 106.95,36.64 106.95,40.24 105.92,41.27 105.92,44.22 104.14,46 104.14,46.43 103.23,47.35 v1(103.23,47.97)
  BOTTOM w0.254: v1(34.29,37.94) 34.32,37.97 34.42,37.97 34.55,38.11 U60.7
VCC0V75_EN_R: length 5.9
  TOP w0.127: U13.26 131.66,129.43 131.95,129.72 133.53,129.72 135.56,131.75 R164.2
VCC0V75_PGOOD: length 5.2
  BOTTOM w0.279: U60.9 34,39.11 33.6,38.7 R785.1
  BOTTOM w0.305: TP96.1 31.75,37.72 33.15,37.72 33.6,38.17 R785.1
VCC0V85: length 38.3
  TOP w0.381: R355.2 12.75,80.77 v1(12.5,81.03)
  L8 w0.381: v1(12.5,81.03) 16.2,81.03 22.61,87.44 31.1,87.44 31.15,87.39 32.11,87.39 32.51,87.79 32.51,90.24 34.11,91.84 34.11,100.75 v3(33.82,101.05)
  BOTTOM w0.381: v2(69.95,88.93) 70.42,89.39 B48.2
  vias: v1(37.57,78.08) v1(37.83,80.78) v2(63.02,78.97) v2(62.99,78.05) v3(33.61,102.67) v3(33.69,103.42) v3(33.68,101.88) v3(34.35,102.59) v3(34.46,101.85)
VCC1V2: length 51.8
  TOP w0.254: v1(134.19,122.03) 134.49,122.03 136.82,119.71 137.67,119.71 138.15,119.23 138.15,113.06 138.56,112.65 139.19,112.65 ; v1(122,127.89) R203.2
  TOP w0.381: C212.1 141.8,96.84 v2(141.64,96.99) ; v2(146.64,72.6) 146.62,72.58 C297.1 ; C290.1 141.09,73.04 v2(140.64,72.6) ; C206.1 141.09,97.44 v2(140.64,96.99) ; C198.1 142.19,100.54 v2(142.64,100.99) ; v2(141.64,76.6) 141.22,77.02 C268.1 ; C295.1 141.8,72.45 v2(141.64,72.6) ; v2(145.64,100.99) 145.49,100.84 C193.1 ; C274.1 142.19,76.14 v2(142.64,76.6) ; C270.1 145.49,76.44 v2(145.64,76.6) ; C213.1 146.62,96.97 v2(146.64,96.99) ; v2(141.64,100.99) 141.22,101.42 C192.1
  L10 w0.254: v1(134.19,122.03) 134.15,122.03 133.5,122.68 132.49,122.68 132.16,122.35 124.26,122.35 122.82,123.79 122.82,126.23 122,127.05 v1(122,127.89)
  BOTTOM w0.381: PHY2.E3 142.14,100.49 v2(141.64,100.99) ; PHY1.J3 v2(145.64,76.6) ; v2(139.64,72.6) 140.14,72.1 PHY1.C7 ; v2(141.64,96.99) 142.14,96.49 PHY2.E7 ; PHY2.D7 141.14,96.49 v2(140.64,96.99) ; PHY1.J7 v2(146.64,72.6) ; v2(142.64,76.6) 143.14,76.1 PHY1.F3 ; PHY2.C6 140.14,97.49 v2(139.64,97.99) ; PHY2.F3 143.14,100.49 v2(142.64,100.99) ; PHY2.J7 v2(146.64,96.99) ; PHY1.D7 141.14,72.1 v2(140.64,72.6) ; v2(141.64,76.6) 142.14,76.1 PHY1.E3 ; v2(139.64,73.6) 140.14,73.1 PHY1.C6 ; PHY2.C7 140.14,96.49 v2(139.64,96.99) ; PHY2.J3 v2(145.64,100.99) ; PHY1.E7 142.14,72.1 v2(141.64,72.6)
  vias: v3(139.22,111.88) v3(139.95,111.91) v3(140.69,111.91)
VCC1V2_EN: length 17.9
  TOP w0.127: R163.1 143.12,132.56 143.12,130.93 v1(143.12,130.76) ; Q7.5 144.23,117.82 144.85,118.43 R255.2 144.85,119 143.95,119.9 R237.1 143.95,120.54 144.78,121.37 v1(144.82,121.37)
  L8 w0.127: v1(143.12,130.76) 144.82,129.06 v1(144.82,121.37)
VCC1V2_EN_R: length 12.8
  TOP w0.127: U13.21 133.36,126.6 133.47,126.71 133.47,126.79 134.67,127.99 134.84,127.99 136.74,129.9 140.79,129.9 141.33,130.43 141.33,132.43 R163.2
VCC1V2_MON: length 3.3
  TOP w0.254: R203.1 123.51,127.57 123.6,127.48 124.98,126.1 U13.41
VCC1V5: length 254.4
  TOP w0.254: U43.G7 94.44,43.3 94.81,42.94 v2(94.82,42.94)
  TOP w0.279: v3(108.08,45.85) 107.82,46.11 U38.2
  TOP w0.356: DIMM1.124 123.46,71.05 v3(123.54,70.97) ; U42.R9 84.38,36.9 84.88,36.41 v2(84.92,36.41) ; U40.K2 55.39,40.9 v2(55.79,41.3) ; U43.R9 96.04,36.9 95.64,36.5 v2(95.63,36.5) ; C266.1 123.5,77.65 DIMM1.102 ; v2(90.81,41.28) 90.81,41.27 90.81,41.27 90.44,40.9 U43.K2 ; U42.K2 78.75,40.9 v2(79.15,41.3) ; U40.A1 v2(54.19,48.5) ; DIMM1.116 123.83,73.45 C289.1 ; U42.G7 82.8,43.3 83.19,43.69 v2(83.19,43.69) ; U40.E9 60.98,44.94 v2(61.4,45.36) 61.05,45.7 U40.D9 ; 122.99,75.25 DIMM1.110 ; v2(65.83,46.87) 65.85,46.87 U41.C1 U41.D2 ; v2(73.25,42.13) 73.25,42.28 73.03,42.5 U41.H9 ; U39.K8 48.13,40.53 v2(48.13,40.5) ; U39.C9 49.3,46.5 v2(49.7,46.9) ; v2(61.38,46.9) 60.99,46.5 U40.C9 ; U43.H9 96.49,42.5 v2(96.58,42.6) ; U40.H2 v2(54.99,42.9) ; v3(123.32,82.3) 123.17,82.45 DIMM1.86 ; v2(73.24,36.64) 72.91,36.64 72.65,36.9 U41.R9 ; U39.D2 v2(43.3,46.1) ; U43.R1 90.04,37.3 v2(90.04,37.3) ; U41.A8 v2(72.22,48.5) ; v2(67.41,41.32) 67.41,41.32 67.02,40.93 U41.K2 ; C299.1 110.62,71.35 DIMM1.123 ; U43.N9 96.58,37.96 v2(96.58,38) ; U43.K8 94.86,40.53 v2(94.86,40.5) ; U43.N1 89.66,38.5 v2(90.04,38.89) ; U40.D2 U40.C1 54.2,46.89 v2(54.19,46.89) ; v2(77.55,44.5) 77.95,44.1 U42.F1 ; v2(48.11,43.69) 48.09,43.67 48.09,43.61 47.78,43.3 U39.G7 ; U41.B2 v2(66.62,47.7) ; DIMM1.94 122.9,80.05 C256.1 ; U39.B2 v2(43.3,47.7) ; U42.D9 v2(84.75,45.3) 84.35,44.9 U42.E9 ; U43.A8 95.24,48.1 v2(94.88,48.46) ; U42.N9 84.84,38.99 84.84,38.99 v2(84.93,39.09) ; v2(66.62,37.3) 66.62,37.3 U41.R1 ; U42.A8 v2(83.95,47.7) ; U39.R9 49.3,36.9 49.75,36.44 49.9,36.44 v2(49.91,36.44) ; U39.D9 v2(49.7,45.3) 49.3,44.9 U39.E9 ; DIMM1.132 123.94,68.65 C305.1 ; U39.F1 42.9,44.1 v2(42.5,44.5) ; U42.H9 84.72,42.87 v2(84.75,42.87) ; U43.A1 v2(90.04,47.7) U43.B2 ; U40.G7 59.44,43.3 59.78,43.65 v2(59.78,43.68) ; v2(84.75,46.9) 84.35,46.5 U42.C9 ; v2(77.55,46.9) U42.C1 78.35,46.1 U42.D2 ; 111.98,82.75 DIMM1.85 ; U43.F1 89.64,44.13 v2(89.21,44.55) ; U41.H2 67.39,42.87 v2(67.39,42.93) ; v2(43.31,41.27) 43.68,40.9 U39.K2 ; U39.A1 v2(42.5,48.5) ; v2(41.53,38.94) 41.53,38.92 41.96,38.49 42.84,38.49 42.86,38.5 U39.N1 ; U43.E9 96.04,44.94 v2(96.45,45.36) 96.1,45.7 U43.D9 ; v2(65.61,37.96) 65.62,37.97 65.64,37.97 66.17,38.5 U41.N1 ; U40.A8 v2(60.59,48.5) ; U41.F1 65.82,43.7 v2(65.79,43.7) ; U41.E9 72.62,44.95 73.02,45.35 v2(73.02,45.35) 72.67,45.7 U41.D9 ; U41.C9 72.98,46.86 v2(73.1,46.86) ; U42.K8 83.18,40.53 v2(83.18,40.5) ; v2(78.35,37.29) 78.35,37.3 U42.R1 ; U41.A1 65.86,48.46 65.86,48.5 v2(65.84,48.5) ; 110.88,75.55 DIMM1.109 ; U39.N9 49.3,38.48 48.92,38.1 v2(48.93,38.09) ; U39.A8 v2(48.9,47.7) ; U42.A1 v2(77.55,48.5) ; C250.1 109.65,80.35 DIMM1.93 ; v2(89.24,46.9) U43.C1 U43.D2 ; v2(43.31,37.3) 43.3,37.3 U39.R1 ; U39.H9 v2(49.68,42.88) ; U40.K8 59.81,40.53 v2(59.81,40.5) ; U43.H2 v2(90.04,42.9) ; v2(78.36,38.89) 78.36,38.91 U42.N1 ; U39.C1 42.67,46.73 v2(42.5,46.9) ; DIMM1.131 110.57,68.95 C304.1 ; U42.B2 v2(78.35,47.7) ; C264.1 111.42,77.23 112.14,77.95 DIMM1.101 ; U40.F1 54.59,44.13 54.29,44.43 v2(54.1,44.43) ; U42.H2 v2(78.35,42.9) ; U39.H2 v2(43.3,42.9) ; v2(96.44,46.9) 96.04,46.5 U43.C9 ; v2(70.18,43.3) U41.G7 ; DIMM1.115 111.15,73.75 ; U40.B2 v2(54.99,47.7)
  TOP w0.381: U24.AD31 v2(68.02,71.92) U24.AE30 v2(67.02,72.92) U24.AF29 ; v2(83.02,92.96) 82.98,92.96 U24.K9 U24.L8 ; U24.M17 U24.L18 v2(82.02,83.92) U24.K19 83.03,82.91 83.03,82.9 v2(83.06,82.87) 83.07,82.87 U24.J20 v2(84.02,81.92) U24.H21 ; U24.AD29 69.09,72.85 ; 69.09,72.85 U24.AC30 v2(70.02,71.92) U24.AB31 ; 69.09,72.85 v2(69.09,72.9) ; v2(54.2,38.09) 54.36,38.24 54.36,38.28 U40.N1 ; U24.Y31 v2(72.02,71.92) U24.AA30 v2(71.02,72.92) U24.AB29 ; C304.1 v3(110.34,67.81) ; U40.N9 61.09,38.5 v2(61.47,38.89) ; 76.07,73.87 U24.T29 v2(77.02,72.92) U24.R30 v2(78.02,71.92) U24.P31 ; 76.07,73.87 U24.U28 ; 76.07,73.87 v2(76.07,73.79) ; v2(62.99,70.87) 62.99,70.95 U24.AK31 ; v3(103.76,42.93) 103.07,42.23 C364.1 ; U24.H23 84.07,79.87 v2(84.02,79.92) U24.J22 v2(83.02,80.92) U24.K21 v2(82.02,81.92) U24.L20 U24.M19 ; U24.L14 v2(82.02,87.92) U24.K15 U24.J16 v2(84.02,85.92) U24.H17 ; U41.K8 71.82,40.88 v2(71.44,40.5) ; U24.J8 83.52,94.38 v2(84,93.9) ; U24.W28 v2(74.02,73.92) U24.V29 v2(75.02,72.92) U24.U30 v2(76.02,71.92) U24.T31 ; v2(85.04,94.92) 84.54,95.42 U24.H7 84.05,95.89 v2(84.05,95.94) 84,95.94 U24.J6 ; U24.H19 v2(84.02,83.92) U24.J18 v2(83.02,84.92) U24.K17 v2(82.02,85.92) U24.L16 ; U24.L32 U24.M31 v2(80.02,71.92) ; U24.V31 v2(74.02,71.92) U24.W30 v2(73.02,72.92) U24.Y29 v2(72.02,73.92) U24.AA28 ; v3(104.39,44.46) 104.39,44.45 104.71,44.14 R441.1 ; U41.N9 72.62,38.46 v2(73.09,37.98) ; v2(81.02,91.93) U24.M11 ; v2(54.98,36.52) 54.6,36.9 U40.R1 ; v1(68.65,56.52) 68.65,56.46 67.88,55.68 C331.1 ; v2(84.99,92.9) 84.52,93.38 U24.H9 ; v2(61.44,42.9) 61.05,42.5 U40.H9 ; U24.L10 U24.K11 v2(83.02,90.92) U24.J12 v2(84.02,89.92) U24.H13 ; U24.J10 v2(84.02,91.92) U24.H11 ; U24.AL32 v2(62.02,69.92) ; v3(110.7,69.71) 110.75,69.76 110.75,70.77 C299.1 110.04,71.13 109.76,70.85 109.76,69.78 v3(109.87,69.68) ; U24.AH31 v2(64.02,71.92) U24.AJ30 ; v2(83.02,94.92) U24.K7 ; C275.1 123.19,75.45 122.99,75.25 ; U24.AG30 v2(66.02,71.92) U24.AF31 ; U24.H15 v2(84.02,87.92) U24.J14 v2(83.02,88.92) U24.K13 v2(82.02,89.92) U24.L12 ; U24.P29 78.29,73.42 77.95,73.76 v2(77.95,73.81) 77.9,73.81 77.52,74.2 U24.R28 ; C250.1 v3(109.58,79.49) ; U24.K23 83.06,78.88 v2(83.06,78.84) ; U40.R9 60.98,36.85 v2(60.58,36.45)
  TOP w0.508: v3(101.84,47.04) 102.43,47.63 C349.2
  BOTTOM w0.254: U60.2 39.74,39.11 40.39,39.75 C768.2 ; C607.1 80.17,81.4 80.56,81.79 80.56,81.95 80.99,82.38 81.56,82.38 v2(82.02,81.92) ; C638.1 88.56,82.46 88.56,83.11 88.57,83.12 C538.1
  BOTTOM w0.305: C554.1 86.81,89.45 86.82,89.44 87.22,89.44 87.22,89.45 87.81,89.45 87.82,89.44 88.22,89.44 88.5,89.72 88.5,90.14 88.58,90.21 C543.1
  BOTTOM w0.356: C777.1 73.92,37.9 73.17,37.9 v2(73.09,37.98)
  BOTTOM w0.381: C739.1 41.6,48.08 42.03,48.5 v2(42.5,48.5) ; v2(54.19,48.5) 53.77,48.5 C740.1 ; v2(65.79,43.7) 65.57,43.49 C755.1 ; C751.1 89.04,44.38 v2(89.21,44.55) ; v2(54.98,36.52) 54.92,36.58 53.09,36.58 52.83,36.83 52.83,37.84 53.09,38.09 v2(54.2,38.09) ; C525.1 86.33,82.32 85.65,82.32 85.17,81.83 C618.1 84.32,81.62 v2(84.02,81.92) ; C748.1 41.64,46.04 v2(42.5,46.9) ; v2(49.91,36.44) 49.4,36.94 49.4,37.62 v2(48.93,38.09) ; C593.1 110.52,82.8 v3(111.42,83.7) ; v2(84.75,46.9) 84.75,46.9 84.98,46.67 C744.1 ; C554.1 86.28,89.45 86.23,89.4 85.92,89.4 85.74,89.22 C581.1 C565.1 84.19,90.1 v2(84.02,89.92) ; R758.2 74.69,44.81 74.3,45.21 73.16,45.21 v2(73.02,45.35) ; v2(66.62,37.3) 66.28,36.96 C789.1 65.48,37.84 v2(65.61,37.96) ; v2(49.68,42.88) 49.28,42.48 C763.1 ; C737.1 65.56,48.5 v2(65.84,48.5) ; C782.1 85.15,36.63 v2(84.92,36.41) ; v2(84.99,92.9) 85.44,92.46 86.47,92.46 C567.1 ; v2(78.36,38.89) 77.63,38.89 C781.1 77.9,37.29 v2(78.35,37.29) ; C521.1 88.56,95.38 88.56,94.73 88.53,94.7 C531.1 C650.1 88.53,92.06 88.5,92.04 88.5,91.61 88.51,91.59 88.51,90.76 88.58,90.69 C543.1 ; v2(61.44,42.9) 61.5,42.84 62.22,42.84 C759.1 ; v2(84.02,83.92) 84.61,84.51 C602.1 85.7,84.51 85.77,84.44 86.23,84.44 86.34,84.34 C612.1 ; v2(83.06,78.84) 83.82,78.08 83.82,77.6 84.91,76.51 C620.1 ; v2(96.44,46.9) 96.67,46.67 C742.1 ; v2(84.02,85.92) 84.64,86.54 C631.1 ; v2(54.19,46.89) 54.17,46.89 53.58,46.3 C747.1 ; C735.1 60.64,48.56 v2(60.59,48.5) ; v2(73.24,36.64) 73.31,36.58 C788.1 ; v2(84.75,45.3) 84.85,45.21 C752.1 ; v2(77.55,44.5) 77.54,44.52 C758.1 ; C790.1 95.94,36.19 v2(95.63,36.5) ; v2(89.24,46.9) 89,46.67 C743.1 ; v2(74.02,73.92) 73.61,74.33 C676.1 ; v2(96.45,45.36) 96.63,45.54 C750.1 ; C746.1 77.08,46.74 77.16,46.82 77.47,46.82 v2(77.55,46.9) ; v2(48.9,47.7) 49.21,48.01 C738.1 ; C753.2 106.3,44.07 v3(108.08,45.85) 109.02,44.9 R757.2 ; v2(72.22,48.5) 71.89,48.83 C736.1 ; v2(90.04,37.3) 89.57,37.3 C780.1 89.1,38.68 89.84,38.68 v2(90.04,38.89) ; C774.1 55.12,39.88 55.79,40.55 v2(55.79,41.3)
  BOTTOM w0.406: C638.1 88.27,82.42 88.24,82.46 86.51,82.46 C525.1
  vias: v1(121.31,141.25) v1(121.87,141.55) v2(41.4,41.62) v2(41.4,41.02) v2(41.91,41.27) v3(109.65,83.82) v3(110.09,78.65) v3(110.45,72.66) v3(110.85,78.66) v3(123.47,74.6) v3(123.47,71.83) v3(123.61,76.72) v3(123.57,67.74) v3(129.67,143.13) v3(129.67,141.86) v3(130.47,140.94) v3(130.91,143.15) v3(130.91,141.88) v3(131.88,140.92) v3(132.18,143.15) v3(132.18,141.88) v3(133.32,147.98) v3(133.32,146.84) v3(133.32,145.69) v3(133.32,144.42) v3(133.32,143.15) v3(133.32,141.88) v3(133.35,140.94)
VCC1V8: length 361.1
  TOP w0.254: CN3.2 33.83,127.2 v1(34.14,127.52) ; U65.20 42.68,128.25 v1(43.17,127.76) ; U28.8 107.54,61.84 v1(107.14,61.43) ; C730.2 145.03,58.23 U33.3 ; U30.8 106.06,57.67 106.43,58.04 106.43,58.93 v1(106.43,58.93)
  TOP w0.279: U17.8 79.4,123.05 v1(79.13,123.32) ; v1(138.78,58.48) 139.09,58.79 U31.2 ; U21.8 78.66,116.96 v1(78.19,117.42) ; CN3.1 37.02,127.2 36.78,126.96 36.35,126.96 36.05,127.27 36.05,127.7 36.1,127.75 36.1,127.81 v1(36.04,127.87)
  TOP w0.33: U68.20 42.68,134.27 v3(42.2,133.78)
  TOP w0.356: U26.5 108.69,63.75 109.11,63.33 v1(109.11,63.28) ; 134.82,157.4 135.65,158.23 U5.2 ; C332.2 124.9,55.81 125.27,56.18 U32.16 ; U37.16 33.54,50.92 33.21,51.24 v3(33.02,51.24) ; C340.2 26.67,50.35 26.71,50.39 U35.16
  TOP w0.381: R404.1 140.72,57 v3(141.07,57.35) ; 60.99,75.97 v2(60.99,75.97) ; 60.99,75.97 61.03,75.94 61.03,75.94 60.52,75.43 U24.AM27 ; 60.99,75.97 61.07,75.97 61.52,76.42 U24.AL26 U24.AK27 62.52,75.38 v2(62.99,74.91) ; R415.2 32.64,53.85 v3(32.89,54.1) ; v3(40.56,52.55) 40.36,52.55 40.01,52.9 R426.1 ; U24.Y7 v2(72.02,95.92) 71.97,95.97 U24.AA6 v2(71.02,96.92) U24.AB5 ; R42.1 R36.1 v3(87.25,155.96) ; C730.2 145.4,57.89 145.92,58.42 v1(145.92,58.5) ; v2(79.02,72.92) U24.N30 ; v3(124.35,54.84) 124.33,54.87 C332.2 ; U67.5 41.71,147 42.53,147 42.66,147.12 C843.2 43,146.51 42.82,146.33 42.37,146.33 v1(42.32,146.38) 42.23,146.29 42.19,146.29 41.86,145.96 41.86,145.93 41.39,145.47 R69.1 ; U24.AE6 67.41,96.42 v2(66.93,96.9) ; v3(36.35,53.95) 36.83,53.47 R418.2 ; U24.J26 v2(83.02,76.92) U24.K25 82.04,77.9 v2(82.02,77.92) U24.L24 ; U24.J26 U24.H25 ; U24.J26 v2(84.02,75.92) U24.H27 v2(84.02,74.92) U24.J28 v2(83.02,74.92) U24.K27 v2(82.02,75.92) U24.L26 ; R307.1 62.07,111.07 v1(62.61,111.61) ; v2(143.79,40.28) 143.32,39.81 GPS1.F1 ; R38.1 101.4,155.96 v3(101.04,155.6) ; U24.Y5 72.97,96.97 v2(73.02,96.92) U24.W6 v2(74.02,95.92) U24.V7 ; R326.2 135.84,98.04 v3(135.89,98) ; v1(44.96,162.69) R25.1 ; v3(134.82,48.21) 134.3,48.74 C347.2 133.73,49.59 U34.1 ; v3(31.6,54.03) 31.24,53.68 R414.2 ; v2(63.02,75.92) 63.52,76.42 U24.AJ26 ; v3(134.75,152.63) 134.3,153.08 R48.1 ; v1(137.57,57.28) 137.81,57.03 R405.1 ; R416.2 v3(34.04,54.05) 34.35,54.37 C333.1 ; R425.1 37.99,52.9 v1(37.61,52.52) ; EEPROM1.8 125.55,98.43 C205.2 124.91,97.25 v3(124.46,96.8) ; R322.2 v3(136.02,102.24) ; U24.AC6 v2(70.02,95.92) U24.AB7 ; v1(87.5,150.45) 88.02,150.45 R61.1 ; U24.AL28 61.52,74.21 v2(61.16,73.85) 60.73,73.42 U24.AM29 ; R411.2 v3(27.05,54.05) 28.19,54.05 28.45,53.79 R412.2 ; v3(134.42,158.42) 134.42,157.61 134.62,157.4 134.81,157.4 134.82,157.4 C34.2 ; R413.2 29.84,53.66 v3(30.29,54.1) ; U24.V5 v2(75.02,96.92) U24.U6 75.95,95.99 ; R50.1 105.61,153.32 104.88,154.05 v3(103.89,154.05) ; v3(103.89,151.79) 103.86,151.77 R56.2 ; v1(59.12,112) 60.06,111.07 R319.1 ; U24.T7 75.95,95.99 ; 75.95,95.99 v2(75.95,95.92) ; v1(27.13,49.69) 26.54,50.27 C340.2 ; R324.1 v3(123.29,100.2) ; U24.AG6 v2(66.02,95.92) U24.AF7 ; U24.R6 v2(77.02,96.92) ; R422.1 135.23,51.82 v3(135.89,51.16) 135.2,50.46 R429.1 ; U24.AD7 v2(68.02,95.92) ; v2(80.02,73.92) U24.M29 v2(81.02,72.92) U24.L30 v2(82.02,71.92) U24.K31 U24.J32 v2(84.02,70.92) ; v3(150.88,52.88) R419.1 ; R417.2 v3(35.43,54.05) ; R33.1 v3(90.38,158.24)
  TOP w0.508: 139.18,31.74 CN21.1 ; CN21.1 139.18,33.8 ; CN21.1 141.24,31.74 ; CN21.1 141.24,33.8 ; v3(148.83,132.77) 148.82,132.75 148.82,132.52 148.45,132.16 148.45,132.14 147.89,131.58 147.89,131.33 147.52,130.96 145.87,130.96 145.09,131.74 v3(145.06,131.74) ; R363.2 99.13,79.19 v1(101.22,81.28)
  L3 w0.102: 151.14,93.64 151,93.49
  L3 w0.381: v1(109.11,63.28) 108.2,64.19 108.2,73.53 107.06,74.68 v1(105.8,74.68) ; 151.14,93.64 152.1,94.59 152.1,101.88 153.09,102.87 154.46,102.87 155.52,101.81 v3(155.52,101.81) ; v3(135.89,98) 135.89,93.68 137.08,92.48 149.99,92.48 151,93.49 ; v3(101.04,155.6) 103.17,157.73 103.17,169.06 v1(103.17,169.06)
  L3 w0.508: v3(134.75,152.63) 133.79,153.59 133.73,153.59 133.3,154.03 133.3,156.24 134.42,157.35 v3(134.42,158.42)
  L5 w0.381: v1(87.5,150.45) v1(87.5,151.89) 87.25,152.14 v3(87.25,155.96) ; v3(42.29,141.88) 41.71,142.46 41.71,145.81 42.19,146.29 42.27,146.29 42.35,146.37 42.35,146.38 42.34,146.38 42.34,146.38 v1(42.32,146.38) ; v3(77.44,105.61) 77.44,106.4 78.61,107.57 v3(78.61,108.71) ; v3(101.04,155.6) 102.34,155.6 v3(103.89,154.05) 104.46,153.48 104.46,152.29 103.96,151.79 v3(103.89,151.79)
  L5 w0.508: v3(157.86,138.18) 159.05,139.37 159.05,143.58 158.79,143.84 158.79,151.21 v3(158.37,151.64)
  L9_PWR w0.508: 139.47,33.51 CN21.1 ; CN21.1 139.47,32.02 ; CN21.1 140.95,32.02 ; CN21.1 140.95,33.51
  L10 w0.508: v3(124.33,107.13) 124.59,106.87 v3(124.59,103.75)
  BOTTOM w0.203: v2(36.62,160.66) 38.23,160.66 38.6,160.28 38.6,159.42 NAND1.G4
  BOTTOM w0.254: U64.18 31.65,147.02 C837.2 ; 42.58,126.93 42.58,128.04 42.3,128.32 41.78,128.32 41.72,128.26 U63.42 ; 31.06,141.1 31.48,141.52 U64.7 ; v3(42.2,133.78) 42.18,133.76 U63.31 ; U36.2 38.1,48.83 C345.2 ; U64.42 41.76,141.52 42,141.27 42.52,141.27 42.67,141.43 43.59,141.43 43.78,141.62 43.78,142.01 ; v1(42.32,146.38) 42.34,146.38 42.34,146.38 42.35,146.38 42.35,146.37 42.14,146.37 41.62,146.9 41.62,146.94 41.55,147.01 41.51,147.01 41.5,147.02 U64.31 ; U63.18 31.28,133.76 30.68,134.37 C835.2
  BOTTOM w0.279: C841.1 31.72,128.26 U63.7
  BOTTOM w0.305: NAND1.J6 40.5,157.44 v2(40.15,157.08) ; C389.2 151.63,169.44 150.9,169.44 150.68,169.22 150.68,169.15 150.56,169.03 U45.20 ; NAND1.H8 39.81,155.84 40.13,155.51 v2(40.13,155.45) ; C665.1 58.87,73.71 59.38,73.2 59.41,73.2 59.51,73.11 R714.2 ; NAND1.D3 36.58,160.62 v2(36.62,160.66)
  BOTTOM w0.356: U51.16 157.36,140.74 157.37,140.74 C418.1 ; v3(103.89,154.05) 103.8,154.14 U50.9 ; U47.9 97.62,164.55 98.04,164.97 v3(98.04,165.05) ; v3(78.61,108.71) 78.87,108.71 79.25,109.09 C494.2 78.94,109.47 78.87,109.47 78.62,109.72 U57.16 ; v3(88.32,164.16) 87.92,164.55 U48.9 ; C421.2 148.91,148.72 149.24,148.39 U52.2
  BOTTOM w0.381: v1(30.23,133.56) 30.23,133.59 30.17,133.65 C835.2 ; C515.1 73.53,97.44 v2(73.02,96.92) ; C418.1 157.37,138.67 v3(157.86,138.18) ; C495.2 124.91,107.7 v3(124.33,107.13) 124.01,106.8 R604.1 ; C836.1 42.73,134.32 42.2,133.79 v3(42.2,133.78) ; R572.1 84.4,127.63 84.83,128.06 v1(84.83,128.08) ; v3(42.29,141.88) 42.41,141.99 43.05,141.99 43.06,142 43.31,142 43.32,142.01 43.78,142.01 C842.1 ; R416.2 v3(34.04,54.05) ; v2(66.02,95.92) 65.6,95.51 C536.1 ; C687.1 C702.1 109.21,63.37 v1(109.11,63.28) ; R670.2 36.27,87.66 v1(37.06,86.87) ; C837.2 30.93,145.44 30.33,144.84 29.85,144.84 v1(29.85,144.84) ; C838.1 42.58,126.93 43.17,127.52 v1(43.17,127.76) ; R804.2 45.28,149.54 44.38,150.43 v2(44.26,150.43) ; U70.5 157.43,101.81 C844.2 v3(155.52,101.81) ; v3(30.61,139.45) 30.61,140.65 31.06,141.1 ; C530.1 71.6,96.34 v2(72.02,95.92) ; v1(79,128.78) 78.99,128.78 78.99,128.78 78.11,128.78 77.67,129.22 C456.2 77.34,128.57 77.42,128.5 U54.1 ; R519.2 134.3,152.18 v3(134.75,152.63) 134.79,152.63 134.7,152.73 134.7,152.78 134.3,153.18 R48.1 ; B38.2 63.92,73.98 v2(62.99,74.91) ; v3(39.24,51.44) 39.12,51.44 38.42,50.74 C350.1 C345.2 ; C514.1 75.56,97.47 v2(75.02,96.92) 74.93,96.84 C528.1 ; v3(30.58,129.29) 30.53,129.29 30.53,129.24 30.57,129.2 30.8,129.2 31.2,128.8 31.2,128.57 31.37,128.4 C841.1 ; v2(61.16,73.85) 60.72,74.29 C685.1 59.25,74.29 58.88,73.91 C665.1 ; v1(105.8,74.68) R701.1 ; C535.1 69.53,95.43 v2(70.02,95.92) 69.49,96.45 C518.1 ; v2(74.02,95.92) 73.6,96.34 C529.1 ; v1(83.33,125.43) 83.51,125.61 R570.1 ; C321.2 139.46,59.16 v1(138.78,58.48) ; C516.1 71.5,97.41 v2(71.02,96.92) ; C389.2 151.66,169.11 151.26,168.71 v3(151.26,167.95) ; C519.1 68.37,96.28 v2(68.02,95.92) ; v3(153.67,149.86) 153.99,150.18 R521.1 ; R517.1 v1(87.5,151.89) ; C421.2 149.29,149.73 v3(149.73,149.73) ; U69.5 49.75,162.16 48.84,163.07 47.43,163.07 v3(47.4,163.1) ; v2(143.79,40.28) 143.63,40.44 C776.2 ; R610.1 124.01,104.33 v3(124.59,103.75) 125.19,103.75 125.83,104.39 U58.1
  BOTTOM w0.508: R733.2 145.71,131.12 145.09,131.74 v3(145.06,131.74) 144.85,131.95 144.09,131.95 C720.2 144.02,132.46 144.32,132.77 NOR1.2 ; v1(105.8,74.68) 106.43,75.31 106.43,77.17 102.32,81.28 v1(101.22,81.28) ; v3(148.83,132.77) 148.97,132.77 149.16,132.96 150.66,132.96 151.36,133.65 151.36,135.98 152.62,137.24 156.93,137.24 v3(157.86,138.18)
  vias: v2(143.89,39.5) v3(29.72,70.1) v3(29.72,69.09) v3(29.72,68.2) v3(29.72,67.18) v3(30.48,66.68) v3(30.61,67.94) v3(30.73,64.26) v3(30.86,65.28) v3(30.86,63.25) v3(31.11,67.31) v3(31.24,66.29) v3(31.62,67.94) v3(32,66.93) v3(32.51,66.17) v3(32.64,67.69) v3(33.02,62.87) v3(33.15,66.8) v3(33.27,68.33) v3(33.4,69.98) v3(33.78,67.44) v3(33.91,66.04) v3(34.16,65.15) v3(34.16,64.13) v3(34.16,63.12) v3(34.42,68.45) v3(34.42,66.93) v3(34.67,70.36) v3(34.67,69.47) v3(34.92,67.69) v3(34.92,66.17) v3(34.92,64.9) v3(34.92,63.88) v3(46.98,161.21) v3(47.07,159.84) v3(63.83,172.62) v3(65,172.59) v3(65.53,112.97) v3(66.04,172.57) v3(66.19,112.64) v3(67.21,172.54) v3(68.28,172.54) v3(69.24,172.54) v3(141.1,58.14) v3(141.91,58.14) v3(141.91,57.38) v3(142.75,57.35) v3(142.77,58.17)
VCC2V5: length 68.3
  TOP w0.381: C273.1 139.06,75.94 139.4,75.6 v2(139.64,75.6) ; C204.1 143.13,97.48 v2(142.64,96.99) ; v2(142.64,72.6) 143.13,73.08 C287.1 ; R400.2 139.76,65.15 v1(140.14,65.15) 140.53,65.15 R399.2 ; C195.1 139.34,99.99 v2(139.64,99.99) ; B34.1 153.35,75.81 v1(153.75,75.41) ; C189.1 139.02,101.99 v2(139.64,101.99) ; B30.1 153.16,91.06 v1(152.65,90.55) ; C262.1 139.02,77.6 v2(139.64,77.6)
  L8 w0.508: v1(123.07,127.13) 123.2,127.13 123.24,127.18 123.67,127.18 125.6,125.25 125.6,121.44 127.08,119.96 131.13,119.96 132.21,121.03 135.14,121.03 138.66,117.52 138.66,115.21 142.24,111.63 v3(145.92,111.63)
  L10 w0.508: CN16.B12 157.77,96.31 ; CN16.B12 156.35,94.9 ; CN16.B12 157.77,94.9 ; CN16.B12 156.35,96.31 ; 156.35,82.34 CN16.A12 ; CN16.A12 157.77,82.34 ; CN16.A12 156.35,80.93 ; CN16.A12 157.77,80.93
  BOTTOM w0.381: v1(123.07,127.13) 123.09,127.15 123.09,128.81 R566.1 ; PHY2.K9 v2(146.64,94.99) PHY2.J8 ; PHY1.L2 v2(148.64,77.6) ; v2(138.64,69.59) 139.15,70.09 PHY1.B9 ; R645.1 v3(140.46,88.77) ; v2(139.64,77.6) 140.14,77.1 PHY1.C2 ; PHY2.B9 139.15,94.48 v2(138.64,93.98) ; v2(142.64,96.99) 143.14,96.49 PHY2.F7 ; PHY2.B4 v2(139.64,99.99) ; PHY1.K9 v2(146.64,70.6) PHY1.J8 ; PHY2.K1 147.14,102.69 v2(147.57,103.12) ; R652.1 v3(143.51,86.49) ; PHY1.F7 143.14,72.1 v2(142.64,72.6) ; v1(143.38,65.15) 143.64,65.41 R728.1 ; PHY1.K1 147.14,78.56 v2(147.57,78.98) ; v1(145.9,64.16) 146.44,63.62 R735.1 ; PHY1.B4 v2(139.64,75.6) ; v2(139.64,101.99) 140.14,101.49 PHY2.C2 ; PHY2.L2 v2(148.64,101.99) ; R679.2 v3(148.34,80.76) ; R603.2 v3(148.34,105.16)
  vias: v3(146.69,111.63) v3(147.45,111.63)
VCC2V5_EN: length 23.1
  TOP w0.127: v1(149.61,118.97) 149.85,118.73 R251.2 150.96,118.64 Q8.5 ; R178.1 140.84,130.76 v1(140.78,130.71)
  L8 w0.114: v1(140.78,130.71) 141.73,130.71 144.35,128.09 144.35,121.22 145.2,120.38 148.2,120.38 v1(149.61,118.97)
  BOTTOM w0.127: v1(149.61,118.97) 149.85,118.73 R251.2
VCC2V5_EN_R: length 10
  TOP w0.127: R178.2 139.94,131.33 v1(139.27,130.66) ; U13.18 133.51,125.1 v1(133.76,125.35)
  BOTTOM w0.127: v1(139.27,130.66) 138.71,130.1 138.18,130.1 133.76,125.68 v1(133.76,125.35)
VCC2V5_MON: length 5.6
  TOP w0.254: U13.40 125.12,126.6 124.08,127.63 124.08,128.72 R197.2 123.51,129.37 v1(123.06,129.82)
  BOTTOM w0.254: R197.2 123.51,129.45 123.14,129.82 v1(123.06,129.82)
VCC3_AUX_EN_R: length 3.4
  TOP w0.254: U13.7 129.66,121.14 131.15,119.65 R250.2
VCC3_AUX_MON: length 6.6
  TOP w0.254: v1(123.02,131.28) 123.02,131.07 123.41,130.68 R191.2 124.46,129.74 124.46,127.89 125.25,127.1 U13.39
  BOTTOM w0.254: R191.2 123.51,130.78 v1(123.02,131.28)
VCC3_AUX_PGOOD: length 4.6
  TOP w0.254: TP2.1 134.7,168.94 133.8,168.04 R21.1
  TOP w0.279: U2.14 133.25,167.97 R21.1
VCC3_LCD: length 14.7
  BOTTOM w0.381: LCD1.12 70.41,155.82 C409.1 72.01,157.1 72.77,156.34 R512.1 R505.1 73.21,159.03 73.8,159.62 Q13.2
VCC3_LCDBK: length 3.7
  BOTTOM w0.508: R509.1 49.09,155.08 48.61,154.61 LCD1.A
VCC3V3_AUX: length 373
  TOP w0.254: U19.27 84.4,120.39 84.28,120.27 v1(84.22,120.27) ; C282.1 26.55,74.5 U25.7 ; R302.1 93.6,113.08 93.04,113.64 93.04,114.83 92.73,115.14 U19.48 ; CN3.61 39.6,147.2 v1(39.72,147.32) ; U19.34 84.2,116.89 v1(84.14,116.95) ; v1(84.52,123.51) 84.54,123.51 85.06,122.99 85.85,122.99 86.12,122.71 U19.24 ; U14.48 49.48,127.28 v1(49.53,127.23) ; U19.18 89.12,123.28 v1(88.82,123.58) 88.82,123.55 88.62,123.35 U19.19 ; v1(93.73,120.39) 93.6,120.39 93.6,120.39 U19.10 ; U19.31 84.49,118.39 v1(84.22,118.67) 84.45,118.89 U19.30 ; U19.7 93.49,118.89 93.68,119.08 v1(93.73,119.08) ; v3(32.85,162.53) 32.45,162.13 CN3.120 ; U33.5 147.16,60.21 147.19,60.17 147.19,60.17 v1(147.19,60.17) ; v1(41.97,162.7) 40.01,162.7 39.02,161.7 CN3.119 ; v1(30.93,147.19) 30.96,147.19 30.95,147.2 CN3.62 ; Q2.4 108.83,161.18 108.66,161.01 ; 107.83,161.12 Q2.2 ; 107.33,161.1 Q2.1 ; v1(91.62,123.58) U19.13
  TOP w0.279: U15.19 67,120.85 66.74,120.59 v3(66.5,120.59) U15.18 ; v1(106.43,124.92) 106.72,125.21 U16.7 ; v3(71.18,123.07) 70.93,123.32 U15.27 ; 102.3,46.3 102.36,46.24 102.36,45.72 102.74,45.34 103.21,45.34 103.48,45.61 U38.10 ; 25.55,86.97 U25.44 ; U14.13 57.31,128.01 57.31,128.01 v1(57.38,128.01) ; U14.34 v1(51.23,135.15) ; U16.44 117.4,126.21 v3(117.63,126.44) 117.36,126.71 U16.45 ; v1(53.24,126.37) 53.24,126.46 53.23,126.47 U14.7 ; U14.30 53.23,134.98 v1(52.96,135.25) 52.73,135.03 U14.31 ; U14.18 57.23,130.51 v3(57.4,130.68) 57.08,131.01 U14.19 ; U55.8 77.68,112.66 v1(77.97,112.95) ; U15.30 70.93,124.82 v3(71.2,125.09) 70.97,125.32 U15.31 ; v1(62.36,123.56) 62.42,123.56 62.65,123.32 U15.10 ; v1(54.73,135.2) U14.27 ; C126.1 63.18,129.67 63.5,129.67 64,129.17 U15.48 ; U15.24 70.04,121.57 v3(70.07,121.61) ; U15.7 v3(62.25,124.82) ; v1(64,120.6) U15.13 ; U15.34 v3(71.2,126.82) ; U25.45 25.06,86.98 ; v1(56.48,135.13) U14.24 ; U14.10 v1(54.73,126.37)
  TOP w0.356: v3(115.44,49.28) 114.71,48.55 DIMM1.199 ; U35.1 27.82,43.57 27.05,42.8 26.35,42.8 C366.1 ; C334.2 131.51,55.93 131.77,56.18 U32.1 133.17,56.18 135.86,58.88 R403.2 ; U37.1 33.54,43.37 32.64,42.47 C367.1 ; U18.15 157.84,110.59 157.42,110.18 C165.1 ; C30.1 144.32,158.23 U5.19
  TOP w0.381: v1(175.9,147.7) 176.4,148.21 R70.2 ; U11.5 103.62,138.57 102.94,139.25 R112.2 102.94,140.49 102.33,141.11 v3(102.29,141.11) ; R329.2 15.44,91.62 v3(15.62,91.44) ; R381.2 35.56,73.28 34.92,72.64 33.99,72.64 v1(33.93,72.69) ; C367.1 32.7,42.11 33.15,41.66 v3(33.27,41.66) ; v1(151.7,57.51) C330.1 ; R386.2 24.39,64.14 24.59,64.34 v3(24.59,64.36) ; v3(63.45,130.58) 63.21,130.58 C126.1 ; C355.1 102.3,46.3 101.6,45.59 v3(101.6,45.57) ; v3(28.83,72.77) 28.14,73.46 R377.1 27.37,73.46 26.67,74.17 26.61,74.17 C282.1 ; v1(30.39,89.19) 30.39,89.19 30.1,88.9 R337.2 ; v3(31.37,72.67) 31.75,73.05 R379.2 ; R216.2 104.7,124.34 v1(104.7,125.12) ; R452.2 36.83,41.15 37.55,40.43 v3(37.64,40.43) ; C165.1 C164.2 155.39,110.18 v3(154.94,109.73) 154.49,109.28 R290.1 ; 123.42,164.41 123.83,164.82 123.83,170.43 124.53,171.14 R13.1 ; v3(87.63,148.34) 88.05,148.76 R81.2 ; v1(157.66,108.69) 158.25,109.28 R291.1 ; R92.2 113.08,143.55 v3(113.08,143) ; R11.2 v3(114.24,172.34) ; R271.2 109.7,115.18 v1(109.58,115.06) 108.85,114.33 107.38,114.33 107.05,114.67 107.05,115.68 B15.1 ; R453.2 37.94,41.18 37.59,41.53 v1(37.52,41.53) ; v3(26.59,40.51) 26.92,40.51 27.05,40.64 R446.2 ; R339.2 33.65,88.33 v1(33.2,87.88) ; R424.2 124.14,50.16 v3(124.16,50.14) ; v1(36.81,78.9) 36.78,78.87 R359.2 R362.2 36.14,77.35 v1(36.68,76.81) 36.62,76.81 R366.2 ; v1(44.83,123.19) 45.36,123.19 45.36,123.19 B25.1 ; Q6.4 120.64,118.11 120.25,118.49 C136.1 119.45,118.55 118.99,119.01 v1(118.99,119.22) ; v3(132.46,55.37) 132.05,54.97 C334.2 ; R318.2 15.13,104.46 15.79,105.13 v3(15.8,105.13) ; v3(134.14,167.14) R21.2 ; R270.1 114.57,115.27 v1(114.55,115.27) ; R450.2 v3(34.04,40.56) ; R409.1 124.14,53.54 v3(124.59,53.09) 124.14,52.64 R420.2 ; B13.3 120.91,126.7 v3(120.94,126.73) ; v1(110.46,52.48) 110.44,52.48 110.17,52.2 R421.2 R428.2 ; v3(16.61,112.14) 16.61,112.75 B23.1 ; v3(66.19,132.61) 66.55,132.26 R214.1 ; v3(92.96,112.5) 93.12,112.5 R302.1 ; R449.2 v3(31.24,40.58) ; v1(26.98,112.21) 26.98,112.47 26.42,113.03 R276.1 ; v1(30.93,147.19) 30.74,147.38 30.73,147.38 29.84,148.26 29.84,150.62 27.13,153.33 R34.2 27.13,157 v1(27.64,157.51) ; R110.2 177.05,140.07 177.93,140.95 R111.2 v1(177.93,141.6) ; R451.2 v3(35.43,40.56) ; v3(135.36,39.17) 135.36,39.14 135.81,38.69 R460.2 ; R448.2 v3(29.84,40.58) ; C366.1 26.1,41.66 v3(26.29,41.66) ; R82.2 v3(75.72,150.32) ; v3(90.04,111.25) R300.1 ; v1(50.8,140.84) 50.71,140.93 50.71,141.02 50.16,141.57 R121.2 ; R406.2 28.77,54.67 v3(29.13,55.02) 29.48,54.67 R407.2 ; R447.2 v3(28.45,40.58) ; R220.1 v3(168.91,124.71)
  TOP w0.508: B14.1 90.02,107.65 v3(89.99,107.62) ; C114.1 121.53,123.95 121.79,123.7 121.79,123.7 v3(121.92,123.57) ; v3(146.05,160.02) 146.05,159.49 145.38,158.81 C30.1
  L3 w0.508: v3(16.61,112.14) 16.61,112.33 18.07,113.79 20.33,113.79 21.35,112.78 26.42,112.78 v1(26.98,112.21)
  L5 w0.508: v3(141.35,39.17) v3(135.36,39.17)
  L8 w0.381: v1(39.72,147.32) 39.4,147.32 38.76,146.68 38.76,146.5 38.3,146.04 37.28,146.04 36.98,145.73 32.83,145.73 31.37,147.19 v1(30.93,147.19)
  L8 w0.508: v3(15.62,91.44) 15.57,91.49 15.57,105.13 v3(15.8,105.13) 15.29,105.63 15.29,111.44 15.99,112.14 16.61,112.14 v3(16.61,112.14)
  BOTTOM w0.254: C769.1 33.74,39.61 U60.10 ; U49.1 144.58,162.93 C393.1 ; C401.2 134.82,155.71 U49.36
  BOTTOM w0.279: U49.6 145.63,159.21 146.05,159.63 v3(146.05,160.02) ; U49.19 145.62,152.71 ; U49.12 146.5,156.21 C402.1
  BOTTOM w0.305: U53.9 95.59,129.88 v1(96.27,130.56)
  BOTTOM w0.356: Q21.4 116.27,35.93 116.76,36.42 118.16,36.42 118.64,35.94 118.64,32.87 120.22,31.29 135.53,31.29 137.01,32.77 137.01,34.59 135.66,35.94 135.66,38.86 v3(135.36,39.17) ; v1(81.03,117.6) 81.03,117.6 81.03,117.88 80.57,118.34 C487.1 79.92,117.7 U57.3 79.92,115 79.55,114.63 78.94,114.63 78.62,114.95 U57.1
  BOTTOM w0.381: R585.2 150.88,120.22 150.65,120.45 v3(150.55,120.45) ; R440.2 35.49,44.88 v3(34.92,45.44) 34.92,45.54 R439.2 ; C688.1 21.08,74.79 v3(20.5,75.37) ; v1(93.73,119.08) 93.68,119.08 93.47,118.87 C485.2 ; v3(71.18,123.07) 71.88,122.37 71.88,121.46 72.39,120.96 72.93,120.96 73.36,121.39 73.36,121.81 75.75,124.21 R586.1 ; v1(93.73,120.39) 93.6,120.39 93.59,120.4 C483.2 ; v3(34.98,48.97) 34.98,48.01 R438.2 ; C230.1 25.46,88.46 25.3,88.62 25.3,88.85 v3(25.28,88.88) ; v3(146.12,152.5) 146.1,152.5 145.9,152.71 145.62,152.71 ; v3(19.3,32.26) 19.75,31.81 R773.1 ; C481.2 C482.2 84.69,123.36 84.54,123.51 v1(84.52,123.51) 84.23,123.22 B44.1 ; R785.2 32.26,38.35 32.24,38.34 v3(32,38.34) ; C402.1 v3(146.69,156.84) ; v1(121.91,130.79) 121.95,130.79 121.98,130.76 122.35,130.76 122.43,130.68 R563.1 ; v1(36.81,78.9) 36.78,78.87 R359.2 ; v3(15.04,31.39) 15.33,31.39 R791.1 ; v3(98.12,124.08) 98.32,123.88 U62.5 ; v1(84.14,116.95) 84.21,116.95 84.28,117.02 84.61,117.02 C489.2 C488.2 84.72,118.67 v1(84.22,118.67) ; C769.1 33.6,40.12 v3(34.04,40.56) ; v3(145.66,162.68) 145.66,162.82 145.16,163.32 C393.1 ; R302.1 93.12,112.5 v3(92.96,112.5) ; C401.2 v1(134.82,154.97) ; v1(91.62,123.58) 91.62,123.07 C478.2 C477.2 ; R534.2 178.89,144.3 v1(178.28,144.91) ; R750.2 101.4,45.76 v3(101.6,45.57) ; R492.2 171.59,154.93 v3(171.83,154.69) ; C479.2 C480.2 88.52,123.24 88.82,123.55 v1(88.82,123.58) ; R557.2 17.96,107.37 16.89,106.3 16.2,106.3 15.8,105.89 v3(15.8,105.13) ; R575.2 119.45,121.47 119.08,121.84 v1(119.02,121.84) 119.45,122.27 R573.2 ; v3(17.91,32.26) 18.36,31.81 R780.1 ; C438.1 68.9,140.44 70.23,139.12 70.23,136.78 69.7,136.25 v3(69.49,136.25) ; v1(106.43,124.92) 106.66,124.92 C465.1 ; R793.1 v3(13.46,31.81) ; v1(30.39,89.19) 30.1,88.89 R337.2 28.99,88.33 28.86,88.46 R650.2
  BOTTOM w0.406: Q17.4 69.1,141.83 68.9,141.63 C438.1
  BOTTOM w0.508: v1(27.64,157.51) 29.74,157.51 32.84,160.6 32.84,162.52 v3(32.85,162.53) 33.79,163.47 41.5,163.47 41.91,163.06 41.91,162.75 v1(41.97,162.7) 41.97,162.82 42.67,163.53 45.47,163.53 46,162.99 46,158.57 47.35,157.23 R509.2 47.45,157.23 48.12,157.9 v3(48.12,157.94)
  vias: v1(37.72,86.54) v1(37.73,85.86) v3(38.23,42.9) v3(41.02,124.08) v3(41.4,123.44) v3(106.93,160.66) v3(108.15,160.66) v3(123.47,53.06) v3(123.57,158.5) v3(123.57,157.61) v3(123.57,156.59) v3(123.57,155.57) v3(124.59,158.5) v3(124.59,157.61) v3(124.59,156.59) v3(124.59,155.57) v3(125.6,158.5) v3(125.6,157.61) v3(125.6,156.59) v3(125.6,155.57) v3(138.13,53.95) v3(138.1,53.11) v3(138.18,54.74) v3(139.48,118.91) v3(140.29,118.93) v3(140.39,80.72) v3(140.39,79.96) v3(141.05,118.87) v3(141.15,79.93) v3(147.32,119.64) v3(147.27,118.77) v3(148.08,119.63) v3(148.11,118.77) v3(169.85,44.02) v3(170.76,44.04) v3(171.58,115.19) v3(171.58,109.98) v3(171.58,107.19)
VCC3V3_AUX_EN: length 161.8
  TOP w0.254: v1(130.85,119.23) 130.94,119.23 131.42,118.75 R250.1
  TOP w0.381: CN24.2 173.68,153.34 R24.2
  L3 w0.254: v1(139.91,156.55) 140.76,155.7 141.86,155.7 144.53,158.37 144.53,160.78 145.24,161.49 146.15,161.49 146.16,161.48 147.8,161.48 148.24,161.93 149.22,161.93 151,160.15 156.97,160.15 159.89,163.07 160.78,163.07 162.88,160.97 168.47,160.97 168.97,160.47 168.97,159.71 169.49,159.19 169.87,159.19 173.61,155.45 173.61,153.27 CN24.2 ; v1(130.85,119.23) 130.84,119.23 130.16,119.91 126.31,119.91 123.95,122.28 123.95,131.11 121.28,133.77 121.28,136.13 117.27,140.15 117.27,140.99 115.87,142.39 115.87,145.07 115.27,145.67 113.51,145.67 110.33,148.85 110.33,166.27 109.63,166.97 109.63,167.34 109.35,167.62 109.35,170.8 109.6,171.06 111.25,171.06 111.89,170.42 111.89,168.27 112.31,167.84 112.32,167.84 112.9,167.26 121.16,167.26 121.54,166.88 124.71,166.88 125.86,165.74 v1(127.51,165.74)
  L8 w0.254: v1(127.51,165.74) 127.51,169.67 128.52,170.69 132.46,170.69 133.22,169.93 133.22,166.5 137.41,162.31 137.41,159.58 139.91,157.08 v1(139.91,156.55)
VCC3V3_AUX_EN_R: length 77.1
  TOP w0.254: U2.10 129.55,166.33 128.95,165.74 v1(128.14,165.74)
  L3 w0.254: CN24.1 173.23,151.13 174.12,152.02 174.12,155.57 170.05,159.64 169.67,159.64 169.42,159.89 169.42,160.66 168.72,161.35 163.04,161.35 160.94,163.45 159.73,163.45 156.81,160.53 151.29,160.53 149.51,162.31 148.08,162.31 147.64,161.87 146.32,161.87 146.31,161.87 144.98,161.87 144.02,160.91 144.02,158.5 141.6,156.08 141.1,156.08 140.08,157.1 139.38,157.1 v1(139.25,156.97)
  L8 w0.254: v1(128.14,165.74) 128.14,166.24 127.89,166.5 127.89,169.42 128.78,170.31 132.3,170.31 132.84,169.77 132.84,166.34 137.03,162.15 137.03,159.13 139.19,156.97 v1(139.25,156.97)
VCC3V3_MP: length 319.2
  TOP w0.254: v3(165.11,150.37) 165.11,150.25 164.55,149.69 U7.68 ; v3(165.86,156.18) 166.18,156.5 166.18,158.25 166.89,158.96 U4.8 ; U12.8 145.13,138.67 v3(145.03,138.58)
  TOP w0.279: 146.13,143.38 146.71,143.97 147.02,143.97 147.29,143.69 U7.20 ; U7.8 146.32,149.69 146.18,149.55 C45.2 ; v3(164.97,143.76) 164.9,143.69 U7.56 ; U7.44 158.96,138.55 158.9,138.49 158.9,138.26 C73.1 ; U7.3 149.27,152.19 v1(149.48,151.98) ; U13.33 128.16,129.87 v3(128.11,129.92) ; U7.81 159.46,156.74 C38.2 ; v3(153.37,157.23) 153.46,157.14 U7.93 ; U7.32 152.96,137.55 C69.1
  TOP w0.356: U6.5 v3(170.19,146.86)
  TOP w0.381: v3(143.64,148.97) 144.94,148.97 145.51,149.55 C45.2 ; R222.2 145.77,122.74 145.99,122.52 v1(146.56,122.52) ; v3(159.05,137.03) 159.03,137.06 158.29,137.06 158,137.36 C73.1 ; R249.1 134.79,118.8 v3(135.33,119.35) ; C38.2 159.07,158.86 v1(159.34,159.13) ; C40.2 169.35,154.33 v3(168.87,154.81) 168.34,155.33 R40.2 ; v3(132.02,133.08) 131.7,132.76 R175.1 ; R30.2 177.39,159.14 177.19,158.94 v1(177.19,158.65) ; v3(144.81,141.68) 145.02,141.89 C427.2 145.02,142.78 145.62,143.38 146.13,143.38 ; v1(154.79,120.85) 154.29,120.85 R232.1 ; v3(170.8,150.24) 170.8,150.31 170.25,150.87 R59.1 ; R176.1 v3(133.1,133.07) ; C69.1 153.27,137.16 v1(153.83,136.61) ; R248.1 132.76,118.8 132.41,119.15 132.41,119.28 132.44,119.3 v3(132.44,119.27)
  TOP w0.508: R161.2 v3(170.88,132.08) 170.88,131.76 171.77,130.87 v3(171.77,124.74) R217.2 ; R83.2 v3(167.95,132.01)
  TOP w0.635: v3(167.18,40.23) 167.58,39.83 R84.2
  TOP w0.762: R317.1 124.01,104.45 123.77,104.22 123.77,103.42 124.25,102.94 125.55,102.94 125.86,103.25 127.61,103.25 128.75,104.39 U22.1 133.79,104.39 C180.2 133.92,104.89 134.82,105.79 R306.1 R297.1 135,107.57 v3(136.02,106.55) ; v3(155.57,39.37) R531.2
  L3 w0.508: v3(159.07,121.03) 159.1,121.06 168.09,121.06 v3(171.77,124.74)
  L3 w0.762: v3(167.18,40.23) 166.21,40.23 166.06,40.39 166.01,40.39 165.63,40.77 165.23,40.77 163.45,42.55 156.72,42.55 155.57,41.4 v3(155.57,39.37) 154.56,38.35 144.91,38.35 144.4,37.85 v3(140.34,37.85)
  L8 w0.508: v3(143.64,148.97) 142.01,148.97 141.48,148.44 141.48,145.67 140.44,144.63 138.33,144.63 133.15,149.81 101.58,149.81 101.48,149.71 100.91,149.71 100.81,149.81 96.65,149.81 88.94,157.51 76.07,157.51 74.11,155.55 v3(74.11,155.55)
  L8 w0.762: v3(140.34,37.85) 140.34,51.05 139.22,52.17 139.22,56.74 136.55,59.41 136.55,82.65 134.75,84.45 134.75,106.17 135.13,106.55 v3(136.02,106.55) 136.78,106.55 137.49,107.26 137.49,117.2 v3(135.33,119.35)
  BOTTOM w0.356: v3(148.11,140.31) 148.81,140.31 149.24,140.74 U52.19 ; R576.1 157.58,119.68 157.58,119.23 157.84,118.98 U56.15
  BOTTOM w0.381: C394.2 146.69,160.94 v3(146.67,160.93) ; v3(126.77,119.3) 126.77,119.3 126.77,119.15 126.42,118.8 R581.2 ; v3(157.91,153.72) 157.91,154.19 157.61,154.49 R497.2 R498.2 ; R528.1 164.41,146.11 164.72,145.8 v3(164.97,145.8) ; R576.1 158.43,120.34 159.07,120.98 v3(159.07,121.03) ; v1(154.81,119.89) 155.26,119.44 C476.1 C475.2 ; v3(160.25,153.87) 160.25,154.15 159.91,154.49 R495.2 R496.2 ; v1(154.79,120.85) 154.76,120.85 154.25,120.34 R577.1 ; v3(162.66,147.7) R526.2 ; v1(178.23,154.86) 178.65,154.44 R507.2 ; R518.2 v3(162.56,151.77) ; D11.1 148.97,160.02 148.41,159.45 v3(147.47,159.45) C398.2 ; R546.1 160.98,137.03 v3(159.05,137.03) ; C416.2 v3(165.11,150.37) ; C424.2 v3(164.97,143.76)
  BOTTOM w0.508: v3(170.88,132.08) 170.81,132.01 v3(167.95,132.01) ; R512.2 v3(74.11,155.55)
  vias: v3(128.81,133.03) v3(129.49,132.69) v3(147.57,130.2) v3(147.58,129.44) v3(156.97,149.1) v3(157.73,149.1)
VCC3V3_MP_ALT: length 55.6
  L5 w0.508: v1(150.37,156.34) 150.24,156.21 149.24,156.21 146.22,159.23 145.39,159.23 144.37,160.25 137.5,160.25 131.88,154.64 124.16,154.64 123.32,153.8 113.45,153.8 110.39,156.86 110.39,163.51 v1(110.84,163.96)
  BOTTOM w0.381: D11.2 149.53,156.21 150.24,156.21 v1(150.37,156.34) R502.1
VCC3V3_MP_ALT_DET: length 3.5
  TOP w0.254: U7.99 150.46,153.77 v1(150.4,153.71)
  BOTTOM w0.381: v1(150.4,153.71) 150.37,153.75 R502.2 R503.1
VCC3V3_MP_AMC: length 12.5
  TOP w0.483: AMC1.4 5.07,36.71 5.42,36.36 9.26,36.36 9.89,36.99 9.89,38.8 10.36,39.26 11.79,39.26
  TOP w0.508: v1(12.68,39.26) 11.79,39.26
  vias: v1(10.34,94.39) v1(10.92,94.11) v1(12.57,35.43) v1(13.08,34.92) v1(13.4,106.12) v1(13.72,106.68) v3(136.14,109.35) v3(136.14,108.46)
VCC3V3_PCIE: length 24.2
  TOP w0.305: 18.59,111.84 18.68,111.75 U20.1 ; U20.11 26.76,108.5 v1(26.92,108.33) 26.59,108 26.59,107.96 26.48,107.85 U20.10
  TOP w0.508: v1(14.73,112.57) 14.73,112.83 15.06,113.16 C151.1 15.43,110.26 15.81,109.88 R292.1 ; 18.59,111.84 18.49,111.94 v1(18.49,112.19) 18.8,112.5 B23.3
  L10 w0.381: v1(26.92,108.33) 24.51,108.33 20.65,112.19 v1(18.49,112.19) 17.92,112.76 14.92,112.76 v1(14.73,112.57)
VCC3V3_U: length 17.6
  TOP w0.254: v1(154.9,172.38) U3.20 ; U3.42 146.81,164.59 C24.1 ; 149.4,157.86 U3.50 ; U3.56 152.4,157.93 C36.1 ; U3.31 149.4,171.91 149.1,172.21 147.32,172.21 147.07,172.47 C3.1
  TOP w0.381: 149.4,157.86 C35.2 149.28,157.73 v1(148.62,157.73) ; C36.1 151.95,157.8 v1(151.38,158.37) ; R16.1 v1(161.11,169.9) ; v1(145.49,163.98) 145.39,163.98 144.98,164.4 C24.1
  TOP w0.508: v1(167.13,165.61) 166.56,165.04 B5.1 ; B6.1 v1(166.56,162.05) ; C3.1 147.26,172.97 v1(147.83,172.97)
  BOTTOM w0.508: R484.2 150.11,162.49 v1(149.92,162.69)
  vias: v1(161.93,167.26) v1(163.58,166.5)
VCC5: length 127.7
  TOP w0.279: CN3.59 39.19,141.7 v1(39.58,142.09) ; v1(34.18,141.59) 34.16,141.59 34.05,141.7 CN3.60
  TOP w0.381: R7.1 v3(103.94,174.85)
  TOP w0.508: v3(48.29,155.51) 47.38,155.51 46.35,154.49 46.35,152.78 47.12,152.02 47.12,150.88 45.8,149.56 45.8,146.58 44.48,145.26 44.46,145.26 44.09,144.89 44.09,144.88 43.43,144.22 42.64,144.22 40.51,142.09 v1(39.58,142.09)
  L8 w0.508: v3(48.29,155.51) 61.51,155.51 78.12,172.12 90.28,172.12 93.01,174.85 v3(103.94,174.85)
  L10 w0.508: v3(152.04,133.99) 151.74,133.99 149.97,135.76 123.02,135.76 121.87,134.6 121.87,134.26 v3(121.95,134.19) ; v1(39.58,142.09) 39.55,142.11 39.36,142.11 38.47,143 35.59,143 v1(34.18,141.59)
  BOTTOM w0.381: v3(121.95,134.19) 121.92,134.16 121.92,133.05 122.61,132.36 R560.1
  vias: v3(119.63,159.51) v3(119.63,158.37) v3(120.78,159.51) v3(120.78,158.37) v3(120.78,157.1) v3(120.78,155.7) v3(121.79,159.51) v3(121.79,158.37) v3(121.79,157.1) v3(121.79,155.7) v3(154.94,105.66) v3(155.45,107.44) v3(155.57,106.04)
VCC5_EN: length 61.2
  TOP w0.254: v1(129.64,119.28) 130.12,118.8 R247.1
  TOP w0.381: v1(109.12,167.13) 109.12,167.23 108.71,167.64 R18.2
  L3 w0.254: v1(119.86,131.11) 119.71,131.27 119.71,135.46 116.51,138.66 116.25,138.66 114.35,140.56 114.35,144.06 109.95,148.46 109.95,166.11 109.12,166.94 v1(109.12,167.13)
  BOTTOM w0.254: v1(129.64,119.28) 129.64,120.17 127.51,122.3 124.71,122.3 122.81,124.2 122.81,126.11 119.86,129.06 v1(119.86,131.11) ; R479.2 109.82,167.16 109.15,167.16 v1(109.12,167.13)
VCC5_EN_R1: length 2.6
  TOP w0.254: U13.6 129.16,120.84 R247.2
VCC5_EN_R2: length 2.2
  TOP w0.254: U1.10 109.48,169.68 108.71,168.91 R18.1
VCC5_MON: length 7.5
  TOP w0.254: v1(123.06,132.72) 123.51,132.26 R173.2 124.08,131.51 124.08,130.94 124.84,130.18 124.84,128.05 125.29,127.6 U13.38
  BOTTOM w0.254: v1(123.06,132.72) 123.51,132.26 R173.2
VCC5_PGOOD: length 3.7
  TOP w0.254: R11.1 113.33,171.46 U1.14
  TOP w0.381: R11.1 113.28,171.39 TP3.1
VCC5_VBUS: length 22.5
  TOP w0.305: D1.6 v1(169.54,165.96)
  TOP w0.381: v1(161.54,171.83) 161.73,171.83 C7.1 164.66,171.07 Q1.8
  TOP w0.508: R26.1 168.21,162.19 v3(168.61,162.59)
  L3 w0.508: v1(161.54,171.83) 162.69,170.69 165.74,170.69 167.84,168.58 167.84,167.66 v1(169.54,165.96) 169.54,164.66 168.61,163.73 v3(168.61,162.59)
  BOTTOM w0.381: C1.1 161.36,170.62 R3.2 162.23,171.58 161.98,171.83 v1(161.54,171.83)
VCC12: length 134.2
  TOP w0.254: 108.98,175.51 U1.6 106.9,173.96 C2.1
  TOP w0.279: R469.2 134.44,35.74 133.99,36.19 U44.27 ; 50.97,144.73 U10.27
  TOP w0.381: AMC1.57 6.12,76.46 7.25,75.32 8.67,75.32 9.42,76.08 v3(9.42,76.48) ; AMC1.72 8.06,87.71 v3(8.33,87.98) ; 114.68,175.77 109.24,175.77 108.98,175.51 ; R469.2 134.77,35.77 C383.1 136.76,35.77 v3(136.88,35.89) ; v3(8.38,35.18) 8.35,35.21 AMC1.2 ; R375.1 14.45,74.17 v3(14.07,73.79) ; R208.1 102.93,125.66 103.28,126.01 v3(103.28,126.12) ; v3(9.27,45.21) 9.27,45.85 8.38,46.74 5.97,46.74 5.5,47.21 AMC1.18 ; v3(9.02,53.95) 8.73,53.65 7.75,53.65 7.44,53.96 AMC1.27 ; v3(8.46,38.02) 7.07,38.02 4.64,40.46 AMC1.9 ; v3(8.38,65.21) AMC1.42 ; v3(8.26,96.19) 7.73,96.71 AMC1.84 ; v3(115.13,149.05) 115.14,149.05 115.14,149.45 114.78,149.81 C44.1 114.74,149.82 114.4,149.48 114.4,149.02 v3(114.4,149.02)
  TOP w0.508: 15.73,55.56 FAN1.2 ; FAN1.2 15.73,56.99 ; FAN1.2 17.16,55.56 ; FAN1.2 17.16,56.99
  L4_PWR w0.508: 9.7,116.31 J1.B1 ; J1.B1 10.7,116.31 ; J1.B1 10.7,115.31 ; 9.5,116.31 J1.A1 8.5,116.31 ; J1.B2 10.7,117.81 ; J1.B2 9.7,117.81 ; J1.B2 9.7,118.81 ; J1.B2 10.7,118.81 ; J1.A2 9.5,118.81 ; J1.A2 9.5,117.81 ; J1.A2 8.5,118.81 ; J1.A2 8.5,117.81 ; FAN1.2 17.12,56.96 ; FAN1.2 17.12,55.6 ; FAN1.2 15.76,56.96 ; FAN1.2 15.76,55.6
  L8 w0.508: v3(120.92,129.2) 121.57,128.55 131.09,128.55 132.16,129.62 135.09,129.62 135.63,129.08 136.15,129.08 136.76,129.69 137.85,129.69 138.43,130.28 v3(138.43,130.71)
  L10 w0.508: v3(103.28,126.12) 103.27,126.12 102.49,126.9 102.49,128.41 102.99,128.91 103.5,128.91 104.08,128.33 116.25,128.33 116.38,128.19 118.43,128.19 119.41,129.18 120.81,129.18 120.83,129.2 v3(120.92,129.2)
  BOTTOM w0.381: v3(50.42,144.91) 50.48,144.96 C49.1
  vias: v3(11.18,97.33) v3(11.68,97.97) v3(11.99,98.68) v3(14.35,52.05) v3(15.11,52.07) v3(16.81,67.18) v3(17.3,66.01) v3(17.53,67.61) v3(17.53,66.75) v3(49.77,147.57) v3(49.78,146.81) v3(50.55,147.57) v3(50.55,146.81) v3(79.4,151.06) v3(80.14,151.13) v3(80.19,151.89) v3(80.9,151.13) v3(81,151.89) v3(81.69,151.21) v3(82.42,151.23) v3(83.16,151.2) v3(112.5,148.16) v3(113.23,148.13) v3(113.39,147.29) v3(114.02,148.13) v3(114.17,147.27) v3(114.94,174.62) v3(114.86,148.18) v3(114.96,147.32) v3(115.82,174.62) v3(126.85,173.35) v3(127.64,173.36) v3(133.99,35.31) v3(133.99,34.54) v3(134.62,34.92) v3(134.62,34.16) v3(135.38,34.92) v3(135.38,34.16) v3(137.64,35.46) v3(137.67,36.2)
VCC18_U: length 41.3
  TOP w0.254: U3.37 145.88,167.1 145.46,167.53 145.46,168.53 145.17,168.82 C12.1 ; C37.1 156.4,158 U3.64 ; U3.49 v1(148.9,161.36)
  TOP w0.279: U3.12 159.36,167.1 160.02,167.77 C17.1
  TOP w0.381: v1(160.22,166.88) 160.29,166.94 160.29,167.69 C17.1 ; v1(155.53,158.4) 155.53,158.16 155.89,157.8 C37.1 ; v1(145.67,166.12) C19.1
  TOP w0.508: C12.1 144.53,168.52 144.53,167.73 v1(144.58,167.69)
  L8 w0.508: v1(144.58,167.69) 144.58,167.21 v1(145.67,166.12) 146.18,166.12 148.9,163.39 v1(148.9,161.36)
  BOTTOM w0.508: v1(160.22,166.88) 160.09,166.88 159.91,167.06 159.1,167.06 158.37,166.32 158.37,160.58 156.16,158.37 155.56,158.37 v1(155.53,158.4) 155.45,158.48 155.45,159.03 153.88,160.59 151.06,160.59 150.29,161.36 v1(148.9,161.36)
