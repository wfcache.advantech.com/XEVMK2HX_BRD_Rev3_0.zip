# Allegro board 19C2830503-01-JOB.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
MMC_PS_N1: length 7.4
  TOP w0.254: D10.1 10.83,35.87 4.9,35.87 4.81,35.96 AMC1.3
MMC_RED_LED: length 21.2
  TOP w0.254: U7.62 164.85,146.69 v1(164.97,146.81) ; R31.1 175.13,157.53 v1(175.39,157.28)
  L10 w0.254: v1(164.97,146.81) 168.53,146.81 169.16,146.18 170.43,146.18 174.96,150.7 174.96,152.45 175.59,153.08 175.59,157.08 v1(175.39,157.28)
NAND_WPZ: length 77.9
  TOP w0.127: R29.2 43.36,160.31 v2(42.57,161.1)
  L3 w0.114: v2(42.57,161.1) 43.28,161.81 43.28,161.98 44.88,163.59 80.89,163.59 94.93,149.54 96.39,149.54 v1(97.47,148.46)
  BOTTOM w0.102: NAND1.C3 35.78,161.16 36.04,161.42 39.72,161.42 40.03,161.1 v2(42.57,161.1)
  BOTTOM w0.127: U50.1 97.95,148.94 v1(97.47,148.46)
NOR_HD#: length 2
  BOTTOM w0.127: NOR1.1 145.59,132.35 R733.1
NOR_SSPCS: length 107.7
  TOP w0.102: U24.F25 86.16,77.06 v2(86,77.06)
  L5 w0.114: v1(130.76,117.93) 130.56,117.73 130.56,85.27 v1(127.91,82.63)
  BOTTOM w0.102: 93.18,82.55 92.17,81.54 86.81,81.54 86.43,81.16 86.43,77.49 v2(86,77.06)
  BOTTOM w0.127: NOR1.7 137.97,132.92 138.11,132.78 138.11,132.3 137.31,131.5 135.43,131.5 134.42,130.49 134.42,129.57 133.15,128.29 133.15,123.29 132.1,122.25 132.1,120.57 131.48,119.95 131.48,118.66 v1(130.76,117.93) ; 93.18,82.55 93.22,82.55 94.98,84.32 113.69,84.32 117.21,80.79 121.26,80.79 122.09,79.97 125.98,79.97 127.91,81.91 v1(127.91,82.63)
NOR_WPZ: length 13.7
  TOP w0.127: v1(142.62,145.03) 142.85,145.26 144.91,145.26 145.23,144.94 147.01,144.94 147.26,144.69 U7.18
  BOTTOM w0.127: NOR1.9 136.7,144.7 136.65,144.75 R530.2 142.56,145.09 v1(142.62,145.03)
P0_CLKSEL: length 8.2
  BOTTOM w0.127: PHY1.H8 145.14,71.1 144.65,70.61 144.65,68.65 R726.1 146.74,66.74 147.22,66.27 147.22,65.18 R735.2
P0_COL_PD: length 5.2
  BOTTOM w0.102: 137.15,73.53 138.68,73.53 139.12,73.1 PHY1.B6
  BOTTOM w0.127: 137.15,73.53 136.91,73.53 135.89,72.52 R709.2
P0_CONFIG0: length 4.7
  BOTTOM w0.102: 140.59,69.1 140.59,70.48 141.15,71.04 PHY1.D8
  BOTTOM w0.127: R730.2 140.59,67 140.59,69.1
P0_CONFIG1: length 6.2
  BOTTOM w0.102: PHY1.E9 142.15,69.1
  BOTTOM w0.127: R738.2 143,65.47 143,67.18 142.15,68.04 142.15,69.1
P0_CONFIG2: length 5
  BOTTOM w0.127: R728.2 143.64,66.93 142.62,67.94 142.62,70.57 PHY1.F8
P0_CONFIG3: length 8.2
  BOTTOM w0.102: PHY1.G7 143.85,72.1 143.23,71.48 142.99,71.48 142.76,71.26 142.76,71.18 142.06,70.48 141.99,70.48 141.73,70.22 141.73,69.1
  BOTTOM w0.127: R729.2 142.66,66.39 142.66,67.02 141.73,67.94 141.73,69.1
P0_CONFIG4: length 6.2
  BOTTOM w0.127: R737.2 144.27,65.22 144.27,67.06 143.15,68.18 PHY1.F9
P0_CONFIG5: length 6.5
  BOTTOM w0.127: PHY1.G9 144.15,68.44 145.66,66.92 145.66,65.14 R736.2
P0_CONFIG6: length 5.2
  BOTTOM w0.127: PHY1.G8 144.12,71.1 143.64,70.61 143.64,68.14 R727.2
P0_RSET: length 5.2
  BOTTOM w0.127: PHY1.M2 149.61,77.56 149.61,78.77 150.37,79.54 150.37,80.89 R678.1
P1_CLKSEL: length 8.9
  BOTTOM w0.102: PHY2.H8 144.76,95.11 144.76,93.49
  BOTTOM w0.127: R652.2 143.9,88.15 144.27,88.52 144.27,89.54 R643.1 143.51,91.47 144.57,92.52 144.76,92.72 144.76,93.49
P1_COL_PD: length 5.2
  BOTTOM w0.102: PHY2.B6 139.15,97.51 138.66,97.99 137.15,97.99
  BOTTOM w0.127: R631.2 135.8,96.65 137.15,97.99
P1_CONFIG0: length 6.7
  BOTTOM w0.102: PHY2.D8 141.15,95.04 140.59,94.49 140.59,93.49
  BOTTOM w0.127: 140.59,93.49 140.59,93.48 R647.2
P1_CONFIG1: length 7.7
  BOTTOM w0.102: 142.15,93.49 PHY2.E9
  BOTTOM w0.127: 142.15,93.49 142.15,93.25 139.83,90.93 139.83,89.04 R655.2
P1_CONFIG2: length 6.3
  BOTTOM w0.102: 142.62,93.49 142.62,94.87 143.15,95.39 PHY2.F8
  BOTTOM w0.127: 142.62,93.49 142.62,92.96 140.46,90.81 R645.2
P1_CONFIG3: length 9.6
  BOTTOM w0.102: PHY2.G7 143.66,96.01 143.13,96.01 142.76,95.65 142.76,95.57 142.06,94.87 141.99,94.87 141.76,94.65 141.76,93.51 141.78,93.49
  BOTTOM w0.127: 141.78,93.49 141.78,93.31 139.57,91.1 139.57,90.04 R646.2
P1_CONFIG4: length 7.8
  BOTTOM w0.127: PHY2.F9 143.15,93.11 141.11,91.07 141.11,88.15 R654.2
P1_CONFIG5: length 7.5
  BOTTOM w0.127: R653.2 142.49,88.15 142.75,88.4 142.75,91.57 143.89,92.71 143.89,94.24 PHY2.G9
P1_CONFIG6: length 6.1
  BOTTOM w0.102: PHY2.G8 143.64,94.98 143.64,93.49
  BOTTOM w0.127: 143.64,93.49 143.64,92.96 141.99,91.31 R644.2
P1_RSET: length 5.4
  BOTTOM w0.127: PHY2.M2 149.61,101.95 149.61,103.17 150.37,103.93 150.37,105.64 150.09,105.92 R602.1
PAPLLOBSCLKN: length 14.7
  TOP w0.102: v2(56.01,68.96) 56.14,68.83 56.14,68.8 U24.AT34
  BOTTOM w0.102: 55.3,61.59 55.55,61.85 55.55,68.5 v2(56.01,68.96)
  BOTTOM w0.127: 55.3,61.59 54.8,61.1 54.8,58.69 56.72,56.77 TP92.1
PAPLLOBSCLKP: length 14.1
  TOP w0.102: v2(55.12,68.96) 55.52,68.56 U24.AU34
  BOTTOM w0.102: v2(55.12,68.96) 54.48,68.33 54.48,61.59
  BOTTOM w0.127: 54.48,61.59 54.48,58.14 55.58,57.05 TP90.1
PASS_CLKN: length 90.5
  TOP w0.102: U14.21 57,132.01 57.15,131.85 57.3,131.85 57.4,131.75 57.58,131.75 v1(57.78,131.95) ; C312.1 43.11,69.21 42.98,69.34 42.6,69.34 42.47,69.21 42.47,68.3 45.39,65.38 48.03,65.38 v1(48.46,65.81)
  L10 w0.089: v1(48.46,65.81) 48.46,65.74 48.71,65.49 49.36,65.49 52.9,69.03 52.9,69.88 54.55,71.53 58.16,71.53 58.4,71.77 58.4,75.24 59.4,76.24 59.4,82.12 59.4,82.39 61.4,84.39 61.4,96.16 61.36,96.21 61.36,97.43 60.4,98.39 60.4,101.63 56.72,105.31 56.72,112.9 57.73,113.92 57.73,118.06 58.87,119.2 58.87,121.85 56.52,124.21 56.52,131.22 57.05,131.75 57.58,131.75 v1(57.78,131.95)
PASS_CLKP: length 90.4
  TOP w0.102: v1(48.44,65.13) 45.28,65.13 42.21,68.2 42.21,69.32 42.49,69.6 42.73,69.6 C309.1 ; v1(57.78,131.32) 57.61,131.5 57.3,131.5 57.2,131.6 57.04,131.6 56.95,131.51 U14.20
  L10 w0.089: v1(57.78,131.32) 57.57,131.53 57.14,131.53 56.73,131.13 56.73,124.3 59.09,121.94 59.09,119.11 57.95,117.97 57.95,113.83 56.93,112.81 56.93,105.4 60.62,101.72 60.62,98.48 61.58,97.52 61.58,96.3 61.62,96.25 61.62,84.3 59.61,82.3 59.61,82.21 59.61,76.15 58.61,75.15 58.61,71.68 58.49,71.55 58.25,71.31 54.64,71.31 53.11,69.79 53.11,68.94 49.45,65.27 48.58,65.27 v1(48.44,65.13)
PASSCLKN_C: length 11.4
  TOP w0.102: C312.2 44.01,68.9 44.2,69.09 52.02,69.09 52.31,68.8 53.25,68.8 53.28,68.82 54.42,68.82 54.52,68.72 U24.AV34
PASSCLKP_C: length 11.4
  TOP w0.102: U24.AV33 54.52,69.26 54.28,69.02 53.28,69.02 53.25,69.05 52.41,69.05 52.12,69.34 44.27,69.34 44.01,69.6 C309.2
PCIE_CLKN: length 102.3
  TOP w0.102: U19.25 84.32,121.39 84.07,121.64 84.07,125.91 83.19,126.8 83.19,128.65 v1(83.31,128.78) ; v1(35.16,110.9) 34.98,111.08 34.98,111.31 34.6,111.68 31.91,111.68 28.86,114.73 13.83,114.73 12.22,113.12 12.22,109.09 12.85,108.46 13.59,108.46 13.77,108.27 C167.1
  L8 w0.102: v1(83.31,128.78) 83.16,128.63 83.16,128.29 82.57,127.7 79.32,127.7 79.11,127.7 77.11,129.7 75.97,129.7 75.21,130.45 71.63,130.45 69.27,128.09 63.5,128.09 61.52,126.11 60.22,126.11 58.06,123.95 52.22,123.95 51.62,124.56 47.53,124.56 46.87,123.9 46.86,123.9 46.61,123.65 46.61,123.64 45.72,122.75 45.72,118.11 43.87,116.26 43.38,116.26 40.72,113.59 40.72,113.23 39.12,111.63 35.26,111.63 35.12,111.49 35.12,110.94 v1(35.16,110.9)
PCIE_CLKN_R: length 6.3
  TOP w0.102: U20.6 18.88,108.5 18.65,108.72 18.24,108.72 R295.2 17.91,108.46 17.65,108.71 17.34,108.71 R296.1 16.71,108.24 16.26,108.69 15.28,108.69 C167.2
PCIE_CLKP: length 102.3
  TOP w0.102: U19.26 84.88,120.89 84.63,121.14 84.22,121.14 83.82,121.54 83.82,125.8 82.93,126.69 82.93,128.52 v1(82.68,128.78) ; C166.1 13.77,108.85 13.64,108.71 12.95,108.71 12.47,109.19 12.47,113.01 13.94,114.48 28.75,114.48 31.8,111.43 34.49,111.43 34.72,111.2 34.72,111.1 v1(34.52,110.9)
  L8 w0.102: v1(82.68,128.78) 82.91,128.55 82.91,128.4 82.46,127.95 79.21,127.95 77.21,129.95 76.07,129.95 75.31,130.71 71.53,130.71 69.16,128.35 63.39,128.35 61.41,126.37 60.12,126.37 57.96,124.21 52.32,124.21 51.72,124.81 47.42,124.81 46.77,124.16 46.76,124.16 46.35,123.75 46.35,123.74 45.47,122.85 45.47,118.22 43.76,116.51 43.27,116.51 40.46,113.7 40.46,113.34 39.01,111.89 35.15,111.89 34.86,111.6 34.86,111.21 34.55,110.9 v1(34.52,110.9)
PCIE_CLKP_R: length 6.3
  TOP w0.102: U20.5 18.88,109.15 18.7,108.98 18.22,108.98 R295.1 17.9,109.29 17.58,108.97 17.34,108.97 R292.2 16.71,109.42 16.23,108.94 15.33,108.94 C166.2
PCIE_REF_CLK_N: length 33.7
  TOP w0.102: v1(9.27,97.03) 9.64,96.66 9.64,94.81 8.94,94.11 6.73,94.11 6.56,94.28 5.16,94.28 4.98,94.46 AMC1.81
  TOP w0.127: v1(16.89,110.49) 17.14,110.74 17.53,110.74 17.85,110.42 R282.1 18.16,110.67 18.65,110.67 18.87,110.45 U20.3
  L3 w0.089: v1(16.89,110.49) 16.52,110.86 14.02,110.86 12.94,109.79 12.94,97.78 11.23,96.06 9.91,96.06 9.77,96.2 9.58,96.39 9.58,96.72 v1(9.27,97.03)
PCIE_REF_CLK_P: length 33.8
  TOP w0.102: v1(10.06,97.03) 9.89,96.86 9.89,94.7 9.04,93.85 6.63,93.85 6.45,94.03 5.21,94.03 4.89,93.71 AMC1.80
  TOP w0.127: v1(16.9,111.34) 17.24,111 17.58,111 R282.2 18.28,110.95 18.72,110.95 18.87,111.1 U20.2
  L3 w0.089: v1(10.06,97.03) 9.98,97.03 9.8,96.85 9.8,96.47 9.99,96.28 11.14,96.28 12.73,97.87 12.73,109.88 13.93,111.08 16.64,111.08 v1(16.9,111.34)
PCIECLK_MCU_PD: length 194.5
  TOP w0.127: R86.2 142.67,145.54 140.88,147.33 139.52,147.33 139.01,146.83 v1(139.01,145.54) ; v1(22.58,113.45) 22.29,113.16 R274.1 21.79,110.3 21.29,109.8 U20.4
  L5 w0.114: v1(31.8,162.36) 31.8,161.87 31.03,161.11 31.03,158.86 29.58,157.4 29.58,148.74 26.74,145.9 26.74,139.69 25.95,138.9 25.95,115.14 24.26,113.45 v1(22.58,113.45)
  L10 w0.114: v1(31.8,162.36) 32.11,162.05 33.74,162.05 35.83,164.14 74.37,164.14 83.5,155 85.69,155 88.85,151.84 92.09,151.84 98.67,145.26 112.94,145.26 120.39,137.81 135.81,137.81 137.92,139.92 137.92,145.72 138.17,145.98 138.58,145.98 v1(139.01,145.54)
PCIECLK_MUX_SEL: length 204.6
  TOP w0.127: U7.76 v1(162.48,154.5) ; U20.16 25.76,112.48 R276.2 R275.1 24.07,111.59 v1(24.12,111.54)
  L5 w0.114: v1(24.12,111.54) 24.4,111.54 27.39,114.54 27.39,133.93 29.22,135.76 29.74,135.76 30.25,136.27 30.84,136.27 32.26,137.7 32.26,139.05 34.62,141.41 34.62,141.55 35.81,142.75 38.34,142.75 39.12,143.53 39.12,144.68 39.67,145.24 v1(39.67,146.3)
  L8 w0.114: v1(39.67,146.3) 40.48,146.3 41.75,147.57 41.75,150.07 43.9,152.22 44.18,152.22 44.49,152.52 44.49,152.92 44.7,153.14 44.7,157.62 45.55,158.47 49.25,158.47 49.8,157.92 58.15,157.92 76.65,176.42 145.85,176.42 147.17,175.09 150.77,175.09 150.86,175.01 150.88,175.01 151.76,174.12 154.94,174.12 156.39,172.67 156.39,169.48 156.39,166.62 158.79,164.22 158.79,158.6 159.99,157.4 159.99,156.98 v1(162.48,154.5)
PCIECLK_OE: length 211.1
  TOP w0.127: v1(12.05,107.21) 13.82,107.21 14.15,106.88 15.7,106.88 16.04,107.23 17.41,107.23 17.96,106.68 R304.1 18.15,107.57 18.43,107.85 U20.7 ; v1(138.35,145.54) 138.35,146.53 139.41,147.59 140.99,147.59 142.16,146.42 145.22,146.42 145.47,146.67 R75.2
  L5 w0.114: v1(12.05,107.21) 12.05,108.27 17.72,113.94 24.41,113.94 25.7,115.24 25.7,139 26.5,139.79 26.5,146 29.34,148.84 29.34,157.5 30.79,158.96 30.79,161.23 v1(30.38,161.65)
  L10 w0.114: v1(138.35,145.54) 138.35,139.74 136.18,137.57 120.29,137.57 112.84,145.02 98.57,145.02 91.99,151.6 88.75,151.6 85.61,154.74 83.42,154.74 74.27,163.9 35.98,163.9 33.73,161.65 v1(30.38,161.65)
PCIECLKN_C: length 8.1
  TOP w0.102: C307.2 46.55,70.81 46.65,70.9 47.07,70.9 47.49,70.48 52.45,70.48 52.76,70.8 53.42,70.8 53.52,70.69 U24.AW32
PCIECLKN_M: length 54.1
  TOP w0.102: R286.1 28.26,110.43 28.36,110.53 28.45,110.62 28.63,110.62 R287.1 29.27,110.14 29.74,110.62 30.53,110.62 31.29,109.85 31.55,109.85 R288.1 32.17,109.83 32.53,109.83 34.05,108.31 34.05,106.81 35.83,105.03 35.83,92.08 38.61,89.3 38.61,85.12 38.3,84.8 38.3,73.05 39.11,72.24 39.11,72.18 39.46,71.83 40.84,71.83 41.68,70.99 45.34,70.99 45.65,70.68 C307.1
PCIECLKN_MR: length 2.2
  TOP w0.102: U20.14 26.5,110.45 26.67,110.62 27.18,110.62 27.36,110.43 R286.2
PCIECLKP_C: length 8.1
  TOP w0.102: C302.2 46.55,71.36 46.75,71.16 47.18,71.16 47.6,70.74 52.35,70.74 52.66,71.05 53.42,71.05 53.52,71.15 U24.AW31
PCIECLKP_M: length 54.1
  TOP w0.102: C302.1 45.65,71.36 45.54,71.25 41.78,71.25 40.95,72.08 39.57,72.08 39.37,72.29 39.37,72.34 38.55,73.16 38.55,84.7 38.86,85.01 38.86,89.41 36.09,92.18 36.09,105.13 34.31,106.91 34.31,108.41 32.64,110.08 32.23,110.08 R288.2 31.55,110.11 31.4,110.11 30.64,110.87 29.75,110.87 29.27,111.36 R279.1 28.63,110.87 28.45,110.87 28.26,111.06 R278.1
PCIECLKP_MR: length 2.2
  TOP w0.102: R278.2 27.36,111.06 27.18,110.87 26.67,110.87 26.44,111.1 U20.15
PHY1_INT#: length 99.9
  L8 w0.114: v1(103.25,128.2) 103.84,127.61 121.1,127.61 121.26,127.45 122.45,127.45 122.73,127.74 125.3,127.74 126.44,126.59 126.44,121.22 127.26,120.4 130.68,120.4 131.83,121.54 135.25,121.54 139.7,117.09 145.19,117.09 153.9,108.38 153.9,84.94 151.26,82.3 149.1,82.3 v1(148.34,83.06)
  BOTTOM w0.127: PHY1.L1 148.14,78.61 148.34,78.81 148.34,79.6 148.97,80.24 148.97,81.79 R679.1 v1(148.34,83.06) ; R568.2 v1(103.25,128.2)
PHY2_INT#: length 85.6
  L8 w0.114: v1(149.1,105.16) 148.41,105.84 139.85,105.84 138.2,107.49 138.2,117.36 135.64,119.92 134.27,119.92 133.14,118.79 132.64,118.79 132.64,118.78 132.23,118.78 132.23,118.79 125.18,118.79 124.71,119.25 124.71,122.05 124.4,122.36 124.4,124.86 122.06,127.21 121.16,127.21 121.15,127.22 120.74,127.22 120.64,127.13 106.4,127.13 105.74,126.47 105.74,126.16 105.14,125.56 103.71,125.56 103.37,125.21 v1(103.37,125.16)
  L10 w0.114: v1(103.37,125.16) 103.37,125.2 103.27,125.2 103.26,125.21 91.82,125.21 91.77,125.25 91.66,125.25 v1(91.44,125.48)
  BOTTOM w0.102: PHY2.L1 148.14,102.55 148.46,102.87 148.46,103.49
  BOTTOM w0.127: v1(91.44,125.48) 91.44,125.86 92.46,126.87 R801.2 ; 148.46,103.49 148.46,104.52 v1(149.1,105.16) 149.1,106.05 R603.1
PHY_P0_XTAL1: length 7.3
  BOTTOM w0.127: R725.2 149.67,67.94 147.19,67.94 145.14,69.99 PHY1.H9
PHY_P0_XTAL1_R: length 4.2
  BOTTOM w0.127: Y4.1 148.45,65.22 148.91,65.68 C719.1 R725.1
PHY_P0_XTAL2: length 10.4
  BOTTOM w0.127: Y4.2 152.54,66.2 C718.1 150.28,68.46 147.79,68.46 PHY1.J9
PHY_P1_XTAL1: length 5.3
  BOTTOM w0.127: PHY2.H9 145.44,94.2 145.44,93.45 147.9,90.99 R642.2
PHY_P1_XTAL1_R: length 5.6
  BOTTOM w0.127: R642.1 C570.1 145.87,90.23 146.79,89.31 146.79,87.78 146.45,87.44 Y3.1
PHY_P1_XTAL2: length 9.9
  BOTTOM w0.127: Y3.2 148.4,87.44 148.08,87.76 148.08,88.9 149.03,89.85 C569.1 148.41,90.92 148.41,91.2 146.14,93.46 PHY2.J9
PHY_RSTZ: length 82.1
  TOP w0.127: v1(149.51,153.83) 148.87,153.19 U7.1
  L5 w0.114: v1(149.51,153.83) 149,153.32 149,146.76 148.77,146.53 148.77,138.61 146.35,136.19 146.35,133.74 146.3,133.7 146.3,129.34 146.35,129.29 146.35,128.7 148.74,126.31 148.74,111.07 v1(150.83,108.99)
  L8 w0.114: v1(150.83,108.99) 150.83,105.59 152.78,103.63 152.78,101.35 153.66,100.46 153.66,86.3 v1(152.2,84.84)
  BOTTOM w0.127: R660.2 R659.2 152.14,84.9 v1(152.2,84.84) ; R589.2 R588.2 150.53,109.29 v1(150.83,108.99)
PHYSYNC: length 111.8
  TOP w0.102: v2(59.07,68.76) 58.73,68.42 U24.AP34
  L10 w0.089: 61.43,104.32 61.17,104.32 v1(59.12,106.36)
  L10 w0.102: 61.43,104.32 63.45,102.3 63.45,101.26 63.63,101.08 63.63,83.36 62.61,82.35 62.61,79.78 62.56,79.73 62.56,73.48 61.59,72.52 61.59,71.04 60.03,69.47 59.78,69.47 v2(59.07,68.76) 58.64,68.33 55.75,68.33 53.61,66.18 53.61,65.85 50.32,62.56
  L10 w0.114: CN17.8 24.36,54.53 27.85,54.53 27.85,54.53 29.54,54.53 29.98,54.98 33.64,54.98 36.07,57.4 41.51,57.4 43.47,59.36 47.68,59.36 50.32,62 50.32,62.56
  BOTTOM w0.102: AMC1.154 5.76,46.46 5.92,46.3 9.5,46.3 12.17,48.97 12.17,52.33 12.74,52.9 22.72,52.9 CN17.8 ; v1(59.12,106.36) 58.8,106.69 R617.1
PLL_LOCK1: length 76.6
  TOP w0.127: v1(48.9,123.19) 48.9,123.27 48.48,123.69 48.48,125.13 49.01,125.67 49.01,126.53 48.53,127.01 48.53,128.37 48.78,128.63 48.78,128.77 49.02,129.01 U14.46
  L10 w0.114: v1(48.9,123.19) 48.53,122.83 47.99,122.83 47.73,123.09 47.73,123.89 49.52,125.68 49.52,126.6 50.13,127.21 50.13,135 51.77,136.65 57.99,136.65 60.88,133.75 67.13,133.75 67.4,133.49 73.38,133.49 76.3,130.58 77.67,130.58 78.41,129.84 79.04,129.84 79.52,130.32 82.79,130.32 82.86,130.24 90.15,130.24 91.11,129.29 94.36,129.29 94.49,129.42 96.67,129.42 97.03,129.06 v1(97.03,128.97)
  BOTTOM w0.127: v1(97.03,128.97) 97.03,128.66 96.85,128.48 96.85,127.95 95.89,126.99 95.89,126.87 95.64,126.63 U53.4
PLL_LOCK2: length 36.5
  TOP w0.127: U15.46 v1(65,129.57)
  L8 w0.114: v1(65,129.57) 65,130.48 68.73,134.21 74.96,134.21 76.97,132.2 81.88,132.2 83.28,130.81 90.14,130.81 91.97,128.98 93.14,128.98 93.47,128.65 v1(93.47,128.54)
  BOTTOM w0.127: v1(93.47,128.54) 93.47,127.79 93.98,127.28 U53.5
PLL_LOCK3: length 27.5
  TOP w0.127: v1(92.66,110.54) 91.77,111.43 91.77,113.63 91.01,114.39 90.92,114.39 90.62,114.69 U19.46
  L5 w0.114: v1(92.66,110.54) 92.15,111.05 92.15,113.57 96.66,118.07 96.66,120.96 96.7,121 96.7,122.12 96.83,122.25 96.83,122.87 96.84,122.88 96.84,123.24 96.7,123.39 96.7,128.04 v1(96.39,128.35)
  BOTTOM w0.127: v1(96.39,128.35) 96.37,128.32 95.96,128.32 95.57,127.93 U53.6
PLLLOCK_LED: length 110.8
  L3 w0.114: v1(169.8,161.54) 170.12,161.87 170.12,170.28 167.95,172.45 157.77,172.45 156.53,173.69 146.6,173.69 146.22,173.31 143.19,173.31 141.66,171.79 135.83,171.79 134.5,170.45 125.33,170.45 124.42,171.37 109.39,171.37 108.58,170.56 108.58,168.15 107.69,167.26 107.69,166.27 107.41,165.98 106.42,165.98 106.11,165.67 v1(106.11,161.99)
  BOTTOM w0.127: v1(106.11,161.99) 105.69,161.58 105.69,152.07 107.52,150.24 U50.26 ; R504.1 174.47,155.03 174.94,155.51 174.94,158.63 173.96,159.61 169.96,159.61 169.53,160.04 169.53,161.28 v1(169.8,161.54)
PMBUS_ALERT: length 345.7
  TOP w0.127: v1(36.71,81.56) 36.7,81.56 36.17,82.09 35.12,82.09 34.63,82.58 32.44,82.58 32.38,82.53 U25.27 ; U7.40 156.96,138.45 156.66,138.15 156.66,134.56 154.89,132.79 149.71,132.79 148.89,131.97 148.89,131.95 148.34,131.39 148.34,130.56 PMBUS1.3 149.15,128.32 144.88,128.32 142.68,130.52 142.68,130.94 142.74,131.01 R179.1 ; v1(115.57,118.24) 115.57,117.16 R270.2 114.87,116.91 113.45,118.33 113.45,119.01 113.39,119.06 U16.27
  L3 w0.114: v1(129.24,115.14) 129.24,113.61 131.47,111.38 131.47,83.46 131.81,83.13 131.81,48.31 127.35,43.85 113.29,43.85 111.37,41.93 111.37,37.09 106.24,31.97 28.32,31.97 26.91,33.37 26.91,39.8 27.32,40.21 27.32,41.88 26.82,42.38 26.82,47.32 24.84,49.3 24.84,61.58 23.86,62.56 17.07,62.56 15.31,64.32 15.31,70.78 17.2,72.66 19.45,72.66 20.13,73.34 25.94,73.34 26.77,74.17 36.99,74.17 37.47,74.64 37.47,77.15 36.37,78.25 36.37,81.22 v1(36.71,81.56)
  BOTTOM w0.127: PMBUS1.3 151.38,127.51 151.38,123.03 148.49,120.14 145.57,120.14 141.76,116.33 130.43,116.33 v1(129.24,115.14) 128.04,116.33 117.47,116.33 v1(115.57,118.24)
PMBUS_CLK: length 313.6
  TOP w0.127: U13.8 130.16,121.27 131.28,120.15 132.87,120.15 133.02,120.3 v1(133.38,120.3) 133.38,119.99 R248.2 ; v1(35.52,75.22) 35.48,75.18 34.92,75.18 34.04,76.06 30.79,76.06 30.55,76.3 U25.15 ; v1(106.88,120.38) 106.88,120.38 106.88,120.38 106.9,120.38 106.9,121.12 106.99,121.21 U16.15
  L3 w0.114: v1(123.06,43.17) 123.07,43.17 123.19,43.05 127.38,43.05 133.9,49.58 133.9,82.83 132.14,84.6 132.14,110.93 133.53,112.33 133.53,120.15 v1(133.38,120.3)
  L8 w0.114: v1(24.51,35.05) 24.12,35.44 24.12,44.46 19.18,49.4 19.18,71.56 21,73.38 24.4,73.38 25.96,74.94 34.91,74.94 35.19,75.22 v1(35.52,75.22)
  L10 w0.114: v1(24.51,35.05) 26.04,33.53 108.84,33.53 110.16,34.85 110.16,41.91 112.14,43.89 122.35,43.89 123.06,43.18 v1(123.06,43.17)
  BOTTOM w0.127: PMBUS1.1 149.86,122.59 148.18,120.9 142.32,120.9 141.27,119.86 136.58,119.86 135.54,120.9 133.99,120.9 v1(133.38,120.3) 133.38,119.99 R248.2 133.68,119.12 133.68,117.84 132.93,117.09 118.39,117.09 116.28,119.2 115.52,119.96 107.77,119.96 107.35,120.38 106.88,120.38 v1(106.88,120.38)
PMBUS_CTL: length 24.9
  TOP w0.127: U7.41 157.46,138.53 156.91,137.99 156.91,134.29 153.53,130.9 150.53,130.9 PMBUS1.4 ; R162.1 140.84,132.45 140.64,132.26 v1(140.59,132.26)
  L8 w0.114: v1(140.59,132.26) 140.61,132.23 145.39,132.23 146.65,130.98 149.26,130.98 PMBUS1.4
PMBUS_DAT: length 318.4
  TOP w0.127: U25.16 34.02,76.78 v1(34.52,76.28) ; R249.2 134.62,119.71 134.09,120.24 v1(134.09,120.32) 133.66,120.75 132.93,120.75 132.71,120.53 131.44,120.53 130.66,121.31 U13.9 ; v1(106.93,119.75) 107.02,119.75 107.64,120.37 U16.16
  L3 w0.114: v1(134.09,120.32) 133.92,120.15 133.92,112.23 132.48,110.79 132.48,84.74 134.25,82.98 134.25,47.73 128.55,42.03 123.45,42.03 v1(122.32,43.16)
  L8 w0.114: v1(34.52,76.28) 33.52,75.29 25.82,75.29 24.26,73.73 20.86,73.73 18.44,71.31 18.44,49.66 23.78,44.32 23.78,35.02 v1(24.51,34.29)
  L10 w0.114: v1(122.32,43.16) 122.28,43.16 121.89,43.55 112.28,43.55 110.64,41.91 110.64,34.72 109.07,33.15 25.65,33.15 v1(24.51,34.29)
  BOTTOM w0.127: PMBUS1.2 151,125.35 151,123.19 148.34,120.52 142.6,120.52 141.55,119.48 136.42,119.48 135.38,120.52 134.29,120.52 v1(134.09,120.32) 134.09,120.24 134.62,119.71 R249.2 134.06,119.14 134.06,117.69 133.09,116.71 118.19,116.71 118.06,116.84 118.06,116.88 115.36,119.58 107.61,119.58 107.45,119.75 v1(106.93,119.75)
PW_SEQ_I2C_EN: length 61.9
  TOP w0.127: U22.5 129.99,108.2 131.34,109.55 132.82,109.55 v1(132.92,109.65) ; v1(142.24,149.68) 144.75,149.68 146.27,151.19 U7.5
  L5 w0.114: v1(132.92,109.65) 132.35,110.22 132.35,113.33 138.48,119.46 140.49,119.46 143.87,122.83 143.87,128.09 143.54,128.42 143.54,128.43 143.29,128.68 143.28,128.68 142.13,129.83 142.13,133.03 143.87,134.77 143.87,137.05 143.86,137.06 143.86,140.15 143.96,140.25 143.96,147.96 v1(142.24,149.68)
PW_SEQ_RSTZ: length 68.3
  TOP w0.127: v1(149.62,153.2) 149.11,152.69 U7.2 ; U13.3 127.66,121.01 v1(127.56,120.9) 127.28,120.62 127.03,120.62 126.11,119.71 C131.2
  L8 w0.114: v1(149.62,153.2) 151.47,153.2 151.71,152.96 153.53,152.96 156.12,150.37 156.12,146.98 157.52,145.59 157.52,140.88 153.68,137.05 153.65,137.05 153.39,136.79 153.39,136.75 150.88,134.24 150.88,133.48 150.11,132.72 149.72,132.72 148.27,131.27 146.7,131.27 145.49,132.47 140.99,132.47 140.77,132.7 140.41,132.7 140.11,132.39 140.11,131.47 139.85,131.22 139.85,130.25 139.07,129.47 138.38,129.47 137.82,128.91 137.06,128.91 136.73,128.57 135.36,128.57 134.95,128.99 134.14,128.99 133.1,127.94 133.1,123.44 130.56,120.9 127.56,120.9 v1(127.56,120.9)
  BOTTOM w0.127: v1(127.56,120.9) 127.28,120.62 127.03,120.62 C131.2
PW_SEQ_SCL: length 21.1
  TOP w0.127: U22.7 127.54,105.66 127.73,105.85 128.72,105.85 131.58,108.71 133.22,108.71 135.06,110.55 135.06,118.01 134.8,118.27 133.48,118.27 v1(133.1,117.89)
  BOTTOM w0.127: R580.1 v1(133.1,117.89)
PW_SEQ_SDA: length 17.7
  TOP w0.127: v1(134.62,117.82) 134.62,110.72 133.06,109.17 131.5,109.17 129.51,107.19 127.58,107.19 127.33,106.93 U22.6
  BOTTOM w0.127: R579.1 v1(134.62,117.82)
R_P0_LAN_RSTZ: length 8.7
  BOTTOM w0.102: 148.08,79.1 148.08,78.86 147.57,78.35 147.57,76.95 147.14,76.52 PHY1.K3
  BOTTOM w0.127: 148.08,79.1 148.08,79.38 147.83,79.63 147.83,81.33 147.74,81.42 147.74,83.4 R660.1
R_P1_LAN_RSTZ: length 8.6
  BOTTOM w0.102: 148.03,103.49 148.03,102.97 147.68,102.62 147.68,101.02 PHY2.K3
  BOTTOM w0.127: 148.03,103.49 147.74,103.78 147.74,107.79 R589.1
RADSYNC: length 112.6
  TOP w0.102: v2(59.99,72.01) 60.41,72.42 U24.AM30
  L10 w0.089: 60.58,104.01 v1(58.65,105.94)
  L10 w0.102: 60.58,104.01 60.58,103.84 63.42,101 63.42,83.47 62.4,82.44 62.4,81.05 61.52,80.16 61.52,74.03 61.54,74.01 61.54,73.55 v2(59.99,72.01) 60.4,71.61 60.4,70.77 60.17,70.54 60.02,70.54 59.31,69.83 59.31,69.77 58.11,68.58 55.55,68.58 53.26,66.29 52.76,66.29 52.7,66.24
  L10 w0.114: 52.7,66.24 49.73,63.27 49.73,62.31 47.36,59.93 43.23,59.93 41.27,57.98 35.83,57.98 33.41,55.55 24.51,55.55 CN17.6
  BOTTOM w0.102: R616.1 57.4,107.16 58.65,105.92 v1(58.65,105.94) ; AMC1.153 5.44,47.21 5.96,46.7 9.03,46.7 11.56,49.22 11.56,52.58 14.38,55.4 22.68,55.4 CN17.6
REFCK_N: length 20.8
  TOP w0.127: v1(54.19,135.88) 54.05,135.75 54.05,135.12 54.23,134.94 54.23,134.26
  L10 w0.114: v1(54.19,135.88) 54.18,135.88 53.99,135.69 53.99,134.71 54.36,134.34 54.79,134.34 59.18,134.34 59.53,133.99 59.53,126.67 59.97,126.23 60.43,126.23 60.79,125.86 60.79,124.97 60.17,124.35 v1(60.17,124.03)
  BOTTOM w0.127: v1(60.17,124.03) 60.17,124 59.75,123.58 C139.1
REFCK_N_C: length 4.7
  TOP w0.127: v1(61.29,123.32) R240.1 60.52,123.73 60.71,123.91 61.71,123.91 61.8,124.01 62.61,124.01 62.79,123.82 U15.9
  BOTTOM w0.127: C139.2 v1(61.29,123.32)
REFCK_P: length 20.4
  TOP w0.127: U14.29 53.73,135.05 53.8,135.12 53.8,135.66 53.57,135.88 v1(53.54,135.88)
  L10 w0.114: v1(53.54,135.88) 53.55,135.88 53.75,135.69 53.75,134.61 54.26,134.1 54.89,134.1 59.08,134.1 59.29,133.88 59.29,126.57 59.87,125.98 60.33,125.98 60.55,125.76 60.55,125.07 60.32,124.83 60.19,124.83 60.1,124.92 v1(60.1,125.35)
  BOTTOM w0.127: v1(60.1,125.35) 60.1,125.06 C138.1
REFCK_P_C: length 4.7
  TOP w0.127: v1(61.3,124.71) R239.1 60.52,124.35 60.71,124.17 61.61,124.17 61.7,124.26 62.61,124.26 62.68,124.32 U15.8
  BOTTOM w0.127: C138.2 v1(61.3,124.71)
REFCLK1_PD#: length 70.8
  TOP w0.127: v1(48.34,129.84) 49,130.51 U14.43 ; R815.1 100.4,129.09 99.95,129.54 98.32,129.54 v1(97.96,129.17)
  L10 w0.114: v1(48.34,129.84) 48.41,129.84 49.07,130.51 49.07,134.94 51.48,137.34 58.3,137.34 61.13,134.51 64.42,134.51 64.9,135 69.47,135 70.23,134.24 73.62,134.24 76.35,131.51 80.31,131.51 80.43,131.64 82.46,131.64 83.15,130.94 90.74,130.94 91.66,130.02 94.01,130.02 94.11,130.12 97.33,130.12 97.96,129.49 v1(97.96,129.17)
  BOTTOM w0.127: U53.1 95.81,124.68 96.9,125.77 96.9,126.57 97.96,127.62 v1(97.96,129.17)
REFCLK2_PD#: length 42.6
  TOP w0.127: v1(66.63,130.35) 66.5,130.22 U15.43
  L8 w0.114: v1(97.43,128.35) 97.28,128.35 96.58,127.64 92.7,127.64 92.27,128.07 91.52,128.07 89.71,129.88 82.92,129.88 82.44,130.35 79.3,130.35 78.51,131.14 76.67,131.14 74.46,133.35 69.63,133.35 v1(66.63,130.35)
  BOTTOM w0.127: U53.2 95.74,125.33 96.39,125.98 96.39,126.78 97.36,127.74 97.36,128.27 v1(97.43,128.35) ; v1(66.63,130.35) 66.63,130.8 66.63,130.8 R816.1
REFCLK3_PD#: length 17.6
  TOP w0.127: U19.43 89.12,114.46 89.47,114.11 v1(89.47,113.92) ; v1(93.51,124.62) 93.05,124.15 R817.1
  L5 w0.114: v1(93.51,124.62) 93.28,124.39 93.28,122.91 92.82,122.44 92.82,116.5 90.23,113.92 v1(89.47,113.92)
  BOTTOM w0.127: U53.3 93.98,125.98 93.51,125.52 v1(93.51,124.62)
RP1CLKN_C: length 10.5
  TOP w0.102: U24.AP2 58.35,100.42 57.84,100.94 v2(57.8,100.94)
  BOTTOM w0.102: v2(57.8,100.94) 57.49,101.24 57.49,102.43 55.91,104.01
  BOTTOM w0.127: 55.91,104.01 55.24,104.68 55.24,108.84 55.43,109.02 C499.2
RP1CLKP_C: length 10.5
  TOP w0.102: v2(56.92,100.97) 57,100.97 57.52,100.45 U24.AR2
  BOTTOM w0.102: 55.56,104.01 55.59,104.01 55.95,103.66 56.31,103.3 57.26,102.34 57.26,101.31 v2(56.92,100.97)
  BOTTOM w0.127: C500.2 54.73,109.02 54.99,108.76 54.99,104.58 55.56,104.01
RP1FBN: length 14.4
  TOP w0.102: C184.2 60.73,112.07 60.83,111.97 60.83,110.8 R319.2 60.73,110.17 60.83,110.07 60.83,109.8 R321.1 60.83,108.53 60.83,106.86 56.89,102.92 56.89,101.8 U24.AT1
RP1FBP: length 14.4
  TOP w0.102: U24.AR1 57.14,101.8 57.14,102.81 61.09,106.76 61.09,108.53 R308.1 61.09,109.8 61.09,110.05 61.21,110.17 R307.2 61.09,110.8 61.09,111.97 61.19,112.07 C170.2
RS232_RX: length 24.2
  BOTTOM w0.127: U56.8 153.93,114.62 154.71,115.39 157.74,115.39 159.38,117.04 159.38,120.04 160.15,120.8 160.15,128.4 157.86,130.68 MCU.4
RS232_TX: length 16
  BOTTOM w0.127: U56.13 156.54,117.02 157.34,116.22 158.03,116.22 159,117.2 159,120.19 159.66,120.85 159.66,126.39 MCU.3
RSV_CLKN: length 58.8
  TOP w0.102: CN3.110 33.6,159.2 v1(34.04,158.76) ; U14.22 56.97,132.51 57.53,133.07 57.53,136.09 58.47,137.03 58.47,138.63 v1(58.55,138.71)
  L10 w0.089: v1(58.55,138.71) 58.39,138.86 58.39,139.37 56.62,141.15 53.77,141.15 52.92,140.3 50.69,140.3 49.66,141.33 49.66,143.94 46.76,146.84 46.76,151.05 46.93,151.22 46.93,154.44 47.59,155.1 47.59,157.52 46.09,159.02 46.09,160.77 43.52,163.34 36.21,163.34 33.25,160.38 33.25,159.61 34.04,158.81 v1(34.04,158.76)
RSV_CLKP: length 58.4
  TOP w0.102: v1(34.29,159.35) 33.82,159.35 33.46,159.7 CN3.112 ; v1(57.63,138.66) 57.73,138.76 58.01,138.76 58.12,138.66 58.12,138.53 58.22,138.43 58.22,137.14 57.28,136.2 57.28,133.18 57.11,133.01 U14.23
  L10 w0.089: v1(57.63,138.66) 58.06,138.66 58.12,138.72 58.12,138.89 58.18,138.94 58.18,139.28 56.53,140.93 53.86,140.93 53.01,140.08 50.6,140.08 49.44,141.24 49.44,143.85 46.55,146.75 46.55,151.14 46.71,151.31 46.71,154.53 47.37,155.19 47.37,157.43 45.87,158.93 45.87,160.68 43.43,163.12 36.3,163.12 33.46,160.29 33.46,159.7 33.81,159.35 v1(34.29,159.35)
SIM_CLK: length 17.8
  TOP w0.127: v1(146.79,62.97) 146.79,63.9 146.08,64.6 145.15,64.6 144.53,63.99 U33.11 ; SIM1.C3 v1(153.29,54.84)
  BOTTOM w0.127: v1(146.79,62.97) 146.79,61.19 153.15,54.84 v1(153.29,54.84)
SIM_EN: length 17.1
  TOP w0.127: U33.1 144.03,58.31 145.21,57.12 147.96,57.12 150.19,54.9 150.19,52.87 150.99,52.07 151.96,52.07 C338.1 153.01,51.03 v1(153.29,51.03) SIM1.SW2
  BOTTOM w0.127: v1(153.29,51.03) 152.88,51.44 C338.1
SIM_IO: length 15
  TOP w0.127: U33.8 147.18,61.71 147.42,61.47 148.88,61.47 151.42,58.93 151.89,58.93 153.16,57.66 153.16,55.65 152.6,55.09 R408.1 152.6,53.91 152.94,53.57 SIM1.C7
SIM_RST: length 11.5
  TOP w0.127: U33.9 146.79,62.46 147.4,61.85 148.86,61.85 151.52,59.18 152.02,59.18 153.83,57.38 SIM1.C2
SIM_SEL: length 36.3
  TOP w0.127: U33.2 144.53,58.57 v1(144.52,58.57)
  BOTTOM w0.127: CN21.2 144.2,34.21 145.84,34.21 151.96,40.33 151.96,49.34 150.11,51.18 150.11,55.37 146.54,58.94 144.89,58.94 144.52,58.57 v1(144.52,58.57)
SIM_VCC: length 15.2
  TOP w0.254: U33.7 146.94,61.21 147.32,60.83 C329.1
  TOP w0.381: R408.2 v1(150.8,54.36) ; C329.1 147.76,59.51 148.59,58.67 v1(150.8,58.67)
  L8 w0.381: v1(150.8,58.67) v1(150.8,54.36)
  BOTTOM w0.381: v1(150.8,58.67) 152.15,58.67 152.81,59.33 v3(152.81,60.66)
SMB_SCL_IPMBL: length 270.6
  TOP w0.127: v1(8.38,74.75) 7.04,74.75 6.08,75.71 AMC1.56 ; U7.72 v1(165.04,151.69)
  L8 w0.114: v1(165.04,151.69) 164.66,151.69 159.64,156.71 159.64,157.25 158.45,158.45 158.45,164.08 156.04,166.48 156.04,169.34 150.63,174.75 147.03,174.75 146.57,175.21 145.18,175.21 144.31,176.08 76.8,176.08 58.17,157.45 47.14,157.45 46.48,158.12 45.69,158.12 45.05,157.48 45.05,153 44.97,152.92 44.97,150.99 46.74,149.22 46.74,141.23 49.66,138.31 49.66,129.49 47.1,126.93 45.92,126.93 45.49,126.5 45.49,126.17 43.17,123.86 43.17,123.33 42.68,122.84 42.68,120.43 39.61,117.35 39.61,116.65 37.24,114.27 34.05,114.27 31.36,111.59 31.36,105.17 31.57,104.97 31.57,98.06 24.07,90.56 13.7,90.56 11.04,93.22 7.94,93.22 6.53,91.82 6.53,76.31 8.09,74.75 v1(8.38,74.75)
  BOTTOM w0.127: R518.1 164.97,151.77 v1(165.04,151.69)
SMB_SDA_IPMBL: length 269.7
  TOP w0.127: AMC1.71 8.63,86.96 9.53,87.86 9.53,89.15 12.65,92.28 v1(12.65,92.27) ; U7.65 v1(165.21,148.19)
  L8 w0.114: v1(165.21,148.19) 165.94,148.92 165.94,154.47 167.94,156.46 167.94,162.11 165.21,164.85 160.46,164.85 157.85,167.45 157.85,171.69 155.08,174.46 152.16,174.46 149.86,176.76 76.51,176.76 58.9,159.16 51.79,159.16 50.9,158.26 49.94,158.26 49.39,158.81 45.41,158.81 44.32,157.72 44.32,157.39 42.54,155.61 42.54,153.54 41.02,152.02 41.02,147.95 39.82,146.74 39.49,146.74 39.24,146.49 39.24,146.12 39.49,145.87 41.73,145.87 42.34,145.25 43.06,145.25 43.36,144.96 43.95,144.96 44.4,145.41 45.05,145.41 46.4,144.06 46.4,141.09 48.55,138.94 48.55,137.4 49.32,136.63 49.32,129.63 46.96,127.27 45.78,127.27 45.14,126.64 45.14,126.31 43.01,124.17 42.78,124.17 42.28,123.67 42.28,120.51 39.27,117.5 39.27,116.79 37.09,114.62 33.91,114.62 31.02,111.73 31.02,105.03 31.22,104.83 31.22,102.62 19.5,90.9 14.02,90.9 v1(12.65,92.27)
  BOTTOM w0.127: v1(165.21,148.19) 164.72,147.7 R526.1
SOC_BOOTCOMPLETE: length 141.2
  TOP w0.102: v2(67.02,97.92) 66.52,97.42 U24.AF5
  L5 w0.114: v1(98.7,163.01) 98.21,162.52 92.74,162.52 91.35,161.12 61.2,161.12 61.2,161.13 61,161.13 60.8,161.13 54.33,161.13 53.38,160.17 50.06,160.17 48.51,158.62 46.19,158.62 45.36,157.79 45.36,154.76 44.72,154.11 44.72,153.24 45.26,152.69 46.24,152.69 46.7,152.23 46.7,151.23 46.01,150.55 46.01,148.2 48.81,145.41 48.81,143.27 48.98,143.09 48.98,143.09 50.14,141.93 50.14,140.82 50.55,140.4 51.17,140.4 51.77,139.8 51.77,139.16 53.14,137.79 55.08,137.79 55.55,137.33 57.1,137.33 60.66,133.77 61.8,133.77 63.26,132.31 63.26,131.7 62.72,131.16 62.72,130.28 63.54,129.46 63.54,123.11 60.49,120.06 60.49,110.5 60.49,109.42 60.71,109.21 60.71,104.01 62.23,102.49 64.14,102.49 64.52,102.11 64.52,98.68 64.77,98.43 66.51,98.43 v2(67.02,97.92)
  BOTTOM w0.127: v1(98.7,163.01) 99.15,162.56 99.95,162.56 102.5,160 U47.27
SOC_CORECLKSEL: length 135.2
  L5 w0.102: 57.78,104.01 59.94,101.85 59.94,101.09 v2(61.09,99.95)
  L5 w0.114: 57.78,104.01 57.45,104.34 57.45,107.87 59.79,110.21 59.79,120.35 62.8,123.36 62.8,129.21 61.96,130.05 61.96,130.89 56.22,136.63 52.93,136.63 52.46,137.1 50.26,139.29 50.26,139.71 49.44,140.53 49.44,141.64 48.29,142.8 48.29,142.8 48.11,142.98 48.11,144.77 45.31,147.56 45.31,150.07 44.39,150.99 44.39,151.81 43.98,152.22 43.82,152.22 43.49,152.54 43.49,154.09 44.67,155.27 44.67,158.13 47.77,161.24 52.86,161.24 53.82,162.2 90.11,162.2 91.22,163.32 97.1,163.32 97.69,163.91 100.3,163.91 v1(100.3,163.9)
  BOTTOM w0.102: R622.2 60.5,99.37 v2(61.09,99.95)
  BOTTOM w0.127: v1(100.3,163.9) 100.76,163.45 102.49,163.45 102.94,163.9 U47.21
SOC_CORESEL0: length 98.8
  TOP w0.102: U24.F24 v2(87.02,77.92)
  L5 w0.102: 93.18,80.03 92.53,79.38 92.53,78.86 92.18,78.51 87.61,78.51 v2(87.02,77.92)
  L5 w0.114: 93.18,80.03 96.63,83.48 96.63,100.92 102.88,107.16 102.88,111.26 98.8,115.34 98.8,120.9 101.53,123.63 101.53,131.88 99.78,133.63 99.5,133.63 97.9,135.23 97.9,136.03 94.31,139.62 94.31,155.08 v1(97.16,157.92)
  BOTTOM w0.127: U47.1 96.63,158.52 97.16,157.99 v1(97.16,157.92)
SOC_CORESEL1: length 95
  TOP w0.102: U24.E24 v2(88.02,78.92)
  L5 w0.102: 93.18,80.55 92.01,79.38 88.47,79.38 v2(88.02,78.92)
  L5 w0.114: v1(97.79,157.99) 97.42,158.36 96.97,158.36 93.98,155.37 93.98,139.36 95.95,137.39 95.95,135.83 100.01,131.77 100.01,128.17 99.6,127.76 99.6,126.87 99.63,126.84 99.63,123.42 96.9,120.7 96.9,117.68 95.81,116.59 95.81,83.18 93.18,80.55
  BOTTOM w0.127: v1(97.79,157.99) 97.79,159.77 97.56,160 U47.2
SOC_CORESEL2: length 99.7
  TOP w0.102: U24.D24 v2(89.02,77.92)
  L5 w0.102: 93.18,79.57 92.74,79.12 92.74,78.78 92.26,78.3 89.4,78.3 v2(89.02,77.92)
  L5 w0.114: v1(98.43,157.99) 94.59,154.15 94.59,139.68 98.14,136.13 98.14,135.33 99.6,133.87 99.88,133.87 101.77,131.98 101.77,123.45 99.11,120.79 99.11,115.37 103.12,111.36 103.12,107.06 96.94,100.88 96.94,83.32 93.18,79.57
  BOTTOM w0.127: U47.3 97.41,160.65 98.43,159.64 v1(98.43,157.99)
SOC_CORESEL3: length 104.2
  TOP w0.102: U24.G24 v2(86.02,77.92)
  L5 w0.102: v2(86.02,77.92) 86.4,77.54 91.79,77.54 93.18,78.94 93.18,78.96
  L5 w0.114: 93.18,78.96 97.27,83.05 97.27,100.87 103.36,106.96 103.36,111.46 99.35,115.47 99.35,120.69 102.01,123.35 102.01,132.08 99.98,134.11 99.7,134.11 98.38,135.43 98.38,136.23 95,139.61 95,153.87 99.06,157.92 v1(99.06,158.04)
  BOTTOM w0.127: v1(99.06,158.04) 99.06,159.77 97.53,161.3 U47.4
SOC_DDR3A_EA0: length 59.8
  TOP w0.102: U24.E8 87.52,94.35 v2(87.93,93.93)
  TOP w0.127: DIMM1.107 115.26,76.15 116.04,76.92 116.86,76.92 v1(117.32,77.38)
  L3 w0.102: 90.7,95.33 88.67,95.33 88.47,95.12 88.47,94.46 v2(87.93,93.93)
  L3 w0.114: 90.7,95.33 99.94,95.33 100.05,95.44 100.05,96.01 100.16,96.13 109.04,96.13 116.31,88.86 118.64,88.86 121.13,86.37 121.13,81.3 121.01,81.19 120.82,81.19 120.68,81.05 120.68,80.81 120.76,80.73 121.04,80.73 121.13,80.65 121.13,79.94 121.01,79.82 120.48,79.82 120.39,79.73 120.39,79.46 120.48,79.37 121.04,79.37 121.13,79.28 121.13,78.95 121.04,78.87 120.59,78.87 120.47,78.75 120.47,78.17 120.36,78.05 119.31,78.05 119.19,77.94 119.19,77.48 119.1,77.4 118.82,77.4 118.73,77.48 118.73,78.14 118.64,78.24 118.35,78.24 118.24,78.12 118.24,77.95 118.12,77.83 117.29,77.83 117.2,77.74 117.2,77.49 117.31,77.38 v1(117.32,77.38)
SOC_DDR3A_EA1: length 59.9
  TOP w0.102: U24.G9 85.74,93.42 v2(86.05,93.11)
  TOP w0.127: v1(116.66,77.4) 115.71,77.4 115.05,76.75 DIMM1.105
  L3 w0.102: v2(86.05,93.11) 86.63,92.53 90.09,92.53
  L3 w0.114: v1(116.66,77.4) 116.66,78.09 116.42,78.32 116.42,78.81 116.3,78.92 116.04,78.92 115.93,79.04 115.93,79.26 116.04,79.38 116.3,79.38 116.42,79.49 116.42,79.72 116.3,79.84 116.04,79.84 115.93,79.95 115.93,80.18 116.04,80.29 116.3,80.29 116.42,80.41 116.42,81.98 115.82,82.58 115.82,83.32 115.73,83.42 115.43,83.42 115.33,83.32 115.33,82.59 115.22,82.47 114.99,82.47 114.87,82.59 114.87,83.14 112.19,85.83 111.02,85.83 106.86,89.99 106.34,89.99 106.22,89.88 106.22,89.47 106.11,89.36 105.88,89.36 105.76,89.47 105.76,89.88 105.65,89.99 105.42,89.99 105.31,89.88 105.31,89.47 105.19,89.36 104.96,89.36 104.85,89.47 104.85,89.88 104.74,89.99 104.51,89.99 104.39,89.88 104.39,89.47 104.28,89.36 104.05,89.36 103.94,89.47 103.94,89.88 103.82,89.99 103.59,89.99 103.48,89.88 103.48,89.47 103.36,89.36 103.14,89.36 103.02,89.47 103.02,89.88 102.91,89.99 102.68,89.99 102.56,89.88 102.56,89.47 102.45,89.36 102.22,89.36 102.11,89.47 102.11,89.88 101.99,89.99 101.76,89.99 101.65,89.88 101.65,89.47 101.54,89.36 101.31,89.36 101.19,89.47 101.19,89.88 101.08,89.99 100.85,89.99 100.74,89.88 100.74,89.47 100.62,89.36 100.39,89.36 100.28,89.47 100.28,89.88 100.16,89.99 99.94,89.99 99.82,89.88 99.82,89.47 99.71,89.36 99.48,89.36 99.36,89.47 99.36,89.88 99.25,89.99 99.02,89.99 98.91,89.88 98.91,89.47 98.79,89.36 98.56,89.36 98.45,89.47 98.45,89.88 98.33,89.99 98.11,89.99 97.99,89.88 97.99,89.47 97.88,89.36 97.65,89.36 97.53,89.47 97.53,89.88 97.42,89.99 97.19,89.99 97.08,89.88 97.08,89.47 96.96,89.36 96.73,89.36 96.62,89.47 96.62,89.88 96.51,89.99 96.28,89.99 96.16,89.88 96.16,89.47 96.05,89.36 95.82,89.36 95.71,89.47 95.71,89.88 95.59,89.99 95.36,89.99 95.25,89.88 95.25,89.6 95.13,89.48 94.91,89.48 94.79,89.6 94.79,89.88 94.68,89.99 94.36,89.99 93.49,90.86 92.98,90.86 92.11,91.72 91.08,91.72 90.27,92.53 90.09,92.53
SOC_DDR3A_EA2: length 59.8
  TOP w0.102: v2(86.02,93.92) 85.52,94.42 U24.G8
  TOP w0.127: DIMM1.106 v1(119.7,76.45)
  L3 w0.102: 90.42,96.52 87.83,96.52 86.41,95.1 86.41,94.32 v2(86.02,93.92)
  L3 w0.114: v1(119.7,76.45) 120.6,76.45 122.33,78.17 122.33,86.54 122.33,86.87 119.14,90.06 116.81,90.06 112.14,94.72 112.14,95.83 110.52,97.46 100.46,97.46 100.08,97.84 99.36,97.84 98.98,97.46 95.5,97.46 95.34,97.63 95.34,97.66 95.21,97.79 95.01,97.79 94.88,97.66 94.88,97.57 94.77,97.46 94.54,97.46 94.42,97.57 94.42,98.03 94.31,98.15 94.08,98.15 93.97,98.03 93.97,97.57 93.85,97.46 93.39,97.46 92.45,96.52 90.42,96.52
SOC_DDR3A_EA3: length 60.6
  TOP w0.102: v2(86.02,91.92) 85.52,92.42 U24.G10
  TOP w0.127: v1(115.3,78.09) 114.56,77.35 DIMM1.103
  L8 w0.102: 86.92,94.41 86.46,93.95 86.46,92.37 v2(86.02,91.92)
  L8 w0.114: v1(115.3,78.09) 116.22,79 120.76,79 122.36,80.61 122.36,90.24 120.39,92.21 118.25,92.21 117.47,93 103.81,93 102.7,94.11 92.63,94.11 92.33,94.41 86.92,94.41
SOC_DDR3A_EA4: length 60.1
  TOP w0.102: U24.F9 86.66,93.42 v2(87.05,93.03)
  TOP w0.127: DIMM1.104 120.47,77.05 v1(120.06,77.45)
  L3 w0.102: v2(87.05,93.03) 87.46,93.44 87.46,94.98 88.01,95.53 90.47,95.53 90.68,95.73
  L3 w0.114: v1(120.06,77.45) 120.44,77.45 121.53,78.54 121.53,86.54 118.8,89.26 116.47,89.26 109.21,96.53 99.75,96.53 99.63,96.41 99.63,95.87 99.52,95.76 99.29,95.76 99.18,95.87 99.18,96.41 99.06,96.53 98.83,96.53 98.72,96.41 98.72,95.87 98.6,95.76 98.37,95.76 98.26,95.87 98.26,96.41 98.15,96.53 97.92,96.53 97.8,96.41 97.8,95.87 97.69,95.76 97.46,95.76 97.35,95.87 97.35,96.41 97.23,96.53 97,96.53 96.89,96.41 96.89,95.87 96.77,95.76 96.55,95.76 96.43,95.87 96.43,96.41 96.32,96.53 96.09,96.53 95.97,96.41 95.97,95.87 95.86,95.76 95.63,95.76 95.52,95.87 95.52,96.41 95.4,96.53 95.17,96.53 95.06,96.41 95.06,95.85 94.95,95.73 90.68,95.73
SOC_DDR3A_EA5: length 60.4
  TOP w0.102: v2(87.02,93.93) 87.02,93.92 86.52,94.42 U24.F8
  TOP w0.127: v1(117.98,77.35) 116.78,78.55 DIMM1.99
  L3 w0.102: v2(87.02,93.93) 87.02,93.92 86.64,94.3 86.64,95.02 87.93,96.32 90.25,96.32 90.4,96.16
  L3 w0.114: v1(117.98,77.35) 118.33,77 120.57,77 121.93,78.35 121.93,86.7 118.97,89.66 116.64,89.66 109.37,96.93 93.42,96.93 92.66,96.16 90.4,96.16
SOC_DDR3A_EA6: length 59.9
  TOP w0.102: v2(89.05,94.02) 89.05,93.89 U24.C9
  TOP w0.127: DIMM1.100 120.27,78.25 v1(120,78.52)
  L3 w0.102: 90.91,93.53 89.55,93.53 v2(89.05,94.02)
  L3 w0.114: 90.91,93.53 101.71,93.53 101.83,93.64 101.83,95.21 101.94,95.33 102.17,95.33 102.29,95.21 102.29,93.64 102.4,93.52 102.63,93.52 102.74,93.64 102.74,95.21 102.86,95.33 103.09,95.33 103.2,95.21 103.2,93.64 103.31,93.52 103.54,93.52 103.66,93.64 103.66,95.21 103.77,95.33 104,95.33 104.11,95.21 104.11,93.64 104.23,93.52 104.46,93.52 104.57,93.64 104.57,95.21 104.69,95.33 104.91,95.33 105.03,95.21 105.03,93.64 105.14,93.52 105.37,93.52 105.49,93.64 105.49,95.21 105.6,95.33 107.75,95.33 111.53,91.55 112.48,91.55 115.42,88.62 115.42,87.48 115.67,87.22 117.17,87.22 119.91,84.49 119.91,82.33 119.82,82.25 119.82,80.15 119.99,79.98 119.99,78.53 v1(120,78.52)
SOC_DDR3A_EA7: length 59.9
  TOP w0.102: U24.D9 88.56,93.42 v2(89.05,92.94)
  TOP w0.127: v1(118.81,79.64) 119.26,79.18 120.11,79.18 120.44,78.85 DIMM1.98
  L3 w0.102: 90.73,93.32 89.43,93.32 v2(89.05,92.94)
  L3 w0.114: v1(118.81,79.64) 118.81,79.26 118.92,79.15 119.42,79.15 119.53,79.03 119.53,78.75 119.42,78.64 118.2,78.64 118.08,78.75 118.08,80.78 118.2,80.9 118.88,80.9 118.99,81.01 118.99,81.34 118.88,81.45 118.31,81.45 117.99,81.77 117.99,82.74 117.58,83.14 117.58,84.75 117.16,85.18 114.52,85.18 114.19,85.18 114.19,85.18 113.97,85.18 113.61,85.54 113.61,86.43 113.49,86.55 112.71,86.55 112.6,86.66 112.6,86.89 112.71,87 113.49,87 113.61,87.12 113.61,87.47 113.5,87.58 111.93,87.58 111.81,87.69 111.81,88.99 111.73,89.07 111.36,89.07 111.25,88.95 111.25,88.61 111.13,88.49 110.91,88.49 110.79,88.61 110.79,88.95 110.68,89.07 110.08,89.07 107.45,91.69 99.37,91.69 99.25,91.58 99.25,90.94 99.14,90.83 98.91,90.83 98.79,90.94 98.79,91.63 98.68,91.74 98.45,91.74 98.34,91.63 98.34,90.94 98.22,90.83 97.99,90.83 97.88,90.94 97.88,91.66 97.77,91.77 97.54,91.77 97.42,91.66 97.42,90.94 97.31,90.83 97.08,90.83 96.97,90.94 96.97,91.66 96.85,91.77 96.62,91.77 96.51,91.66 96.51,90.94 96.39,90.83 96.17,90.83 96.05,90.94 96.05,91.66 95.94,91.77 95.71,91.77 95.59,91.66 95.59,90.94 95.48,90.83 95.25,90.83 95.14,90.94 95.14,91.58 95.02,91.69 94.79,91.69 94.68,91.58 94.68,91.35 94.57,91.24 94.34,91.24 94.22,91.35 94.22,91.58 94.11,91.69 93.27,91.69 92.58,92.38 91.67,92.38 90.73,93.32
SOC_DDR3A_EA8: length 59.9
  TOP w0.102: U24.B9 v2(90.02,92.92)
  TOP w0.127: v1(116.98,80.12) 116,79.15 DIMM1.97
  L3 w0.114: v1(116.98,80.12) 116.98,78.35 117.09,78.23 117.54,78.23 117.65,78.35 117.65,80.39 117.18,80.86 117.18,82.82 117.07,82.93 116.57,82.93 116.46,83.04 116.46,83.27 116.57,83.39 117.07,83.39 117.18,83.5 117.18,84.59 117.04,84.73 116.84,84.73 116.73,84.62 116.73,83.93 116.61,83.82 114.76,83.82 108.18,90.4 107.51,90.4 107.4,90.51 107.4,91.18 107.28,91.29 107.06,91.29 106.94,91.18 106.94,90.56 106.83,90.45 106.62,90.45 106.51,90.56 106.51,91.18 106.4,91.29 106.17,91.29 106.05,91.18 106.05,90.54 105.94,90.42 105.68,90.42 105.6,90.51 105.6,91.18 105.48,91.29 105.23,91.29 105.14,91.21 105.14,90.54 105.02,90.42 104.77,90.42 104.68,90.51 104.68,91.18 104.57,91.29 104.31,91.29 104.22,91.21 104.22,90.54 104.11,90.42 103.86,90.42 103.77,90.51 103.77,91.18 103.65,91.29 103.4,91.29 103.31,91.21 103.31,90.54 103.19,90.42 102.94,90.42 102.85,90.51 102.85,91.18 102.74,91.29 102.48,91.29 102.39,91.21 102.39,90.54 102.28,90.42 102.03,90.42 101.94,90.51 101.94,91.18 101.82,91.29 101.57,91.29 101.48,91.21 101.48,90.54 101.37,90.42 101.11,90.42 101.02,90.51 101.02,91.18 100.91,91.29 100.65,91.29 100.57,91.21 100.57,90.54 100.45,90.42 100.2,90.42 100.11,90.51 100.11,91.18 99.99,91.29 99.76,91.29 99.65,91.19 99.65,90.78 99.64,90.77 99.64,90.54 99.53,90.43 94.58,90.43 93.71,91.29 93.1,91.29 92.33,92.06 91.35,92.06 90.49,92.92 v2(90.02,92.92)
SOC_DDR3A_EA9: length 59.8
  TOP w0.102: U24.D8 88.66,94.42 v2(89.08,94.84)
  TOP w0.127: v1(120.28,80.35) 120.28,80.45 120.48,80.65 DIMM1.92
  L3 w0.114: v2(89.08,94.84) 89.58,94.34 93.21,94.34 93.29,94.26 93.29,94.02 93.38,93.93 94.45,93.93 94.54,94.02 94.54,94.81 94.65,94.93 94.95,94.93 95.06,94.81 95.06,94.04 95.17,93.93 95.4,93.93 95.52,94.04 95.52,94.81 95.63,94.93 95.86,94.93 95.97,94.81 95.97,94.02 96.06,93.93 96.34,93.93 96.43,94.02 96.43,94.81 96.55,94.93 96.77,94.93 96.89,94.81 96.89,94.02 96.98,93.93 97.26,93.93 97.35,94.02 97.35,94.81 97.46,94.93 97.69,94.93 97.8,94.81 97.8,94.04 97.92,93.93 98.15,93.93 98.26,94.04 98.26,94.81 98.37,94.93 98.6,94.93 98.72,94.81 98.72,94.07 98.83,93.95 99.06,93.95 99.17,94.07 99.17,94.81 99.29,94.93 99.52,94.93 99.63,94.81 99.63,94.02 99.72,93.93 100.36,93.93 100.45,94.02 100.45,95.62 100.56,95.73 100.85,95.73 100.96,95.62 100.96,94.04 101.02,93.98 101.35,93.98 101.42,94.04 101.42,95.61 101.53,95.73 107.92,95.73 111.7,91.95 112.65,91.95 116.14,88.46 118.47,88.46 120.73,86.2 120.73,81.66 120.28,81.21 v1(120.28,80.35)
SOC_DDR3A_EA10: length 59.7
  TOP w0.102: U24.F10 86.52,92.42 86.99,91.95 v2(87.07,91.95)
  TOP w0.127: v1(115.58,73.82) 115.58,73.62 115.11,73.15 DIMM1.117
  L3 w0.102: 89.51,91.97 89.18,92.3 87.43,92.3 v2(87.07,91.95)
  L3 w0.114: 89.51,91.97 89.51,89.79 89.84,89.46 92.25,89.46 94.98,86.73 95.86,86.73 95.98,86.61 95.98,86.22 96.09,86.11 96.32,86.11 96.43,86.22 96.43,86.63 96.54,86.73 96.79,86.73 96.89,86.63 96.89,86.22 97.01,86.11 97.23,86.11 97.35,86.22 97.35,86.63 97.45,86.73 97.7,86.73 97.81,86.63 97.81,86.22 97.92,86.11 98.15,86.11 98.26,86.22 98.26,86.63 98.36,86.73 98.62,86.73 98.72,86.63 98.72,86.22 98.83,86.11 99.06,86.11 99.18,86.22 99.18,86.61 99.29,86.73 99.52,86.73 99.63,86.61 99.63,86.22 99.75,86.11 99.98,86.11 100.09,86.22 100.09,86.61 100.21,86.73 100.43,86.73 100.55,86.61 100.55,86.22 100.66,86.11 100.89,86.11 101.01,86.22 101.01,86.61 101.12,86.73 101.35,86.73 101.46,86.61 101.46,86.22 101.58,86.11 101.81,86.11 101.92,86.22 101.92,86.61 102.04,86.73 102.26,86.73 102.38,86.61 102.38,86.22 102.49,86.11 102.72,86.11 102.84,86.22 102.84,86.61 102.95,86.73 103.18,86.73 103.29,86.61 103.29,86.22 103.41,86.11 103.64,86.11 103.75,86.22 103.75,86.61 103.86,86.73 104.09,86.73 104.21,86.61 104.21,86.22 104.32,86.11 104.55,86.11 104.66,86.22 104.66,86.61 104.78,86.73 105.01,86.73 105.12,86.61 105.12,86.22 105.24,86.11 105.46,86.11 105.58,86.22 105.58,86.61 105.69,86.73 105.92,86.73 106.04,86.61 106.04,86.22 106.15,86.11 106.38,86.11 106.49,86.22 106.49,86.61 106.61,86.73 106.84,86.73 106.95,86.61 106.95,86.22 107.06,86.11 107.29,86.11 107.41,86.22 107.41,86.61 107.52,86.73 107.75,86.73 107.97,86.51 107.97,86.17 108.08,86.05 108.42,86.05 108.53,85.94 108.53,85.71 108.42,85.59 108.08,85.59 107.97,85.48 107.97,85.26 108.29,84.94 108.67,84.94 108.79,85.05 108.79,85.21 108.9,85.32 109.13,85.32 109.25,85.21 109.25,85.05 109.36,84.94 109.54,84.94 109.7,84.77 109.7,84.54 109.59,84.43 109.28,84.43 109.16,84.32 109.16,83.62 109.45,83.33 109.89,83.33 114.25,78.98 114.25,74.83 115.26,73.82 v1(115.58,73.82)
SOC_DDR3A_EA11: length 59.9
  TOP w0.102: U24.A9 91.52,93.42 91.58,93.36 v2(92.02,92.92)
  TOP w0.127: v1(119.44,79.64) 120.36,79.64 120.55,79.45 DIMM1.96
  L3 w0.114: v1(119.44,79.64) 119.39,79.69 119.39,82.92 118.39,83.92 118.39,85.43 117.85,85.98 114.56,85.98 114.41,86.13 114.41,89.06 112.32,91.15 111.7,91.15 111.69,91.15 111.4,91.15 111.29,91.04 111.29,90 111.17,89.89 110.95,89.89 110.83,90 110.83,91.2 110.72,91.31 110.49,91.31 110.37,91.2 110.37,90.34 110.26,90.22 110.06,90.22 109.92,90.36 109.92,91.04 109.8,91.15 109.49,91.15 109.37,91.27 109.37,91.6 109.49,91.71 110.35,91.71 110.46,91.83 110.46,92.05 110.34,92.17 109.74,92.17 109.63,92.29 109.63,92.67 109.51,92.79 109.21,92.79 109.1,92.67 109.1,91.86 108.98,91.74 108.75,91.74 108.64,91.86 108.64,92.54 108.53,92.66 108.3,92.66 108.19,92.77 108.19,93.06 108.3,93.18 108.88,93.18 108.99,93.29 108.99,93.52 108.88,93.63 108.3,93.63 108.19,93.75 108.19,94.33 108.05,94.46 107.84,94.46 107.73,94.35 107.73,93.26 107.61,93.14 107.39,93.14 107.27,93.26 107.27,94.81 107.16,94.92 106.93,94.92 106.81,94.81 106.81,93.26 106.7,93.14 106.47,93.14 106.36,93.26 106.36,94.83 106.26,94.93 105.99,94.93 105.9,94.83 105.9,93.31 105.71,93.12 104.06,93.12 104.06,93.13 103.72,93.13 103.71,93.12 103.15,93.12 103.14,93.13 102.8,93.13 102.79,93.12 102.23,93.12 102.23,93.13 92.22,93.13 v2(92.02,92.92)
SOC_DDR3A_EA12: length 59.8
  TOP w0.102: v2(87.94,91.87) 87.94,92 87.52,92.42 U24.E10
  TOP w0.127: v1(115.73,80.93) 115.73,80.88 114.6,79.75 DIMM1.95
  L8 w0.102: v2(87.94,91.87) 87.55,92.26 87.55,93.04 87.83,93.32 93.16,93.32 93.18,93.29
  L8 w0.114: 93.18,93.29 101.8,93.29 103.75,91.35 118.15,91.35 121.35,88.15 121.35,81.7 120.86,81.21 117.82,81.21 117.71,81.33 117.71,82.84 117.6,82.96 117.37,82.96 117.25,82.84 117.25,81.33 117.14,81.21 116.91,81.21 116.8,81.33 116.8,82.89 116.68,83.01 116.45,83.01 116.34,82.89 116.34,81.33 116.22,81.21 116.04,81.21 115.73,80.91 v1(115.73,80.93)
SOC_DDR3A_EA13: length 59.9
  TOP w0.127: v2(93.7,94.54) 93.7,94.05 92.07,92.42 U24.A10 ; v1(119.58,69.86) 120.19,69.25 DIMM1.130
  L8 w0.114: v2(93.7,94.54) 103.07,94.54 104.21,93.4 114.05,93.4 114.64,93.99 118.61,93.99 119.04,93.56 120.54,93.56 122.82,91.28 122.82,72.25 120.43,69.86 v1(119.58,69.86)
SOC_DDR3A_EA14: length 59.8
  TOP w0.127: v1(118.43,81.95) 119.13,81.25 DIMM1.90 ; v2(93.47,92.18) 93.32,92.02 90.92,92.02 U24.B10
  L3 w0.114: v1(118.43,81.95) 118.8,81.95 118.99,82.15 118.99,82.75 118.81,82.93 118.36,82.93 117.98,83.31 117.98,85.28 117.68,85.58 114.35,85.58 114.01,85.93 114.01,87.98 113.89,88.1 112.48,88.1 112.37,88.21 112.37,88.44 112.48,88.56 113.89,88.56 114.01,88.67 114.01,88.9 113.88,89.03 112.38,89.03 112.27,89.14 112.27,89.38 112.38,89.5 112.94,89.5 113.06,89.61 113.06,89.84 112.94,89.96 112.38,89.96 112.27,90.07 112.27,90.56 112.15,90.68 111.8,90.68 111.69,90.56 111.69,89.58 111.57,89.47 110.25,89.47 107.62,92.09 107.07,92.09 106.96,92.21 106.96,92.6 106.85,92.71 106.58,92.71 106.47,92.6 106.47,92.27 106.35,92.15 106.12,92.15 106.01,92.27 106.01,92.6 105.9,92.71 105.67,92.71 105.55,92.6 105.55,92.27 105.44,92.15 105.21,92.15 105.1,92.27 105.1,92.6 104.98,92.71 104.75,92.71 104.64,92.6 104.64,92.27 104.52,92.15 104.3,92.15 104.18,92.27 104.18,92.6 104.07,92.71 103.84,92.71 103.72,92.6 103.72,92.27 103.61,92.15 103.38,92.15 103.27,92.27 103.27,92.6 103.15,92.71 102.92,92.71 102.81,92.6 102.81,92.27 102.7,92.15 102.47,92.15 102.35,92.27 102.35,92.6 102.24,92.71 102.01,92.71 101.9,92.6 101.9,92.27 101.78,92.15 101.55,92.15 101.44,92.27 101.44,92.6 101.32,92.71 101.1,92.71 100.98,92.6 100.98,92.27 100.87,92.15 100.64,92.15 100.52,92.27 100.52,92.6 100.41,92.71 100.18,92.71 100.07,92.6 100.07,92.27 99.95,92.15 99.72,92.15 99.61,92.27 99.61,92.6 99.5,92.71 99.27,92.71 99.15,92.6 99.15,92.27 99.04,92.15 98.81,92.15 98.7,92.27 98.7,92.6 98.58,92.71 98.35,92.71 98.24,92.6 98.24,92.27 98.12,92.15 97.89,92.15 97.78,92.27 97.78,92.6 97.67,92.71 97.44,92.71 97.32,92.6 97.32,92.27 97.21,92.15 96.98,92.15 96.87,92.27 96.87,92.6 96.75,92.71 96.52,92.71 96.41,92.6 96.41,92.27 96.29,92.15 96.07,92.15 95.95,92.27 95.95,92.6 95.84,92.71 95.61,92.71 95.49,92.6 95.49,92.27 95.38,92.15 95.15,92.15 95.04,92.27 95.04,92.6 94.92,92.71 94.69,92.71 94.58,92.6 94.58,92.27 94.47,92.15 94.24,92.15 94.12,92.27 94.12,92.6 94.01,92.71 93.59,92.71 93.47,92.6 v2(93.47,92.18)
