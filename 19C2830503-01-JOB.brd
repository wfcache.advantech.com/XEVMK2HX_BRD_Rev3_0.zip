# Allegro board 19C2830503-01-JOB.brd (continued)
## Nets (continued)
GND: AMC1.1(GND_1) AMC1.7(GND_2) AMC1.10(GND_3) AMC1.13(GND_4) AMC1.16(GND_5) AMC1.19(GND_6) AMC1.22(GND_7) AMC1.25(GND_8) AMC1.28(GND_9) AMC1.31(GND_10) AMC1.34(GND_11) AMC1.37(GND_12) AMC1.40(GND_13) AMC1.43(GND_14) AMC1.46(GND_15) AMC1.49(GND_16) AMC1.52(GND_17) AMC1.55(GND_18) AMC1.58(GND_19) AMC1.61(GND_20) AMC1.64(GND_21) AMC1.67(GND_22) AMC1.70(GND_23) AMC1.73(GND_24) AMC1.76(GND_25) AMC1.79(GND_26) AMC1.82(GND_27) AMC1.85(GND_28) AMC1.86(GND_29) AMC1.89(GND_30) AMC1.92(GND_31) AMC1.95(GND_32) AMC1.98(GND_33) AMC1.101(GND_34) AMC1.104(GND_35) AMC1.107(GND_36) AMC1.110(GND_37) AMC1.113(GND_38) AMC1.116(GND_39) AMC1.119(GND_40) AMC1.122(GND_41) AMC1.125(GND_42) AMC1.128(GND_43) AMC1.131(GND_44) AMC1.134(GND_45) AMC1.137(GND_46) AMC1.140(GND_47) AMC1.143(GND_48) AMC1.146(GND_49) AMC1.149(GND_50) AMC1.152(GND_51) AMC1.155(GND_52) AMC1.158(GND_53) AMC1.161(GND_54) AMC1.164(GND_55) AMC1.170(GND_56) ATT.1 B4.1 B8.2 B9.2(GND) B10.2(GND) B11.2(GND) B12.2(GND) B13.2(GND) B14.2(GND) B15.2(GND) B23.2(GND) B25.2(GND) B28.2(GND) B29.2(GND) B31.2(GND) B39.2(GND) B44.2(GND) B47.2(GND) C1.2 C2.2 C3.2 C4.2 C5.2 C6.2 C7.2 C8.2 C9.2 C10.2 C11.2 C12.2 C14.2 C15.2 C16.2 C17.2 C18.2 C19.2 C20.2 C21.2 C23.2 C24.2 C25.2 C26.2 C27.2 C28.1 C29.2 C30.2 C31.2 C32.2 C33.1 C34.1 C35.1 C36.2 C37.2 C38.1 C39.2 C40.1 C41.2 C42.2 C43.1 C44.2 C45.1 C46.2 C47.2 C48.1 C49.2 C52.2 C53.2 C54.2 C55.1 C56.2 C57.2 C58.2 C59.2 C61.1 C62.1 C64.2 C65.2 C66.2 C67.1 C68.2 C69.2 C70.2 C71.1 C72.2 C73.2 C74.1 C75.2 C76.2 C77.2 C78.2 C79.1 C80.2 C85.2 C86.1 C87.1 C88.2 C89.1 C90.2 C91.2 C92.2 C93.2 C94.1 C95.1 C96.2 C97.2 C98.2 C99.2 C100.2 C101.1 C102.1 C103.2 C104.2 C105.2 C106.2 C107.1 C109.2 C110.2 C111.2 C112.2 C114.2 C115.2 C116.2 C117.2 C118.2 C119.2 C120.2 C123.2 C124.1 C125.2 C126.2 C127.1 C130.1 C131.1 C132.2 C133.2 C134.2 C135.1 C136.2 C137.2 C140.2 C143.2 C144.2 C145.2 C146.1 C148.2 C150.2 C151.2 C152.2 C153.2 C155.2 C156.2 C157.2 C158.2 C159.2 C160.1 C161.1 C162.1 C163.2 C164.1 C165.2 C168.2 C171.2 C172.2 C173.2 C180.1 C181.1 C183.2 C185.2 C186.2 C188.2 C189.2 C192.2 C193.2 C194.2 C195.2 C196.2 C197.2 C198.2 C201.1 C202.2 C204.2 C205.1 C206.2 C207.2 C208.2 C209.1 C211.2 C212.2 C213.2 C214.1 C217.2 C220.2 C222.2 C223.2 C225.2 C226.2 C228.2 C230.2 C231.2 C232.2 C242.2 C246.1 C247.1 C249.2 C250.2 C251.2 C254.2 C255.2 C256.2 C259.2 C260.2 C261.2 C262.2 C263.2 C264.2 C266.2 C268.2 C269.1 C270.2 C271.2 C272.2 C273.2 C274.2 C275.2 C278.2 C279.2 C280.1 C281.1 C282.2 C283.2 C284.2 C285.2 C287.2 C289.2 C290.2 C293.2 C294.1 C295.2 C296.2 C297.2 C299.2 C301.1 C303.2 C304.2 C305.2 C306.1 C313.2 C314.2 C315.2 C316.2 C318.1 C321.1 C322.2 C325.1 C326.2 C327.2 C328.2 C329.2 C330.2 C331.2 C332.1 C333.2 C334.1 C335.2 C336.1 C337.1 C338.2 C339.1 C340.1 C341.1 C342.2 C343.1 C344.1 C345.1 C346.2 C347.1 C348.2 C349.1 C350.2 C352.1 C353.1 C354.2 C355.2 C356.2 C357.2 C358.2 C359.2 C360.1 C361.2 C362.2 C363.2 C365.2 C366.2 C367.2 C368.2 C369.2 C371.1 C372.1 C373.2 C374.2 C375.2 C376.1 C377.2 C378.2 C379.2 C380.2 C381.1 C382.1 C383.2 C384.2 C385.2 C386.2 C387.2 C388.2 C389.1 C390.2 C391.2 C392.2 C393.2 C394.1 C395.2 C396.2 C397.2 C398.1 C399.2 C400.2 C401.1 C402.2 C403.2 C404.1 C405.2 C406.1 C407.2 C408.2 C409.2 C410.2 C413.2 C414.1 C415.1 C416.1 C417.1 C418.2 C419.2 C420.2 C421.1 C422.2 C423.1 C424.1 C425.1 C426.2 C427.1 C428.2 C429.2 C431.2 C432.2 C433.2 C435.2 C436.2 C437.2 C438.2 C439.1 C440.2 C441.2 C442.1 C443.1 C444.1 C445.1 C446.1 C447.1 C448.1 C449.1 C450.1 C451.2 C452.2 C453.1 C454.2 C455.1 C456.1 C457.2 C458.1 C459.1 C460.2 C461.2 C462.1 C463.1 C464.1 C465.2 C466.1 C467.1 C468.1 C469.1 C470.1 C471.1 C472.1 C473.1 C474.1 C475.1 C476.2 C477.1 C478.1 C479.1 C480.1 C481.1 C482.1 C483.1 C484.2 C485.1 C486.1 C487.2 C488.1 C489.1 C490.1 C493.1 C494.1 C495.1 C496.1 C497.2 C498.2 C501.2 C503.2 C504.1 C508.2 C509.2 C514.2 C515.2 C516.2 C518.2 C519.2 C520.2 C521.2 C522.2 C525.2 C526.2 C527.2 C528.2 C529.2 C530.2 C531.2 C532.2 C533.2 C535.2 C536.2 C537.2 C538.2 C539.2 C540.2 C541.2 C542.2 C543.2 C544.2 C545.2 C546.2 C547.2 C548.2 C549.2 C550.2 C551.2 C552.2 C553.2 C554.2 C555.2 C556.2 C557.2 C558.2 C559.2 C560.2 C561.2 C562.2 C563.2 C564.2 C565.2 C566.2 C567.2 C569.2 C570.2 C571.2 C572.1 C573.2 C574.2 C575.2 C576.2 C578.2 C580.2 C581.2 C582.2 C583.2 C584.2 C585.2 C586.2 C587.2 C588.2 C591.2 C592.1 C593.2 C594.2 C595.2 C597.2 C598.2 C599.2 C600.2 C601.2 C602.2 C603.2 C604.2 C605.2 C606.2 C607.2 C608.2 C609.2 C610.2 C611.2 C612.2 C613.2 C614.2 C615.2 C616.2 C617.2 C618.2 C619.2 C620.2 C621.2 C622.2 C623.2 C624.2 C625.1 C626.2 C627.2 C628.2 C629.2 C630.2 C631.2 C632.2 C633.2 C634.2 C635.2 C636.2 C637.2 C638.2 C639.2 C640.2 C641.2 C642.2 C643.2 C644.1 C645.2 C646.2 C647.2 C648.2 C649.2 C650.2 C651.2 C652.2 C653.2 C654.2 C655.2 C656.2 C657.2 C658.2 C659.2 C660.2 C661.2 C662.2 C663.2 C664.2 C665.2 C667.2 C669.2 C672.2 C673.2 C674.2 C676.2 C677.2 C678.2 C679.2 C680.2 C681.2 C682.2 C683.2 C684.2 C685.2 C687.2 C688.2 C689.2 C690.2 C691.2 C692.2 C693.2 C694.2 C695.2 C696.2 C697.2 C698.2 C699.2 C700.2 C701.2 C702.2 C703.2 C704.2 C705.2 C706.2 C707.2 C708.2 C709.2 C710.2 C711.2 C712.2 C713.2 C714.1 C715.1 C718.2 C719.2 C720.1 C721.2 C722.2 C723.1 C724.2 C727.2 C728.2 C729.2 C730.1 C731.2 C732.1 C733.1 C734.1 C735.2 C736.2 C737.2 C738.2 C739.2 C740.2 C741.1 C742.2 C743.2 C744.2 C745.2 C746.2 C747.2 C748.2 C750.2 C751.2 C752.2 C753.1 C754.2 C755.2 C756.1 C757.1 C758.2 C759.2 C760.2 C761.1 C762.2 C763.2 C764.2 C765.2 C766.1 C767.2 C768.1 C769.2 C770.2 C771.2 C772.2 C773.2 C774.2 C775.1 C776.1 C777.2 C778.1 C779.2 C780.2 C781.2 C782.2 C783.2 C784.1 C785.2 C786.2 C787.1 C788.2 C789.2 C790.2 C792.1 C793.2 C794.1 C795.2 C796.2 C797.2 C798.2 C799.1 C800.2 C801.2 C802.2 C803.2 C804.1 C805.2 C806.2 C807.1 C808.2 C809.2 C810.1 C811.2 C812.2 C813.1 C814.2 C815.2 C816.2 C817.2 C818.2 C819.2 C820.2 C821.2 C822.2 C823.2 C825.2 C826.2 C827.2 C828.2 C829.1 C830.1 C831.2 C832.2 C833.2 C834.2 C835.1 C836.2 C837.1 C838.2 C841.2 C842.2 C843.1 C844.1 CN2.3 CN3.3 CN3.4 CN3.57 CN3.58 CN3.63 CN3.64 CN3.117 CN3.118 CN3.H3(SMDFIX_1) CN3.H4(SMDFIX_2) CN3.H5(SMDFIX_3) CN3.H6(SMDFIX_4) CN3.H7(SMDFIX_5) CN3.H8(SMDFIX_6) CN3.H9(SMDFIX_7) CN3.H10(SMDFIX_8) CN3.H11(PTH_1) CN3.H12(PTH_2) CN4.1(GND1) CN4.3(GND2) CN5.1(GND1) CN5.3(GND2) CN6.1(GND1) CN6.3(GND2) CN8.3 CN9.2 CN10.1(GND1) CN10.3(GND2) CN11.H1(SMDFIX1) CN11.H2(SMDFIX2) CN12.H1(SMDFIX1) CN12.H2(SMDFIX2) CN13.H1(SMDFIX1) CN13.H2(SMDFIX2) CN16.A6(TCT2_A) CN16.B6(TCT2_B) CN18.2(GND_1) CN18.3(GND_2) CN18.4(GND_3) CN18.5(GND_4) CN21.3 CN22.3 CN22.5 CN22.9 CN23.1(GND1) CN23.3(GND2) D14.3(GND) DC_IN1.2 DC_IN1.3 DIMM1.2(VSS1) DIMM1.3(VSS2) DIMM1.8(VSS3) DIMM1.9(VSS4) DIMM1.14(VSS5) DIMM1.17(VSS6) DIMM1.20(VSS7) DIMM1.23(VSS8) DIMM1.26(VSS9) DIMM1.29(VSS10) DIMM1.32(VSS11) DIMM1.35(VSS12) DIMM1.38(VSS13) DIMM1.41(VSS14) DIMM1.46(VSS15) DIMM1.47(VSS16) DIMM1.52(VSS17) DIMM1.53(VSS18) DIMM1.58(VSS19) DIMM1.61(VSS20) DIMM1.64(VSS21) DIMM1.67(VSS22) DIMM1.70(VSS23) DIMM1.73(VSS24) DIMM1.78(VSS25) DIMM1.79(VSS26) DIMM1.137(VSS27) DIMM1.138(VSS28) DIMM1.143(VSS29) DIMM1.146(VSS30) DIMM1.149(VSS31) DIMM1.152(VSS32) DIMM1.155(VSS33) DIMM1.158(VSS34) DIMM1.163(VSS35) DIMM1.164(VSS36) DIMM1.169(VSS37) DIMM1.170(VSS38) DIMM1.175(VSS39) DIMM1.178(VSS40) DIMM1.181(VSS41) DIMM1.184(VSS42) DIMM1.187(VSS43) DIMM1.190(VSS44) DIMM1.195(VSS45) DIMM1.196(VSS46) DIMM1.H3(SMDFIX_1) DIMM1.H4(SMDFIX_2) EEPROM1.4(VSS) EMU1.16 EMU1.57(PTH_61) EMU1.H3(PTH_1) EMU1.H4(PTH_2) EMU1.H5(PTH_3) EMU1.H6(PTH_4) FAN1.1 FTDI_USB.4(GND_1) FTDI_USB.5(GND_2) GPS1.A1(GPS_GND_1) GPS1.A2(GPS_GND_2) GPS1.B2(GPS_GND_3) GPS1.E2(GND_1) GPS1.E6(GND_4) GPS1.F2(GND_2) GPS1.F5(GND_3) J1.GA1(GNDA1) J1.GA2(GNDA2) J1.GA3(GNDA3) J1.GA4(GNDA4) J1.GA5(GNDA5) J1.GA6(GNDA6) J1.GA7(GNDA7) J1.GA8(GNDA8) J1.GA9(GNDA9) J1.GA10(GNDA10) J1.GB1(GNDB1) J1.GB2(GNDB2) J1.GB3(GNDB3) J1.GB4(GNDB4) J1.GB5(GNDB5) J1.GB6(GNDB6) J1.GB7(GNDB7) J1.GB8(GNDB8) J1.GB9(GNDB9) J1.GB10(GNDB10) J1.GC1(GNDC1) J1.GC2(GNDC2) J1.GC3(GNDC3) J1.GC4(GNDC4) J1.GC5(GNDC5) J1.GC6(GNDC6) J1.GC7(GNDC7) J1.GC8(GNDC8) J1.GC9(GNDC9) J1.GC10(GNDC10) J1.GD1(GNDD1) J1.GD2(GNDD2) J1.GD3(GNDD3) J1.GD4(GNDD4) J1.GD5(GNDD5) J1.GD6(GNDD6) J1.GD7(GNDD7) J1.GD8(GNDD8) J1.GD9(GNDD9) J1.GD10(GNDD10) J1.GE1(GNDE1) J1.GE2(GNDE2) J1.GE3(GNDE3) J1.GE4(GNDE4) J1.GE5(GNDE5) J1.GE6(GNDE6) J1.GE7(GNDE7) J1.GE8(GNDE8) J1.GE9(GNDE9) J1.GE10(GNDE10) J1.GF1(GNDF1) J1.GF2(GNDF2) J1.GF3(GNDF3) J1.GF4(GNDF4) J1.GF5(GNDF5) J1.GF6(GNDF6) J1.GF7(GNDF7) J1.GF8(GNDF8) J1.GF9(GNDF9) J1.GF10(GNDF10) J1.GG1(GNDG1) J1.GG2(GNDG2) J1.GG3(GNDG3) J1.GG4(GNDG4) J1.GG5(GNDG5) J1.GG6(GNDG6) J1.GG7(GNDG7) J1.GG8(GNDG8) J1.GG9(GNDG9) J1.GG10(GNDG10) J1.GH1(GNDH1) J1.GH2(GNDH2) J1.GH3(GNDH3) J1.GH4(GNDH4) J1.GH5(GNDH5) J1.GH6(GNDH6) J1.GH7(GNDH7) J1.GH8(GNDH8) J1.GH9(GNDH9) J1.GH10(GNDH10) J2.GA1(GNDA1) J2.GA2(GNDA2) J2.GA3(GNDA3) J2.GA4(GNDA4) J2.GA5(GNDA5) J2.GA6(GNDA6) J2.GA7(GNDA7) J2.GA8(GNDA8) J2.GA9(GNDA9) J2.GA10(GNDA10) J2.GB1(GNDB1) J2.GB2(GNDB2) J2.GB3(GNDB3) J2.GB4(GNDB4) J2.GB5(GNDB5) J2.GB6(GNDB6) J2.GB7(GNDB7) J2.GB8(GNDB8) J2.GB9(GNDB9) J2.GB10(GNDB10) J2.GC1(GNDC1) J2.GC2(GNDC2) J2.GC3(GNDC3) J2.GC4(GNDC4) J2.GC5(GNDC5) J2.GC6(GNDC6) J2.GC7(GNDC7) J2.GC8(GNDC8) J2.GC9(GNDC9) J2.GC10(GNDC10) J2.GD1(GNDD1) J2.GD2(GNDD2) J2.GD3(GNDD3) J2.GD4(GNDD4) J2.GD5(GNDD5) J2.GD6(GNDD6) J2.GD7(GNDD7) J2.GD8(GNDD8) J2.GD9(GNDD9) J2.GD10(GNDD10) J2.GE1(GNDE1) J2.GE2(GNDE2) J2.GE3(GNDE3) J2.GE4(GNDE4) J2.GE5(GNDE5) J2.GE6(GNDE6) J2.GE7(GNDE7) J2.GE8(GNDE8) J2.GE9(GNDE9) J2.GE10(GNDE10) J2.GF1(GNDF1) J2.GF2(GNDF2) J2.GF3(GNDF3) J2.GF4(GNDF4) J2.GF5(GNDF5) J2.GF6(GNDF6) J2.GF7(GNDF7) J2.GF8(GNDF8) J2.GF9(GNDF9) J2.GF10(GNDF10) J2.GG1(GNDG1) J2.GG2(GNDG2) J2.GG3(GNDG3) J2.GG4(GNDG4) J2.GG5(GNDG5) J2.GG6(GNDG6) J2.GG7(GNDG7) J2.GG8(GNDG8) J2.GG9(GNDG9) J2.GG10(GNDG10) J2.GH1(GNDH1) J2.GH2(GNDH2) J2.GH3(GNDH3) J2.GH4(GNDH4) J2.GH5(GNDH5) J2.GH6(GNDH6) J2.GH7(GNDH7) J2.GH8(GNDH8) J2.GH9(GNDH9) J2.GH10(GNDH10) LCD1.11(VSS) LCD1.K(LED-) MCU.2 NAND1.C5(VSS4) NAND1.F7(VSS1) NAND1.K3(VSS3) NAND1.K8(VSS2) NOR1.10(VSS) OSC1.2(GND) OSC2.3(GND) OSC3.2(GND) OSC4.2(GND) PB1.1 PHY1.D4(VSS_1) PHY1.D5(VSS_10) PHY1.D6(VSS_11) PHY1.E4(VSS_12) PHY1.E5(VSS_13) PHY1.E6(VSS_14) PHY1.F4(VSS_15) PHY1.F5(VSS_16) PHY1.F6(VSS_17) PHY1.G4(VSS_18) PHY1.G5(VSS_19) PHY1.G6(VSS_2) PHY1.H4(VSS_20) PHY1.H5(VSS_21) PHY1.H6(VSS_22) PHY1.H7(VSSC) PHY1.J4(VSS_23) PHY1.J5(VSS_3) PHY1.J6(VSS_4) PHY1.K4(VSS_5) PHY1.K5(VSS_6) PHY1.K6(VSS_7) PHY1.L4(COMA) PHY1.L5(VSS_8) PHY1.L6(VSS_9) PHY2.D4(VSS_1) PHY2.D5(VSS_10) PHY2.D6(VSS_11) PHY2.E4(VSS_12) PHY2.E5(VSS_13) PHY2.E6(VSS_14) PHY2.F4(VSS_15) PHY2.F5(VSS_16) PHY2.F6(VSS_17) PHY2.G4(VSS_18) PHY2.G5(VSS_19) PHY2.G6(VSS_2) PHY2.H4(VSS_20) PHY2.H5(VSS_21) PHY2.H6(VSS_22) PHY2.H7(VSSC) PHY2.J4(VSS_23) PHY2.J5(VSS_3) PHY2.J6(VSS_4) PHY2.K4(VSS_5) PHY2.K5(VSS_6) PHY2.K6(VSS_7) PHY2.L4(COMA) PHY2.L5(VSS_8) PHY2.L6(VSS_9) PMBUS1.5 PWR.1 Q1.4(GND) Q1.9(EPAD) Q2.6(GND) Q2.11(THERMAL_PAD) Q2.12(THERMAL_VIA_1) Q2.13(THERMAL_VIA_2) Q2.14(THERMAL_VIA_3) Q2.15(THERMAL_VIA_4) Q2.16(THERMAL_VIA_5) Q3.2(E) Q4.2(E) Q5.2(E) Q6.2(GND) Q7.4(GND) Q7.9(EPAD) Q8.4(GND) Q8.9(EPAD) Q9.2(E) Q10.1(ADJ/GND) Q11.2(E) Q12.2(E) Q13.3(ANODE) Q14.2(E) Q15.2(GND) Q16.2(E) Q17.2(GND) Q18.2(E) Q20.2(SOURCE) Q21.2(GND) R1.2 R4.1 R5.1 R6.1 R8.1 R9.2 R10.2 R14.2 R15.1 R20.1 R24.1 R28.2 R29.1 R54.2 R58.1 R65.1 R77.1 R105.1 R113.1 R128.1 R136.1 R151.1 R159.2 R171.2 R172.1 R173.1 R174.1 R191.1 R196.2 R197.1 R198.1 R202.2 R207.2 R209.2 R212.1 R213.2 R218.2 R224.1 R225.2 R235.2 R241.2 R251.1 R252.2 R255.1 R259.2 R260.1 R264.2 R268.1 R274.2 R275.2 R279.2 R281.1 R284.2 R285.2 R287.2 R289.2 R293.2 R296.2 R298.2 R301.2 R303.2 R304.2 R305.2 R308.2 R310.2 R312.2 R313.2 R320.1 R321.2 R323.1 R325.1 R328.1 R336.1 R351.1 R352.2 R357.2 R360.1 R361.1 R365.2 R376.2 R385.1 R389.1 R390.1 R394.1 R395.2 R397.1 R410.2 R427.2 R430.1 R432.2 R437.2 R442.2 R456.1 R470.2 R472.1 R473.1 R474.1 R475.1 R476.1 R479.1 R481.2 R483.1 R487.2 R488.2 R489.2 R503.2 R508.2 R530.1 R540.2 R544.2 R567.1 R578.2 R582.1 R583.1 R587.2 R588.1 R590.1 R591.1 R592.1 R593.1 R594.1 R595.1 R596.1 R597.1 R598.1 R599.1 R600.1 R601.1 R602.2 R605.2 R612.2 R613.2 R615.2 R616.2 R617.2 R620.1 R623.1 R625.1 R627.2 R629.1 R631.1 R632.2 R634.2 R635.2 R638.2 R639.2 R640.2 R643.2 R644.1 R648.2 R649.2 R656.1 R657.2 R659.1 R661.1 R662.1 R663.1 R664.1 R665.1 R666.1 R667.1 R668.2 R671.2 R672.1 R673.1 R674.1 R675.1 R676.1 R677.1 R678.2 R684.2 R685.2 R686.2 R687.2 R694.2 R696.1 R698.2 R699.1 R702.1 R704.2 R706.1 R707.1 R709.1 R711.1 R713.1 R715.2 R716.2 R719.2 R720.1 R721.1 R723.1 R726.2 R727.1 R730.1 R731.1 R734.1 R739.1 R743.2 R744.1 R745.2 R746.1 R747.1 R748.1 R749.1 R751.1 R752.1 R753.1 R754.2 R756.2 R762.2 R768.1 R770.2 R771.1 R776.1 R777.1 R778.1 R783.1 R784.1 R787.1 R796.1 R797.1 R800.1 R805.1 R806.1 R815.2 R816.2 R817.2 RR1.2 RST_MCU1.1 SIM1.C5 SIM1.H1(SMDFIX2) SIM1.H2(SMDFIX1) SOC.2 SOCKET1.H1(PTH_1) SOCKET1.H2(PTH_2) SOCKET1.H3(PTH_3) SOCKET1.H4(PTH_4) U1.2(GND1) U1.3(GND2) U1.15(EPAD) U2.2(GND1) U2.3(GND2) U2.15(EPAD) U3.1(GND_1) U3.5(GND_2) U3.10(AGND) U3.11(GND_3) U3.13(TEST) U3.15(GND_4) U3.25(GND_5) U3.35(GND_6) U3.47(GND_7) U3.51(GND_8) U4.1 U4.4(GND) U5.9(A8) U5.11(GND) U5.12(B8) U6.3(GND) U7.4(GNDA) U7.9(GND_1) U7.21(GND_2) U7.33(GND_9) U7.45(GND_3) U7.54(GND_8) U7.57(GND_4) U7.69(GND_5) U7.82(GND_6) U7.94(GND_7) U8.1(AGND) U8.2(VGG_DIS) U8.13(PGND_1) U8.14(PGND_2) U8.15(PGND_3) U8.16(PGND_4) U8.17(PGND_5) U8.18(PGND_6) U8.19(PGND_7) U8.20(PGND_8) U8.41(THERMAL_PAD) U8.42(THERMAL_VIA1) U8.43(THERMAL_VIA2) U8.44(THERMAL_VIA3) U8.45(THERMAL_VIA4) U8.46(THERMAL_VIA5) U8.47(THERMAL_VIA6) U8.48(THERMAL_VIA7) U8.49(THERMAL_VIA8) U8.50(THERMAL_VIA9) U8.51(THERMAL_VIA10) U8.52(THERMAL_VIA11) U8.53(THERMAL_VIA12) U8.54(THERMAL_VIA13) U8.55(THERMAL_VIA14) U8.56(THERMAL_VIA15) U8.57(THERMAL_VIA16) U8.58(THERMAL_VIA17) U8.59(THERMAL_VIA18) U8.60(THERMAL_VIA19) U8.61(THERMAL_VIA20) U8.62(THERMAL_VIA21) U9.6(VGG_DIS) U9.8(TESTMODE) U9.10(PGND_1) U9.11(NC-PGND_1) U9.12(PGND_2) U9.15(PGND_3) U9.16(NC-PGND_2) U9.17(PGND_4) U9.21(AGND) U10.1(AGND) U10.2(VGG_DIS) U10.13(PGND_1) U10.14(PGND_2) U10.15(PGND_3) U10.16(PGND_4) U10.17(PGND_5) U10.18(PGND_6) U10.19(PGND_7) U10.20(PGND_8) U10.41(THERMAL_PAD) U10.42(THERMAL_VIA1) U10.43(THERMAL_VIA2) U10.44(THERMAL_VIA3) U10.45(THERMAL_VIA4) U10.46(THERMAL_VIA5) U10.47(THERMAL_VIA6) U10.48(THERMAL_VIA7) U10.49(THERMAL_VIA8) U10.50(THERMAL_VIA9) U10.51(THERMAL_VIA10) U10.52(THERMAL_VIA11) U10.53(THERMAL_VIA12) U10.54(THERMAL_VIA13) U10.55(THERMAL_VIA14) U10.56(THERMAL_VIA15) U10.57(THERMAL_VIA16) U10.58(THERMAL_VIA17) U10.59(THERMAL_VIA18) U10.60(THERMAL_VIA19) U10.61(THERMAL_VIA20) U10.62(THERMAL_VIA21) U11.3 U12.4(GND) U12.7(G\) U13.32(DVSS) U13.49(THERMAL_PAD) U13.50(THERMAL_VIA1) U13.51(THERMAL_VIA2) U13.52(THERMAL_VIA3) U13.53(THERMAL_VIA4) U13.54(THERMAL_VIA5) U13.55(THERMAL_VIA6) U13.56(THERMAL_VIA7) U13.57(THERMAL_VIA8) U13.58(THERMAL_VIA9) U13.59(THERMAL_VIA10) U13.60(THERMAL_VIA11) U13.61(THERMAL_VIA12) U13.62(THERMAL_VIA13) U13.63(THERMAL_VIA14) U13.64(THERMAL_VIA15) U13.65(THERMAL_VIA16) U13.66(THERMAL_VIA17) U13.67(THERMAL_VIA18) U13.68(THERMAL_VIA19) U13.69(THERMAL_VIA20) U13.70(THERMAL_VIA21) U13.71(THERMAL_VIA22) U13.72(THERMAL_VIA23) U13.73(THERMAL_VIA24) U13.74(THERMAL_VIA25) U14.12(SEC_REFN) U14.49(GND_EPAD) U14.50(THERMAL_VIA_1) U14.51(THERMAL_VIA_2) U14.52(THERMAL_VIA_3) U14.53(THERMAL_VIA_4) U14.54(THERMAL_VIA_5) U14.55(THERMAL_VIA_6) U14.56(THERMAL_VIA_7) U14.57(THERMAL_VIA_8) U14.58(THERMAL_VIA_9) U14.59(THERMAL_VIA_10) U14.60(THERMAL_VIA_11) U14.61(THERMAL_VIA_12) U14.62(THERMAL_VIA_13) U14.63(THERMAL_VIA_14) U14.64(THERMAL_VIA_15) U14.65(THERMAL_VIA_16) U15.12(SEC_REFN) U15.49(GND_EPAD) U15.50(THERMAL_VIA_1) U15.51(THERMAL_VIA_2) U15.52(THERMAL_VIA_3) U15.53(THERMAL_VIA_4) U15.54(THERMAL_VIA_5) U15.55(THERMAL_VIA_6) U15.56(THERMAL_VIA_7) U15.57(THERMAL_VIA_8) U15.58(THERMAL_VIA_9) U15.59(THERMAL_VIA_10) U15.60(THERMAL_VIA_11) U15.61(THERMAL_VIA_12) U15.62(THERMAL_VIA_13) U15.63(THERMAL_VIA_14) U15.64(THERMAL_VIA_15) U15.65(THERMAL_VIA_16) U16.8(DGND1) U16.26(DGND2) U16.43(DGND3) U16.48(AGND2) U16.49(AGND1) U16.64(AGND3) U16.65(POWERPAD) U16.66(THERMAL_VIA1) U16.67(THERMAL_VIA2) U16.68(THERMAL_VIA3) U16.69(THERMAL_VIA4) U16.70(THERMAL_VIA5) U16.71(THERMAL_VIA6) U16.72(THERMAL_VIA7) U16.73(THERMAL_VIA8) U16.74(THERMAL_VIA9) U16.75(THERMAL_VIA10) U16.76(THERMAL_VIA11) U16.77(THERMAL_VIA12) U16.78(THERMAL_VIA13) U16.79(THERMAL_VIA14) U16.80(THERMAL_VIA15) U16.81(THERMAL_VIA16) U16.82(THERMAL_VIA17) U16.83(THERMAL_VIA18) U16.84(THERMAL_VIA19) U16.85(THERMAL_VIA20) U16.86(THERMAL_VIA21) U16.87(THERMAL_VIA22) U16.88(THERMAL_VIA23) U16.89(THERMAL_VIA24) U16.90(THERMAL_VIA25) U17.4(GND) U17.7(G\) U18.1(E\N\) U18.14(GND) U19.49(GND_EPAD) U19.50(THERMAL_VIA_1) U19.51(THERMAL_VIA_2) U19.52(THERMAL_VIA_3) U19.53(THERMAL_VIA_4) U19.54(THERMAL_VIA_5) U19.55(THERMAL_VIA_6) U19.56(THERMAL_VIA_7) U19.57(THERMAL_VIA_8) U19.58(THERMAL_VIA_9) U19.59(THERMAL_VIA_10) U19.60(THERMAL_VIA_11) U19.61(THERMAL_VIA_12) U19.62(THERMAL_VIA_13) U19.63(THERMAL_VIA_14) U19.64(THERMAL_VIA_15) U19.65(THERMAL_VIA_16) U20.8(GND_1) U20.12(GND_2) U20.13(GND_3) U21.4(GND) U21.7(G\) U22.4(GND) U23.6(VGG_DIS) U23.8(TESTMODE) U23.10(PGND_1) U23.11(NC-PGND_1) U23.12(PGND_2) U23.15(PGND_3) U23.16(NC-PGND_2) U23.17(PGND_4) U23.21(AGND) U24.A2(VSS_01) U24.A3(VSS_02) U24.A37(VSS_03) U24.A38(VSS_04) U24.AA5(VSS_16) U24.AA7(VSS_17) U24.AA9(VSS_18) U24.AA11(VSS_05) U24.AA13(VSS_06) U24.AA15(VSS_07) U24.AA17(VSS_08) U24.AA19(VSS_09) U24.AA21(VSS_10) U24.AA23(VSS_11) U24.AA25(VSS_12) U24.AA27(VSS_13) U24.AA29(VSS_14) U24.AA35(VSS_15) U24.AB6(VSS_32) U24.AB8(VSS_33) U24.AB10(VSS_19) U24.AB12(VSS_20) U24.AB14(VSS_21) U24.AB16(VSS_22) U24.AB18(VSS_23) U24.AB20(VSS_24) U24.AB22(VSS_25) U24.AB24(VSS_26) U24.AB26(VSS_27) U24.AB30(VSS_28) U24.AB33(VSS_29) U24.AB36(VSS_30) U24.AB37(VSS_31) U24.AC7(VSS_45) U24.AC9(VSS_46) U24.AC11(VSS_34) U24.AC13(VSS_35) U24.AC15(VSS_36) U24.AC17(VSS_37) U24.AC19(VSS_38) U24.AC21(VSS_39) U24.AC23(VSS_40) U24.AC25(VSS_41) U24.AC27(VSS_42) U24.AC29(VSS_43) U24.AC35(VSS_44) U24.AD6(VSS_59) U24.AD8(VSS_60) U24.AD10(VSS_47) U24.AD12(VSS_48) U24.AD14(VSS_49) U24.AD16(VSS_50) U24.AD18(VSS_51) U24.AD20(VSS_52) U24.AD22(VSS_53) U24.AD24(VSS_54) U24.AD26(VSS_55) U24.AD30(VSS_56) U24.AD33(VSS_57) U24.AD37(VSS_58) U24.AE3(VSS_71) U24.AE7(VSS_74) U24.AE9(VSS_75) U24.AE11(VSS_61) U24.AE13(VSS_62) U24.AE15(VSS_63) U24.AE17(VSS_64) U24.AE19(VSS_65) U24.AE21(VSS_66) U24.AE23(VSS_67) U24.AE25(VSS_68) U24.AE27(VSS_69) U24.AE29(VSS_70) U24.AE31(VSS_72) U24.AE35(VSS_73) U24.AF6(VSS_89) U24.AF8(VSS_90) U24.AF10(VSS_76) U24.AF12(VSS_77) U24.AF14(VSS_78) U24.AF16(VSS_79) U24.AF18(VSS_80) U24.AF20(VSS_81) U24.AF22(VSS_82) U24.AF24(VSS_83) U24.AF26(VSS_84) U24.AF28(VSS_85) U24.AF30(VSS_86) U24.AF33(VSS_87) U24.AF37(VSS_88) U24.AG4(VSS_103) U24.AG7(VSS_104) U24.AG9(VSS_105) U24.AG11(VSS_91) U24.AG13(VSS_92) U24.AG15(VSS_93) U24.AG17(VSS_94) U24.AG19(VSS_95) U24.AG21(VSS_96) U24.AG23(VSS_97) U24.AG25(VSS_98) U24.AG27(VSS_99) U24.AG29(VSS_100) U24.AG31(VSS_101) U24.AG35(VSS_102) U24.AH6(VSS_119) U24.AH7(VSS_120) U24.AH8(VSS_121) U24.AH10(VSS_106) U24.AH12(VSS_107) U24.AH14(VSS_108) U24.AH16(VSS_109) U24.AH18(VSS_110) U24.AH20(VSS_111) U24.AH22(VSS_112) U24.AH24(VSS_113) U24.AH26(VSS_114) U24.AH28(VSS_115) U24.AH30(VSS_116) U24.AH33(VSS_117) U24.AH37(VSS_118) U24.AJ6(VSS_135) U24.AJ7(VSS_520) U24.AJ9(VSS_136) U24.AJ11(VSS_122) U24.AJ13(VSS_123) U24.AJ15(VSS_124) U24.AJ17(VSS_125) U24.AJ19(VSS_126) U24.AJ21(VSS_127) U24.AJ23(VSS_128) U24.AJ25(VSS_129) U24.AJ27(VSS_130) U24.AJ29(VSS_131) U24.AJ31(VSS_132) U24.AJ32(VSS_133) U24.AJ35(VSS_134) U24.AK2(VSS_142) U24.AK6(VSS_151) U24.AK8(VSS_152) U24.AK10(VSS_137) U24.AK12(VSS_138) U24.AK14(VSS_139) U24.AK16(VSS_140) U24.AK18(VSS_141) U24.AK20(VSS_143) U24.AK22(VSS_144) U24.AK24(VSS_145) U24.AK26(VSS_146) U24.AK28(VSS_147) U24.AK30(VSS_148) U24.AK33(VSS_149) U24.AK37(VSS_150) U24.AL5(VSS_165) U24.AL7(VSS_166) U24.AL9(VSS_167) U24.AL11(VSS_153) U24.AL13(VSS_154) U24.AL15(VSS_155) U24.AL17(VSS_156) U24.AL19(VSS_157) U24.AL21(VSS_158) U24.AL23(VSS_159) U24.AL25(VSS_160) U24.AL27(VSS_161) U24.AL29(VSS_162) U24.AL31(VSS_163) U24.AL35(VSS_164) U24.AM3(VSS_175) U24.AM8(VSS_178) U24.AM10(VSS_168) U24.AM12(VSS_169) U24.AM13(VSS_170) U24.AM17(VSS_171) U24.AM18(VSS_172) U24.AM20(VSS_173) U24.AM22(VSS_174) U24.AM32(VSS_521) U24.AM33(VSS_176) U24.AM37(VSS_177) U24.AN2(VSS_186) U24.AN5(VSS_199) U24.AN6(VSS_200) U24.AN7(VSS_201) U24.AN8(VSS_202) U24.AN9(VSS_203) U24.AN11(VSS_179) U24.AN12(VSS_180) U24.AN13(VSS_181) U24.AN14(VSS_182) U24.AN15(VSS_183) U24.AN17(VSS_184) U24.AN18(VSS_185) U24.AN20(VSS_187) U24.AN21(VSS_188) U24.AN22(VSS_189) U24.AN23(VSS_190) U24.AN24(VSS_191) U24.AN25(VSS_192) U24.AN26(VSS_193) U24.AN27(VSS_194) U24.AN28(VSS_195) U24.AN29(VSS_196) U24.AN31(VSS_197) U24.AN35(VSS_198) U24.AP4(VSS_216) U24.AP7(VSS_217) U24.AP10(VSS_204) U24.AP13(VSS_205) U24.AP16(VSS_206) U24.AP19(VSS_207) U24.AP20(VSS_208) U24.AP21(VSS_209) U24.AP24(VSS_210) U24.AP27(VSS_211) U24.AP28(VSS_212) U24.AP29(VSS_213) U24.AP30(VSS_214) U24.AP37(VSS_215) U24.AR3(VSS_225) U24.AR6(VSS_228) U24.AR9(VSS_229) U24.AR12(VSS_218) U24.AR15(VSS_219) U24.AR18(VSS_220) U24.AR21(VSS_221) U24.AR22(VSS_222) U24.AR25(VSS_223) U24.AR28(VSS_224) U24.AR31(VSS_226) U24.AR33(VSS_227) U24.AT2(VSS_233) U24.AT5(VSS_240) U24.AT8(VSS_241) U24.AT11(VSS_230) U24.AT14(VSS_231) U24.AT17(VSS_232) U24.AT20(VSS_234) U24.AT23(VSS_235) U24.AT26(VSS_236) U24.AT29(VSS_237) U24.AT32(VSS_238) U24.AT36(VSS_239) U24.AU1(VSS_242) U24.AU2(VSS_246) U24.AU3(VSS_250) U24.AU6(VSS_254) U24.AU9(VSS_255) U24.AU12(VSS_243) U24.AU15(VSS_244) U24.AU18(VSS_245) U24.AU21(VSS_247) U24.AU24(VSS_248) U24.AU27(VSS_249) U24.AU30(VSS_251) U24.AU33(VSS_252) U24.AU39(VSS_253) U24.AV1(VSS_256) U24.AV2(VSS_260) U24.AV5(VSS_269) U24.AV8(VSS_270) U24.AV11(VSS_257) U24.AV14(VSS_258) U24.AV17(VSS_259) U24.AV20(VSS_261) U24.AV23(VSS_262) U24.AV26(VSS_263) U24.AV29(VSS_264) U24.AV32(VSS_265) U24.AV35(VSS_266) U24.AV38(VSS_267) U24.AV39(VSS_268) U24.AW2(VSS_274) U24.AW3(VSS_278) U24.AW6(VSS_283) U24.AW9(VSS_284) U24.AW12(VSS_271) U24.AW15(VSS_272) U24.AW18(VSS_273) U24.AW21(VSS_275) U24.AW24(VSS_276) U24.AW27(VSS_277) U24.AW30(VSS_279) U24.AW33(VSS_280) U24.AW37(VSS_281) U24.AW38(VSS_282) U24.B1(VSS_285) U24.B2(VSS_286) U24.B38(VSS_287) U24.B39(VSS_288) U24.C1(VSS_289) U24.C4(VSS_302) U24.C6(VSS_303) U24.C8(VSS_304) U24.C10(VSS_290) U24.C12(VSS_291) U24.C14(VSS_292) U24.C16(VSS_293) U24.C18(VSS_294) U24.C20(VSS_295) U24.C22(VSS_296) U24.C24(VSS_297) U24.C26(VSS_298) U24.C29(VSS_299) U24.C32(VSS_300) U24.C39(VSS_301) U24.D34(VSS_305) U24.D37(VSS_306) U24.E3(VSS_314) U24.E5(VSS_315) U24.E7(VSS_316) U24.E9(VSS_317) U24.E11(VSS_307) U24.E13(VSS_308) U24.E15(VSS_309) U24.E17(VSS_310) U24.E19(VSS_311) U24.E21(VSS_312) U24.E28(VSS_313) U24.G23(VSS_318) U24.G25(VSS_319) U24.G27(VSS_320) U24.G29(VSS_321) U24.G31(VSS_322) U24.G35(VSS_323) U24.H4(VSS_334) U24.H6(VSS_335) U24.H8(VSS_336) U24.H12(VSS_324) U24.H14(VSS_325) U24.H18(VSS_326) U24.H20(VSS_327) U24.H24(VSS_328) U24.H26(VSS_329) U24.H28(VSS_330) U24.H29(VSS_522) U24.H30(VSS_331) U24.H32(VSS_332) U24.H37(VSS_333) U24.J1(VSS_337) U24.J2(VSS_343) U24.J3(VSS_349) U24.J4(VSS_352) U24.J5(VSS_353) U24.J7(VSS_354) U24.J9(VSS_355) U24.J11(VSS_338) U24.J13(VSS_339) U24.J15(VSS_340) U24.J17(VSS_341) U24.J19(VSS_342) U24.J21(VSS_344) U24.J23(VSS_345) U24.J24(VSS_523) U24.J25(VSS_346) U24.J27(VSS_347) U24.J29(VSS_348) U24.J31(VSS_350) U24.J33(VSS_351) U24.K5(VSS_369) U24.K6(VSS_370) U24.K8(VSS_371) U24.K10(VSS_356) U24.K12(VSS_357) U24.K14(VSS_358) U24.K16(VSS_359) U24.K18(VSS_360) U24.K20(VSS_361) U24.K22(VSS_362) U24.K24(VSS_363) U24.K26(VSS_364) U24.K28(VSS_365) U24.K30(VSS_366) U24.K32(VSS_367) U24.K35(VSS_368) U24.L5(VSS_384) U24.L7(VSS_385) U24.L9(VSS_386) U24.L11(VSS_372) U24.L13(VSS_373) U24.L15(VSS_374) U24.L17(VSS_375) U24.L19(VSS_376) U24.L21(VSS_377) U24.L23(VSS_378) U24.L25(VSS_379) U24.L27(VSS_380) U24.L29(VSS_381) U24.L31(VSS_382) U24.L37(VSS_383) U24.M6(VSS_397) U24.M8(VSS_398) U24.M10(VSS_387) U24.M12(VSS_388) U24.M14(VSS_389) U24.M16(VSS_390) U24.M22(VSS_391) U24.M24(VSS_392) U24.M26(VSS_393) U24.M28(VSS_394) U24.M30(VSS_395) U24.M33(VSS_396) U24.N5(VSS_411) U24.N7(VSS_412) U24.N9(VSS_413) U24.N11(VSS_399) U24.N13(VSS_400) U24.N15(VSS_401) U24.N17(VSS_402) U24.N19(VSS_403) U24.N21(VSS_404) U24.N23(VSS_405) U24.N25(VSS_406) U24.N27(VSS_407) U24.N29(VSS_408) U24.N31(VSS_409) U24.N35(VSS_410) U24.P5(VSS_427) U24.P6(VSS_428) U24.P8(VSS_429) U24.P10(VSS_414) U24.P12(VSS_415) U24.P14(VSS_416) U24.P16(VSS_417) U24.P18(VSS_418) U24.P20(VSS_419) U24.P22(VSS_420) U24.P24(VSS_421) U24.P26(VSS_422) U24.P28(VSS_423) U24.P30(VSS_424) U24.P33(VSS_425) U24.P37(VSS_426) U24.R2(VSS_435) U24.R5(VSS_443) U24.R7(VSS_444) U24.R9(VSS_445) U24.R11(VSS_430) U24.R13(VSS_431) U24.R15(VSS_432) U24.R17(VSS_433) U24.R19(VSS_434) U24.R21(VSS_436) U24.R23(VSS_437) U24.R25(VSS_438) U24.R27(VSS_439) U24.R29(VSS_440) U24.R31(VSS_441) U24.R35(VSS_442) U24.T6(VSS_459) U24.T8(VSS_460) U24.T10(VSS_446) U24.T12(VSS_447) U24.T14(VSS_448) U24.T16(VSS_449) U24.T18(VSS_450) U24.T20(VSS_451) U24.T22(VSS_452) U24.T24(VSS_453) U24.T26(VSS_454) U24.T28(VSS_455) U24.T30(VSS_456) U24.T33(VSS_457) U24.T37(VSS_458) U24.U7(VSS_473) U24.U9(VSS_474) U24.U11(VSS_461) U24.U13(VSS_462) U24.U15(VSS_463) U24.U17(VSS_464) U24.U19(VSS_465) U24.U21(VSS_466) U24.U23(VSS_467) U24.U25(VSS_468) U24.U27(VSS_469) U24.U29(VSS_470) U24.U31(VSS_471) U24.U35(VSS_472) U24.V3(VSS_485) U24.V6(VSS_489) U24.V8(VSS_490) U24.V10(VSS_475) U24.V12(VSS_476) U24.V14(VSS_477) U24.V16(VSS_478) U24.V18(VSS_479) U24.V20(VSS_480) U24.V22(VSS_481) U24.V24(VSS_482) U24.V26(VSS_483) U24.V28(VSS_484) U24.V30(VSS_486) U24.V33(VSS_487) U24.V37(VSS_488) U24.W5(VSS_503) U24.W7(VSS_504) U24.W9(VSS_505) U24.W11(VSS_491) U24.W13(VSS_492) U24.W15(VSS_493) U24.W17(VSS_494) U24.W19(VSS_495) U24.W21(VSS_496) U24.W23(VSS_497) U24.W25(VSS_498) U24.W27(VSS_499) U24.W29(VSS_500) U24.W31(VSS_501) U24.W35(VSS_502) U24.Y2(VSS_511) U24.Y6(VSS_519) U24.Y8(VSS_524) U24.Y10(VSS_506) U24.Y12(VSS_507) U24.Y14(VSS_508) U24.Y16(VSS_509) U24.Y18(VSS_510) U24.Y20(VSS_512) U24.Y22(VSS_513) U24.Y24(VSS_514) U24.Y26(VSS_515) U24.Y30(VSS_516) U24.Y33(VSS_517) U24.Y37(VSS_518) U25.8(DGND1) U25.26(DGND2) U25.43(DGND3) U25.48(AGND2) U25.49(AGND1) U25.64(AGND3) U25.65(POWERPAD) U25.66(THERMAL_VIA1) U25.67(THERMAL_VIA2) U25.68(THERMAL_VIA3) U25.69(THERMAL_VIA4) U25.70(THERMAL_VIA5) U25.71(THERMAL_VIA6) U25.72(THERMAL_VIA7) U25.73(THERMAL_VIA8) U25.74(THERMAL_VIA9) U25.75(THERMAL_VIA10) U25.76(THERMAL_VIA11) U25.77(THERMAL_VIA12) U25.78(THERMAL_VIA13) U25.79(THERMAL_VIA14) U25.80(THERMAL_VIA15) U25.81(THERMAL_VIA16) U25.82(THERMAL_VIA17) U25.83(THERMAL_VIA18) U25.84(THERMAL_VIA19) U25.85(THERMAL_VIA20) U25.86(THERMAL_VIA21) U25.87(THERMAL_VIA22) U25.88(THERMAL_VIA23) U25.89(THERMAL_VIA24) U25.90(THERMAL_VIA25) U26.2(GND) U27.7(PGND) U27.8(AGND) U28.4(GND) U29.8(GND) U30.4(GND) U30.7(G\) U31.1(GND) U32.2(1DIR) U32.3(2DIR) U32.8(GND1) U32.9(GND2) U32.14(2O\E\) U32.15(1O\E\) U33.10(GND) U33.17(EPAD) U34.4(GND) U35.2(1DIR) U35.3(2DIR) U35.8(GND1) U35.9(GND2) U36.1(GND) U37.2(1DIR) U37.3(2DIR) U37.8(GND1) U37.9(GND2) U38.4(PGND) U38.8(GND) U38.11(EPAD) U38.12(VIA1) U38.13(VIA2) U38.14(VIA3) U38.15(VIA4) U38.16(VIA5) U39.A9(VSS_1) U39.B1(VSSQ_1) U39.B3(VSS_2) U39.B9(VSSQ_2) U39.D1(VSSQ_3) U39.D8(VSSQ_4) U39.E1(VSS_3) U39.E2(VSSQ_5) U39.E8(VSSQ_6) U39.F9(VSSQ_7) U39.G1(VSSQ_8) U39.G8(VSS_4) U39.G9(VSSQ_9) U39.J2(VSS_5) U39.J8(VSS_6) U39.M1(VSS_7) U39.M9(VSS_8) U39.P1(VSS_9) U39.P9(VSS_10) U39.T1(VSS_11) U39.T9(VSS_12) U40.A9(VSS_1) U40.B1(VSSQ_1) U40.B3(VSS_2) U40.B9(VSSQ_2) U40.D1(VSSQ_3) U40.D8(VSSQ_4) U40.E1(VSS_3) U40.E2(VSSQ_5) U40.E8(VSSQ_6) U40.F9(VSSQ_7) U40.G1(VSSQ_8) U40.G8(VSS_4) U40.G9(VSSQ_9) U40.J2(VSS_5) U40.J8(VSS_6) U40.M1(VSS_7) U40.M9(VSS_8) U40.P1(VSS_9) U40.P9(VSS_10) U40.T1(VSS_11) U40.T9(VSS_12) U41.A9(VSS_1) U41.B1(VSSQ_1) U41.B3(VSS_2) U41.B9(VSSQ_2) U41.D1(VSSQ_3) U41.D8(VSSQ_4) U41.E1(VSS_3) U41.E2(VSSQ_5) U41.E8(VSSQ_6) U41.F9(VSSQ_7) U41.G1(VSSQ_8) U41.G8(VSS_4) U41.G9(VSSQ_9) U41.J2(VSS_5) U41.J8(VSS_6) U41.M1(VSS_7) U41.M9(VSS_8) U41.P1(VSS_9) U41.P9(VSS_10) U41.T1(VSS_11) U41.T9(VSS_12) U42.A9(VSS_1) U42.B1(VSSQ_1) U42.B3(VSS_2) U42.B9(VSSQ_2) U42.D1(VSSQ_3) U42.D8(VSSQ_4) U42.E1(VSS_3) U42.E2(VSSQ_5) U42.E8(VSSQ_6) U42.F9(VSSQ_7) U42.G1(VSSQ_8) U42.G8(VSS_4) U42.G9(VSSQ_9) U42.J2(VSS_5) U42.J8(VSS_6) U42.M1(VSS_7) U42.M9(VSS_8) U42.P1(VSS_9) U42.P9(VSS_10) U42.T1(VSS_11) U42.T9(VSS_12) U43.A9(VSS_1) U43.B1(VSSQ_1) U43.B3(VSS_2) U43.B9(VSSQ_2) U43.D1(VSSQ_3) U43.D8(VSSQ_4) U43.E1(VSS_3) U43.E2(VSSQ_5) U43.E8(VSSQ_6) U43.F9(VSSQ_7) U43.G1(VSSQ_8) U43.G8(VSS_4) U43.G9(VSSQ_9) U43.J2(VSS_5) U43.J8(VSS_6) U43.M1(VSS_7) U43.M9(VSS_8) U43.P1(VSS_9) U43.P9(VSS_10) U43.T1(VSS_11) U43.T9(VSS_12) U44.1(AGND) U44.2(VGG_DIS) U44.13(PGND_1) U44.14(PGND_2) U44.15(PGND_3) U44.16(PGND_4) U44.17(PGND_5) U44.18(PGND_6) U44.19(PGND_7) U44.20(PGND_8) U44.41(THERMAL_PAD) U44.42(THERMAL_VIA1) U44.43(THERMAL_VIA2) U44.44(THERMAL_VIA3) U44.45(THERMAL_VIA4) U44.46(THERMAL_VIA5) U44.47(THERMAL_VIA6) U44.48(THERMAL_VIA7) U44.49(THERMAL_VIA8) U44.50(THERMAL_VIA9) U44.51(THERMAL_VIA10) U44.52(THERMAL_VIA11) U44.53(THERMAL_VIA12) U44.54(THERMAL_VIA13) U44.55(THERMAL_VIA14) U44.56(THERMAL_VIA15) U44.57(THERMAL_VIA16) U44.58(THERMAL_VIA17) U44.59(THERMAL_VIA18) U44.60(THERMAL_VIA19) U44.61(THERMAL_VIA20) U44.62(THERMAL_VIA21) U45.10(GND) U46.5(GND) U47.10(VSS) U47.15(A0) U47.16(A1) U47.17(A2) U48.10(VSS) U48.15(A0) U48.16(A1) U48.17(A2) U49.3(GND1) U49.5(GND2) U49.7(GND3) U49.9(GND4) U49.11(GND5) U49.13(GND6) U49.16(GND7) U49.18(GND8) U49.20(GND9) U49.22(GND10) U49.27(GND11) U49.30(GND12) U49.33(GND13) U49.37(GND14) U49.40(GND15) U49.43(GND16) U49.46(GND17) U50.10(VSS) U50.15(A0) U50.16(A1) U50.17(A2) U51.8(GND1) U51.9(GND2) U51.14(2O\E\) U51.15(1O\E\) U52.11(GND) U53.10(VSS) U53.15(A0) U53.16(A1) U53.17(A2) U54.4(GND) U55.4(GND) U55.7(G\) U56.1(E\N\) U56.14(GND) U57.2(1DIR) U57.8(GND1) U57.9(GND2) U57.14(2O\E\) U57.15(1O\E\) U58.4(GND) U59.2(GND) U60.4(PGND) U60.8(GND) U60.11(EPAD) U60.12(VIA1) U60.13(VIA2) U60.14(VIA3) U60.15(VIA4) U60.16(VIA5) U61.4(GND) U62.3 U63.1(1\O\E\) U63.4(GND_1) U63.10(GND_2) U63.15(GND_3) U63.21(GND_4) U63.24(4\O\E\) U63.25(3\O\E\) U63.28(GND_5) U63.34(GND_6) U63.39(GND_7) U63.45(GND_8) U63.48(2\O\E\) U64.1(1\O\E\) U64.4(GND_1) U64.10(GND_2) U64.15(GND_3) U64.21(GND_4) U64.24(4\O\E\) U64.25(3\O\E\) U64.28(GND_5) U64.34(GND_6) U64.39(GND_7) U64.45(GND_8) U64.48(2\O\E\) U65.10(GND) U65.21(E-PAD_1) U65.22(E-PAD_2) U65.23(E-PAD_3) U65.24(E-PAD_4) U65.25(E-PAD_5) U65.26(E-PAD_6) U65.27(E-PAD_7) U67.1(O\E\) U67.3(GND) U68.10(GND) U68.21(E-PAD_1) U68.22(E-PAD_2) U68.23(E-PAD_3) U68.24(E-PAD_4) U68.25(E-PAD_5) U68.26(E-PAD_6) U68.27(E-PAD_7) U69.3 U70.3
GND_3: B8.1 U13.36(AVSS1) U13.47(AVSS2)
GND_SHIELD: CN16.H3(PTH_1) CN16.H4(PTH_2) R613.1
GND_USB1: B4.2 D1.4(GND) FTDI_USB.6(PTH_1) FTDI_USB.7(PTH_2) FTDI_USB.8(PTH_3) FTDI_USB.9(PTH_4)
VBAT: C55.2 CN2.2 OSC1.1(OE) OSC1.4(VCC) U7.55(VBAT)
VBUS: C173.1 C183.1 R799.2 SOC_USB.1(VBUS) U59.1(OUT)
VCC0V75_EN: R164.1 U38.7(EN) U60.7(EN)
VCC0V75_EN_R: R164.2 U13.26(GPIO17)
VCC0V75_PGOOD: R785.1 TP96.1 U60.9(PGOOD)
VCC0V85: B28.1(INPUT) B46.1 B48.2 C196.1 C197.1 C501.1 C503.1 C508.1 C509.1 L7.1 R320.2 R355.2
VCC1V2: C150.1 C158.1 C192.1 C193.1 C198.1 C206.1 C212.1 C213.1 C268.1 C270.1 C274.1 C290.1 C295.1 C297.1 PHY1.C6(DVDD_1) PHY1.C7(DVDD_2) PHY1.D7(DVDD_3) PHY1.E3(DVDD_4) PHY1.E7(DVDD_5) PHY1.F3(DVDD_6) PHY1.J3(DVDD_7) PHY1.J7(DVDD_8) PHY2.C6(DVDD_1) PHY2.C7(DVDD_2) PHY2.D7(DVDD_3) PHY2.E3(DVDD_4) PHY2.E7(DVDD_5) PHY2.F3(DVDD_6) PHY2.J3(DVDD_7) PHY2.J7(DVDD_8) Q7.1(VOUT) R203.2 R280.1 TP38.1
VCC1V2_EN: Q7.5(EN) R163.1 R237.1 R255.2
VCC1V2_EN_R: R163.2 U13.21(GPIO14)
VCC1V2_MON: R203.1 U13.41(MON6)
VCC1V5: C46.1 C47.1 C53.1 C59.1 C65.1 C68.1 C242.1 C250.1 C256.1 C264.1 C266.1 C275.1 C285.1 C289.1 C299.1 C304.1 C305.1 C331.1 C349.2 C364.1 C372.2 C419.1 C430.2 C432.1 C521.1 C525.1 C531.1 C538.1 C543.1 C554.1 C565.1 C567.1 C581.1 C593.1 C602.1 C607.1 C612.1 C618.1 C620.1 C631.1 C638.1 C650.1 C676.1 C678.1 C690.1 C691.1 C692.1 C693.1 C694.1 C695.1 C696.1 C703.1 C704.1 C705.1 C706.1 C707.1 C709.1 C710.1 C712.1 C713.1 C735.1 C736.1 C737.1 C738.1 C739.1 C740.1 C742.1 C743.1 C744.1 C746.1 C747.1 C748.1 C750.1 C751.1 C752.1 C753.2 C755.1 C758.1 C759.1 C763.1 C768.2 C774.1 C777.1 C780.1 C781.1 C782.1 C785.1 C786.1 C788.1 C789.1 C790.1 C832.1 DIMM1.85(VDD1) DIMM1.86(VDD2) DIMM1.93(VDD3) DIMM1.94(VDD4) DIMM1.101(VDD5) DIMM1.102(VDD6) DIMM1.109(VDD7) DIMM1.110(VDD8) DIMM1.115(VDD9) DIMM1.116(VDD10) DIMM1.123(VDD11) DIMM1.124(VDD12) DIMM1.131(VDD13) DIMM1.132(VDD14) L3.1 R65.2 R441.1 R547.1 R757.2 R758.2 R769.1 TP10.1 U24.AA28(DVDD15_01) U24.AA30(DVDD15_02) U24.AB29(DVDD15_03) U24.AB31(DVDD15_04) U24.AC30(DVDD15_05) U24.AD29(DVDD15_06) U24.AD31(DVDD15_07) U24.AE30(DVDD15_08) U24.AF29(DVDD15_09) U24.AF31(DVDD15_10) U24.AG30(DVDD15_11) U24.AH31(DVDD15_12) U24.AJ30(DVDD15_13) U24.AK31(DVDD15_14) U24.AL32(DVDD15_15) U24.H7(DVDD15_23) U24.H9(DVDD15_24) U24.H11(DVDD15_16) U24.H13(DVDD15_17) U24.H15(DVDD15_18) U24.H17(DVDD15_19) U24.H19(DVDD15_20) U24.H21(DVDD15_21) U24.H23(DVDD15_22) U24.J6(DVDD15_32) U24.J8(DVDD15_33) U24.J10(DVDD15_25) U24.J12(DVDD15_26) U24.J14(DVDD15_27) U24.J16(DVDD15_28) U24.J18(DVDD15_29) U24.J20(DVDD15_30) U24.J22(DVDD15_31) U24.K7(DVDD15_41) U24.K9(DVDD15_42) U24.K11(DVDD15_34) U24.K13(DVDD15_35) U24.K15(DVDD15_36) U24.K17(DVDD15_37) U24.K19(DVDD15_38) U24.K21(DVDD15_39) U24.K23(DVDD15_40) U24.L8(DVDD15_50) U24.L10(DVDD15_43) U24.L12(DVDD15_44) U24.L14(DVDD15_45) U24.L16(DVDD15_46) U24.L18(DVDD15_47) U24.L20(DVDD15_48) U24.L32(DVDD15_49) U24.M11(DVDD15_51) U24.M17(DVDD15_52) U24.M19(DVDD15_53) U24.M31(DVDD15_54) U24.P29(DVDD15_55) U24.P31(DVDD15_56) U24.R28(DVDD15_57) U24.R30(DVDD15_58) U24.T29(DVDD15_59) U24.T31(DVDD15_60) U24.U28(DVDD15_61) U24.U30(DVDD15_62) U24.V29(DVDD15_63) U24.V31(DVDD15_64) U24.W28(DVDD15_65) U24.W30(DVDD15_66) U24.Y29(DVDD15_67) U24.Y31(DVDD15_68) U38.2(VLDOIN) U39.A1(VDDQ_1) U39.A8(VDDQ_2) U39.B2(VDD_1) U39.C1(VDDQ_3) U39.C9(VDDQ_4) U39.D2(VDDQ_5) U39.D9(VDD_2) U39.E9(VDDQ_6) U39.F1(VDDQ_7) U39.G7(VDD_3) U39.H2(VDDQ_8) U39.H9(VDDQ_9) U39.K2(VDD_4) U39.K8(VDD_5) U39.N1(VDD_6) U39.N9(VDD_7) U39.R1(VDD_8) U39.R9(VDD_9) U40.A1(VDDQ_1) U40.A8(VDDQ_2) U40.B2(VDD_1) U40.C1(VDDQ_3) U40.C9(VDDQ_4) U40.D2(VDDQ_5) U40.D9(VDD_2) U40.E9(VDDQ_6) U40.F1(VDDQ_7) U40.G7(VDD_3) U40.H2(VDDQ_8) U40.H9(VDDQ_9) U40.K2(VDD_4) U40.K8(VDD_5) U40.N1(VDD_6) U40.N9(VDD_7) U40.R1(VDD_8) U40.R9(VDD_9) U41.A1(VDDQ_1) U41.A8(VDDQ_2) U41.B2(VDD_1) U41.C1(VDDQ_3) U41.C9(VDDQ_4) U41.D2(VDDQ_5) U41.D9(VDD_2) U41.E9(VDDQ_6) U41.F1(VDDQ_7) U41.G7(VDD_3) U41.H2(VDDQ_8) U41.H9(VDDQ_9) U41.K2(VDD_4) U41.K8(VDD_5) U41.N1(VDD_6) U41.N9(VDD_7) U41.R1(VDD_8) U41.R9(VDD_9) U42.A1(VDDQ_1) U42.A8(VDDQ_2) U42.B2(VDD_1) U42.C1(VDDQ_3) U42.C9(VDDQ_4) U42.D2(VDDQ_5) U42.D9(VDD_2) U42.E9(VDDQ_6) U42.F1(VDDQ_7) U42.G7(VDD_3) U42.H2(VDDQ_8) U42.H9(VDDQ_9) U42.K2(VDD_4) U42.K8(VDD_5) U42.N1(VDD_6) U42.N9(VDD_7) U42.R1(VDD_8) U42.R9(VDD_9) U43.A1(VDDQ_1) U43.A8(VDDQ_2) U43.B2(VDD_1) U43.C1(VDDQ_3) U43.C9(VDDQ_4) U43.D2(VDDQ_5) U43.D9(VDD_2) U43.E9(VDDQ_6) U43.F1(VDDQ_7) U43.G7(VDD_3) U43.H2(VDDQ_8) U43.H9(VDDQ_9) U43.K2(VDD_4) U43.K8(VDD_5) U43.N1(VDD_6) U43.N9(VDD_7) U43.R1(VDD_8) U43.R9(VDD_9) U60.2(VLDOIN)
VCC1V8: B16.2 B17.2 B20.2 B32.2 B38.2 B41.2 B43.2 B45.2 C34.2 C205.2 C249.1 C313.1 C321.2 C326.1 C327.1 C328.1 C332.2 C333.1 C335.1 C337.2 C340.2 C341.2 C345.2 C347.2 C350.1 C389.2 C395.1 C396.1 C397.1 C418.1 C421.2 C456.2 C494.2 C495.2 C514.1 C515.1 C516.1 C518.1 C519.1 C528.1 C529.1 C530.1 C535.1 C536.1 C654.1 C665.1 C672.1 C685.1 C687.1 C702.1 C708.1 C711.1 C720.2 C721.1 C727.1 C728.1 C730.2 C732.2 C776.2 C835.2 C836.1 C837.2 C838.1 C841.1 C842.1 C843.2 C844.2 CN3.1 CN3.2 CN21.1 EEPROM1.8(VCC) GPS1.F1(VDD_IO) L9.2 NAND1.D3(VCC2) NAND1.G4(VCC1) NAND1.H8(VCC3) NAND1.J6(VCC4) NOR1.2(VCC) OSC4.1(OE) OSC4.4(VCC) R25.1 R33.1 R36.1 R38.1 R42.1 R48.1 R50.1 R56.2 R61.1 R69.1 R307.1 R319.1 R322.2 R324.1 R326.2 R363.2 R397.2 R404.1 R405.1 R411.2 R412.2 R413.2 R414.2 R415.2 R416.2 R417.2 R418.2 R419.1 R422.1 R425.1 R426.1 R429.1 R471.1 R511.2 R517.1 R519.2 R521.1 R570.1 R572.1 R604.1 R610.1 R670.2 R701.1 R714.2 R733.2 R804.2 TP50.1 U5.2(VCCA) U17.8(VCC) U21.8(VCC) U24.AA6(DVDD18_01) U24.AB5(DVDD18_02) U24.AB7(DVDD18_03) U24.AC6(DVDD18_04) U24.AD7(DVDD18_05) U24.AE6(DVDD18_06) U24.AF7(DVDD18_07) U24.AG6(DVDD18_08) U24.AJ26(DVDD18_09) U24.AK27(DVDD18_10) U24.AL26(DVDD18_11) U24.AL28(DVDD18_12) U24.AM27(DVDD18_13) U24.AM29(DVDD18_14) U24.H25(DVDD18_15) U24.H27(DVDD18_16) U24.J26(DVDD18_17) U24.J28(DVDD18_18) U24.J32(DVDD18_19) U24.K25(DVDD18_20) U24.K27(DVDD18_21) U24.K31(DVDD18_22) U24.L24(DVDD18_23) U24.L26(DVDD18_24) U24.L30(DVDD18_25) U24.M29(DVDD18_26) U24.N30(DVDD18_27) U24.R6(DVDD18_28) U24.T7(DVDD18_29) U24.U6(DVDD18_30) U24.V5(DVDD18_31) U24.V7(DVDD18_32) U24.W6(DVDD18_33) U24.Y5(DVDD18_34) U24.Y7(DVDD18_35) U26.5(VCC) U28.8(VCC) U30.8(VCC) U31.2(VREF1) U32.16(VCCB) U33.3(VCC) U34.1(VCCA) U35.16(VCCB) U36.2(VREF1) U37.16(VCCB) U45.20(VCC) U47.9(VDD) U48.9(VDD) U50.9(VDD) U51.16(VCCB) U52.2(VCCA) U54.1(VCCA) U57.16(VCCB) U58.1(VCCA) U63.7(VCC_1) U63.18(VCC_2) U63.31(VCC_3) U63.42(VCC_4) U64.7(VCC_1) U64.18(VCC_2) U64.31(VCC_3) U64.42(VCC_4) U65.20(VCC) U67.5(VCC) U68.20(VCC) U69.5 U70.5
VCC2V5: B27.2 B30.1 B33.2 B34.1 C148.1 C159.1 C185.1 C188.1 C189.1 C195.1 C204.1 C254.1 C261.1 C262.1 C273.1 C287.1 CN16.A12 CN16.B12 PHY1.B4(VDDO_1) PHY1.B9(VDDOH_1) PHY1.C2(VDDO_2) PHY1.F7(VDDOH_2) PHY1.J8(VDDOH_3) PHY1.K1(VDDO_3) PHY1.K9(VDDOX_1) PHY1.L2(VDDOX_2) PHY2.B4(VDDO_1) PHY2.B9(VDDOH_1) PHY2.C2(VDDO_2) PHY2.F7(VDDOH_2) PHY2.J8(VDDOH_3) PHY2.K1(VDDO_3) PHY2.K9(VDDOX_1) PHY2.L2(VDDOX_2) Q8.1(VOUT) R283.1 R399.2 R400.2 R566.1 R603.2 R645.1 R652.1 R679.2 R728.1 R735.1 TP39.1
VCC2V5_EN: Q8.5(EN) R178.1 R251.2 R585.1
VCC2V5_EN_R: R178.2 U13.18(GPIO13)
VCC2V5_MON: R197.2 R566.2 U13.40(MON5)
VCC3_AUX_EN_R: R250.2 U13.7(GPIO4)
VCC3_AUX_MON: R191.2 R563.2 U13.39(MON4)
VCC3_AUX_PGOOD: R21.1 TP2.1 U2.14(PWRGD)
VCC3_LCD: C409.1 LCD1.12(VDD) Q13.2(CATHODE) R505.1 R512.1
VCC3_LCDBK: LCD1.A(LED+) R509.1
VCC3V3_AUX: B9.1(IN) B10.1(IN) B11.1(IN) B12.1(IN) B13.3(OUT) B14.1(IN) B15.1(IN) B23.1(IN) B25.1(IN) B31.3(OUT) B39.1(IN) B44.1(IN) B47.1(IN) C29.1 C30.1 C31.1 C41.1 C114.1 C126.1 C132.1 C133.1 C136.1 C143.1 C144.1 C164.2 C165.1 C230.1 C282.1 C330.1 C334.2 C355.1 C366.1 C367.1 C393.1 C400.1 C401.2 C402.1 C413.1 C438.1 C442.2 C443.2 C444.2 C445.2 C446.2 C447.2 C448.2 C449.2 C450.2 C454.1 C455.2 C459.2 C460.1 C462.2 C463.2 C464.2 C465.1 C466.2 C467.2 C468.2 C469.2 C470.2 C471.2 C472.2 C473.2 C474.2 C477.2 C478.2 C479.2 C480.2 C481.2 C482.2 C483.2 C485.2 C487.1 C488.2 C489.2 C496.2 C582.1 C688.1 C733.2 C734.2 C769.1 CN3.61 CN3.62 CN3.119 CN3.120 DIMM1.199(VDDSPD) L2.2 L10.2 Q2.1(IN_1) Q2.2(IN_2) Q2.4(BIAS) Q6.4(VDD) Q7.8(VIN) Q8.8(VIN) Q15.4(VDD) Q17.4(VDD) Q21.4(VDD) R11.2 R13.1 R21.2 R34.2 R70.2 R81.2 R82.2 R92.2 R110.2 R111.2 R112.2 R121.2 R214.1 R216.2 R220.1 R228.1 R237.2 R258.1 R270.1 R271.2 R276.1 R290.1 R291.1 R300.1 R302.1 R318.2 R329.2 R330.2 R331.2 R332.2 R334.2 R337.2 R339.2 R340.2 R341.2 R344.2 R359.2 R362.2 R366.2 R377.1 R379.2 R381.2 R386.2 R403.2 R406.2 R407.2 R409.1 R420.2 R421.2 R424.2 R428.2 R438.2 R439.2 R440.2 R446.2 R447.2 R448.2 R449.2 R450.2 R451.2 R452.2 R453.2 R460.2 R492.2 R509.2 R534.2 R557.2 R563.1 R569.2 R571.2 R573.2 R575.2 R584.1 R585.2 R586.1 R650.2 R651.2 R688.2 R750.2 R773.1 R780.1 R785.2 R791.1 R793.1 TP60.1 U5.19(VCCB) U11.5 U14.7(VDD_PRI_REF) U14.10(VDD_SEC_REF) U14.13(VDD_Y0_Y1_1) U14.18(VDD_Y0_Y1_2) U14.19(VDD_Y2_Y3_1) U14.24(VDD_Y2_Y3_2) U14.27(VDD_Y4) U14.30(VDD_Y5) U14.31(VDD_Y6) U14.34(VDD_Y7) U14.48(DVDD) U15.7(VDD_PRI_REF) U15.10(VDD_SEC_REF) U15.13(VDD_Y0_Y1_1) U15.18(VDD_Y0_Y1_2) U15.19(VDD_Y2_Y3_1) U15.24(VDD_Y2_Y3_2) U15.27(VDD_Y4) U15.30(VDD_Y5) U15.31(VDD_Y6) U15.34(VDD_Y7) U15.48(DVDD) U16.7(V33DIO1) U16.44(V33DIO2) U16.45(V33D) U18.15(VCC) U19.7(VDD_PRI_REF) U19.10(VDD_SEC_REF) U19.13(VDD_Y0_Y1_1) U19.18(VDD_Y0_Y1_2) U19.19(VDD_Y2_Y3_1) U19.24(VDD_Y2_Y3_2) U19.27(VDD_Y4) U19.30(VDD_Y5) U19.31(VDD_Y6) U19.34(VDD_Y7) U19.48(DVDD) U25.7(V33DIO1) U25.44(V33DIO2) U25.45(V33D) U32.1(VCCA) U33.5(VBATT) U35.1(VCCA) U37.1(VCCA) U38.10(VIN) U49.1(VDD1) U49.6(VDD2) U49.12(VDD3) U49.19(VDD4) U49.36(VDD5) U53.9(VDD) U55.8(VCC) U57.1(VCCA) U57.3(2DIR) U60.10(VIN) U62.5
VCC3V3_AUX_EN: CN24.2 R24.2 R250.1
VCC3V3_AUX_EN_R: CN24.1 U2.10(EN)
VCC3V3_MP: B7.1 C38.2 C40.2 C45.2 C69.1 C73.1 C180.2 C362.1 C394.2 C398.2 C416.2 C417.2 C424.2 C427.2 C439.2 C441.1 C475.2 C476.1 D9.1(CATHODE) D11.1(CATHODE) R30.2 R40.2 R59.1 R83.2 R84.2 R161.2 R175.1 R176.1 R217.2 R222.2 R232.1 R248.1 R249.1 R297.1 R306.1 R317.1 R495.2 R496.2 R497.2 R498.2 R507.2 R512.2 R518.2 R526.2 R528.1 R531.2 R546.1 R576.1 R577.1 R581.2 R611.1 U4.8(VCC) U6.5(VCC) U7.3(VDDA) U7.8(VDD_1) U7.20(VDD_2) U7.32(VDD_3) U7.44(VDD_4) U7.56(VDD_5) U7.68(VDD_6) U7.81(VDD_7) U7.93(VDD_8) U12.8(VCC) U13.33(V33D) U22.1(VCCA) U51.1(VCCA) U51.2(1DIR) U51.3(2DIR) U52.19(VCCB) U56.15(VCC)
VCC3V3_MP_ALT: C390.1 D11.2(ANODE) Q10.2(VOUT1) Q10.4(VOUT2) R502.1
VCC3V3_MP_ALT_DET: R502.2 R503.1 U7.99(PD6)
VCC3V3_MP_AMC: AMC1.4(MP) D9.2(ANODE) R549.2
VCC3V3_PCIE: B23.3(OUT) C151.1 R292.1 U20.1(VDDIN) U20.10(VDD_1) U20.11(VDD_2)
VCC3V3_U: B5.1 B6.1 C3.1 C15.1 C24.1 C35.2 C36.1 C384.1 C388.1 Q1.1(VOUT) R16.1 R19.1 R477.1 R484.2 U3.20(VCCIO_1) U3.31(VCCIO_2) U3.42(VCCIO_3) U3.50(VREGIN) U3.56(VCCIO_4) U46.8(VCC)
VCC5: C39.1 C399.1 C403.1 CN3.59 CN3.60 L1.2 R7.1 R560.1 R814.2 TP4.1 U59.5(IN)
VCC5_EN: R18.2 R247.1 R479.2
VCC5_EN_R1: R247.2 U13.6(GPIO3)
VCC5_EN_R2: R18.1 U1.10(EN)
VCC5_MON: R173.2 R560.2 U13.38(MON3)
VCC5_PGOOD: R11.1 TP3.1 U1.14(PWRGD)
VCC5_VBUS: C1.1 C7.1 D1.6(VBUS) Q1.8(VIN) R3.2 R26.1
VCC12: AMC1.2(PWR_12V_1) AMC1.9(PWR_12V_2) AMC1.18(PWR_12V_3) AMC1.27(PWR_12V_4) AMC1.42(PWR_12V_5) AMC1.57(PWR_12V_6) AMC1.72(PWR_12V_7) AMC1.84(PWR_12V_8) B1.1 B2.1 B3.1 C2.1 C5.1 C43.2 C44.1 C48.2 C49.1 C306.2 C346.1 C381.2 C383.1 C425.2 C426.1 C504.2 C537.1 C729.1 C731.1 FAN1.2 J1.A1(PWRA1) J1.A2(PWRA2) J1.B1(PWRB1) J1.B2(PWRB2) Q19.5(D1) Q19.6(D2) Q19.7(D3) Q19.8(D4) R85.2 R106.2 R208.1 R375.1 R469.2 TP57.1 U1.6(VIN) U2.6(VIN) U8.21(VIN_1) U8.22(VIN_2) U8.23(VIN_3) U8.24(VIN_4) U8.25(VIN_5) U8.26(VIN_6) U8.27(VDD) U9.27(VIN_3) U9.28(NC-VIN_2) U9.29(VIN_4) U9.30(VIN_1) U9.31(NC-VIN_1) U9.32(VIN_2) U10.21(VIN_1) U10.22(VIN_2) U10.23(VIN_3) U10.24(VIN_4) U10.25(VIN_5) U10.26(VIN_6) U10.27(VDD) U23.27(VIN_3) U23.28(NC-VIN_2) U23.29(VIN_4) U23.30(VIN_1) U23.31(NC-VIN_1) U23.32(VIN_2) U27.13(VIN) U44.21(VIN_1) U44.22(VIN_2) U44.23(VIN_3) U44.24(VIN_4) U44.25(VIN_5) U44.26(VIN_6) U44.27(VDD)
VCC18_U: C12.1 C17.1 C19.1 C37.1 U3.12(VCORE_1) U3.37(VCORE_2) U3.49(VREGOUT) U3.64(VCORE_3)
VCCA0V75: C336.2 C339.2 C343.2 C352.2 C353.2 C357.1 C358.1 C359.1 C741.2 C833.1 DIMM1.203(VTT1) DIMM1.204(VTT2) R226.2 TP58.1 U38.3(VO) U38.5(VOSNS)
VCCA0V75_MON: R226.1 U13.45(MON8)
VCCA0V75_PGOOD: R750.1 TP94.1 U38.9(PGOOD)
VCCA0V75REF: C160.2 C161.2 C247.2 C342.1 C344.2 C592.2 C625.2 DIMM1.1(VREF_DQ) DIMM1.84(VREF_CA) U24.G14(DDR3AVREFSSTL) U38.6(REFOUT)
VCCB0V75: C356.1 C361.1 C374.1 C376.2 C378.1 C379.1 C756.2 C757.2 C761.2 C766.2 C778.2 C784.2 C787.2 C793.1 C794.2 C834.1 R206.2 R444.2 R454.2 R455.2 R457.2 R458.2 R462.2 R463.2 R464.2 R465.2 R466.2 R467.2 R763.2 R765.2 R772.2 R775.2 R779.2 R781.2 R782.2 R786.2 R788.2 R789.2 R790.2 R792.2 R794.2 R795.2 TP97.1 U60.3(VO) U60.5(VOSNS)
VCCB0V75_MON: R206.1 U13.42(MON7)
VCCB0V75REF: C715.2 C754.1 C760.1 C770.1 C771.1 C772.1 C783.1 C792.2 U24.AC31(DDR3BVREFSSTL) U39.H1(VREFDQ) U39.M8(VREFCA) U40.H1(VREFDQ) U40.M8(VREFCA) U41.H1(VREFDQ) U41.M8(VREFCA) U42.H1(VREFDQ) U42.M8(VREFCA) U43.H1(VREFDQ) U43.M8(VREFCA) U60.6(REFOUT)
VCCPLLA1A: B10.3(OUT) C93.1 C94.2 U14.37(VDD_PLL1)
VCCPLLA1B: B12.3(OUT) C106.1 C107.2 U14.38(VDD_PLL2) U14.39(VDD_VCO)
VCCPLLA2A: B9.3(OUT) C88.1 C89.2 U15.37(VDD_PLL1)
VCCPLLA2B: B11.3(OUT) C95.2 C96.1 U15.38(VDD_PLL2) U15.39(VDD_VCO)
VCCPLLA3A: B44.3(OUT) C484.1 C486.2 U19.37(VDD_PLL1)
VCCPLLA3B: B14.3(OUT) C101.2 C102.2 C103.1 U19.38(VDD_PLL2) U19.39(VDD_VCO)
VDD33: B29.1(INPUT) C207.1 C222.1 C223.1 C544.1 C557.1 C560.1 C561.1 L8.1 R328.2 R348.2 U24.AA14(DVDD33)
VDDPLL0: B17.1 C155.1 C156.1 C157.1 C821.1 C822.1 C823.1 U24.M13(AVDDA7) U24.M15(AVDDA8) U24.M18(AVDDA9) U24.M20(AVDDA10) U24.P11(AVDDA6)
VDDPLL1: B20.1 C153.1 C272.1 C825.1 C826.1 U24.AB28(AVDDA12) U24.AC28(AVDDA13) U24.AD28(AVDDA14) U24.AE28(AVDDA15) U24.Y28(AVDDA11)
10M_TESTN: CN4.2(SIG) U15.25(Y4_N)
10M_TESTP: CN23.2(SIG) U15.26(Y4_P)
19.2M_TESTN: CN6.2(SIG) U14.25(Y4_N)
19.2M_TESTP: CN5.2(SIG) U14.26(Y4_P)
25M_MMCX: CN10.2(SIG) R242.2
25M_MMCX_R: R242.1 U15.11(SEC_REFP)
5482S_LAN1_LINK_R: CN16.A11 R350.2
5482S_LAN1_SPEED1_R: CN16.A14 R382.2
5482S_LAN1_SPEED2_R: CN16.A13 R371.2
5482S_LAN2_LINK_R: CN16.B11 R327.2
5482S_LAN2_SPEED1_R: CN16.B14 R335.2
5482S_LAN2_SPEED2_R: CN16.B13 R333.2
5482S_RJ451_VCC: B34.2 C255.1 C263.1 CN16.A5(TCT1_A)
5482S_RJ452_VCC: B30.2 C217.1 C220.1 CN16.B5(TCT1_B)
9090FPWM4: CN7.1 U13.13(FPWM4/GPIO8)
9090FPWM6: CN7.2 U13.15(FPWM6/GPIO10)
9090FPWM7: CN7.3 U13.16(FPWM7/GPIO11)
9090FPWM8: CN7.4 U13.17(FPWM8/GPIO12)
AIF0_RXN_C: C233.1 U24.AW16(AIFRXN0)
AIF0_RXP_C: C235.1 U24.AW17(AIFRXP0)
AIF1_RXN_C: C577.1 U24.AU16(AIFRXN1)
AIF1_RXP_C: C589.1 U24.AU17(AIFRXP1)
AIF2_RXN_C: C590.1 U24.AV15(AIFRXN2)
AIF2_RXP_C: C596.1 U24.AV16(AIFRXP2)
AIF3_RXN_C: C227.1 U24.AW13(AIFRXN3)
AIF3_RXP_C: C229.1 U24.AW14(AIFRXP3)
AIF4_RXN_C: C568.1 U24.AU13(AIFRXN4)
AIF4_RXP_C: C579.1 U24.AU14(AIFRXP4)
AIF5_RXN_C: C219.1 U24.AV12(AIFRXN5)
AIF5_RXP_C: C224.1 U24.AV13(AIFRXP5)
ALT_CORE_CLKN: C175.1 U19.22(Y3_N)
ALT_CORE_CLKP: C174.1 U19.23(Y3_P)
ALTCORECLKN_C: C175.2 U24.AL2(ALTCORECLKN)
ALTCORECLKP_C: C174.2 U24.AM2(ALTCORECLKP)
AMC0_SGMII2_RX_DN: AMC1.15(RX0-) C277.1
AMC0_SGMII2_RX_DN_C: C277.2 U24.AU25(SGMII2RXN)
AMC0_SGMII2_RX_DP: AMC1.14(RX0+) C288.1
AMC0_SGMII2_RX_DP_C: C288.2 U24.AU26(SGMII2RXP)
AMC0_SGMII2_TX_DN: AMC1.12(TX0-) U24.AR26(SGMII2TXN)
AMC0_SGMII2_TX_DP: AMC1.11(TX0+) U24.AR27(SGMII2TXP)
AMC1_SGMII3_RX_DN: AMC1.24(RX1-) C267.1
AMC1_SGMII3_RX_DN_C: C267.2 U24.AW25(SGMII3RXN)
AMC1_SGMII3_RX_DP: AMC1.23(RX1+) C276.1
AMC1_SGMII3_RX_DP_C: C276.2 U24.AW26(SGMII3RXP)
AMC1_SGMII3_TX_DN: AMC1.21(TX1-) U24.AP25(SGMII3TXN)
AMC1_SGMII3_TX_DP: AMC1.20(TX1+) U24.AP26(SGMII3TXP)
AMC_JTAG_RST#: AMC1.167(T\R\S\T\) R787.2 U5.17(B3)
AMC_JTAG_TCK: AMC1.165(TCK) R773.2 U5.16(B4)
AMC_JTAG_TDI: AMC1.169(TDI) R793.2 U5.20(B1)
AMC_JTAG_TDO: AMC1.168(TDO) R791.2 U5.15(B5)
AMC_JTAG_TMS: AMC1.166(TMS) R780.2 U5.18(B2)
AMC_RP1CLKN: AMC1.162(TX20-) C499.1
AMC_RP1CLKP: AMC1.163(TX20+) C500.1
AMC_RP1FBN: AMC1.156(TX19-) C184.1
AMC_RP1FBP: AMC1.157(TX19+) C170.1
AMC_TIMO0: R742.2 U30.1(A)
AMCC_P4_PCIE_RX1N: AMC1.48(RX4-) U24.AU31(PCIERXN0)
AMCC_P4_PCIE_RX1P: AMC1.47(RX4+) U24.AU32(PCIERXP0)
AMCC_P4_PCIE_TX1N: AMC1.45(TX4-) C308.1
AMCC_P4_PCIE_TX1N_C: C308.2 U24.AT30(PCIETXN0)
AMCC_P4_PCIE_TX1P: AMC1.44(TX4+) C311.1
AMCC_P4_PCIE_TX1P_C: C311.2 U24.AT31(PCIETXP0)
AMCC_P5_PCIE_RX2N: AMC1.54(RX5-) U24.AV30(PCIERXN1)
AMCC_P5_PCIE_RX2P: AMC1.53(RX5+) U24.AV31(PCIERXP1)
AMCC_P5_PCIE_TX2N: AMC1.51(TX5-) C291.1
AMCC_P5_PCIE_TX2N_C: C291.2 U24.AR29(PCIETXN1)
AMCC_P5_PCIE_TX2P: AMC1.50(TX5+) C300.1
AMCC_P5_PCIE_TX2P_C: C300.2 U24.AR30(PCIETXP1)
AMCC_P8_SRIO1_RXN: AMC1.87(RX8-) C258.1
AMCC_P8_SRIO1_RXN_C: C258.2 U24.AV24(RIORXN0)
AMCC_P8_SRIO1_RXP: AMC1.88(RX8+) C265.1
AMCC_P8_SRIO1_RXP_C: C265.2 U24.AV25(RIORXP0)
AMCC_P8_SRIO1_TXN: AMC1.90(TX8-) U24.AT24(RIOTXN0)
AMCC_P8_SRIO1_TXP: AMC1.91(TX8+) U24.AT25(RIOTXP0)
AMCC_P9_SRIO2_RXN: AMC1.93(RX9-) C253.1
AMCC_P9_SRIO2_RXN_C: C253.2 U24.AU22(RIORXN1)
AMCC_P9_SRIO2_RXP: AMC1.94(RX9+) C257.1
AMCC_P9_SRIO2_RXP_C: C257.2 U24.AU23(RIORXP1)
AMCC_P9_SRIO2_TXN: AMC1.96(TX9-) U24.AR23(RIOTXN1)
AMCC_P9_SRIO2_TXP: AMC1.97(TX9+) U24.AR24(RIOTXP1)
AMCC_P10_SRIO3_RXN: AMC1.99(RX10-) C245.1
AMCC_P10_SRIO3_RXN_C: C245.2 U24.AW22(RIORXN2)
AMCC_P10_SRIO3_RXP: AMC1.100(RX10+) C248.1
AMCC_P10_SRIO3_RXP_C: C248.2 U24.AW23(RIORXP2)
AMCC_P10_SRIO3_TXN: AMC1.102(TX10-) U24.AP22(RIOTXN2)
AMCC_P10_SRIO3_TXP: AMC1.103(TX10+) U24.AP23(RIOTXP2)
AMCC_P11_SRIO4_RXN: AMC1.105(RX11-) C240.1
AMCC_P11_SRIO4_RXN_C: C240.2 U24.AV21(RIORXN3)
AMCC_P11_SRIO4_RXP: AMC1.106(RX11+) C243.1
AMCC_P11_SRIO4_RXP_C: C243.2 U24.AV22(RIORXP3)
AMCC_P11_SRIO4_TXN: AMC1.108(TX11-) U24.AT21(RIOTXN3)
AMCC_P11_SRIO4_TXP: AMC1.109(TX11+) U24.AT22(RIOTXP3)
AMCC_P17_AIF4_RXN: AMC1.141(RX17-) C568.2
AMCC_P17_AIF4_RXP: AMC1.142(RX17+) C579.2
AMCC_P17_AIF4_TXN: AMC1.144(TX17-) U24.AR13(AIFTXN4)
AMCC_P17_AIF4_TXP: AMC1.145(TX17+) U24.AR14(AIFTXP4)
AMCC_P18_AIF5_RXN: AMC1.147(RX18-) C219.2
AMCC_P18_AIF5_RXP: AMC1.148(RX18+) C224.2
AMCC_P18_AIF5_TXN: AMC1.150(TX18-) U24.AT12(AIFTXN5)
AMCC_P18_AIF5_TXP: AMC1.151(TX18+) U24.AT13(AIFTXP5)
ARM0_VCL_R: CN19.3 U24.AT37(VCLT)
ARM0_VD_R: CN19.4 U24.AT35(VDT)
ARM_CLKN: C725.1 U19.21(Y2_N)
ARM_CLKP: C726.1 U19.20(Y2_P)
ARM_UCD9244_VID2A: R446.1 U16.20(VID2A) U35.4(1A1)
ARM_UCD9244_VID2B: R447.1 U16.22(VID2B) U35.5(1A2)
ARM_UCD9244_VID2C: R448.1 U16.29(VID2C) U35.6(2A1)
ARM_UCD9244_VID2S: R449.1 U16.14(VID2S) U35.7(2A2)
ARM_VIDA: R411.1 U24.AU37(VCNTL2T) U35.13(1B1)
ARM_VIDB: R412.1 U24.AV36(VCNTL3T) U35.12(1B2)
ARM_VIDC: R413.1 U24.AU35(VCNTL4T) U35.11(2B1)
ARM_VIDS: R414.1 U24.AW36(VCNTL5T) U35.10(2B2)
ARMCLKN_C: C725.2 U24.B37(ARMCLKN)
ARMCLKP_C: C726.2 U24.C37(ARMCLKP)
AT_CLKN: C177.2 U14.16(Y1_N)
AT_CLKN_C: C177.1 U24.AL1(TSREFCLKN)
AT_CLKP: C176.2 U14.17(Y1_P)
AT_CLKP_C: C176.1 U24.AM1(TSREFCLKP)
AVID_OEZ: R263.1 R406.1 U35.14(2O\E\) U35.15(1O\E\)
BD_ID0: CN3.104 U50.4(GPB3)
BD_ID1: CN3.106 U50.5(GPB4)
BD_ID2: CN3.108 U50.6(GPB5)
BD_PRESENT: CN3.102 U50.3(GPB2)
BPCAP: C85.1 C86.2 U13.35(BPCAP)
BSC_JTAG_SRSTN: R52.1 R513.1
BSC_JTAG_TCK: C828.1 R491.1 U4.2
BSC_JTAG_TDI: R45.1 R506.1
